# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAN_SMBCLK_R: length 2.2
  TOP w0.102: R551.2 287.98,86.07 288.05,85.99 v2(288.05,85.68) 288.05,85.4 287.91,85.26 U31.28
LAN_SMBDATA: length 216.2
  TOP w0.102: v1(295.2,67.15) 295.42,67.37 295.42,68.86 RH306.2 295.39,69.75 295.39,70.31 v1(295.17,70.53) ; R552.1 v1(286.2,88.21)
  IN3 w0.122: v1(295.2,67.15) 295.4,66.96 295.4,66.42 295.1,66.12 290.17,66.12 289.22,65.16 289.22,63.52 289.03,63.33 289.03,56.04 289.26,55.8 289.26,50.57 290.22,49.61 292.71,49.61 293.45,48.87 293.45,46.63 289.04,42.22 289.04,36.06 288.21,35.23 288.21,28.02 288.62,27.62 289.15,27.62 v3(289.32,27.44) ; v1(286.2,88.21) 286.22,88.21 286.95,87.47 286.95,86.86 288.28,85.54 288.28,85 289.74,83.54 289.74,79.37 288.25,77.88 288.25,75.67 290.15,73.78 291.77,73.78 293.27,72.28 294.16,72.28 295.36,71.08 295.36,70.73 v1(295.17,70.53)
  IN4 w0.084: v1(167.34,24.46) 166.93,24.04 166.93,21.72 167.63,21.01 167.77,21.01 168.1,20.67 168.1,20.19 168.84,19.46 173.62,19.46 174.65,18.42 176.94,18.42 177.38,17.99 180.7,17.99 181,18.29 183.92,18.29 184.86,19.24 185.35,19.24 v1(185.58,19.01) 185.74,19.17 187,19.17 187.71,19.88 191.36,19.88 194.01,22.53 230.5,22.53 233.4,25.43 261.95,25.43 262.7,24.68 267.05,24.68 269.28,26.92 269.28,28.36 271.13,30.21 273.19,30.21 275.23,28.17 282.16,28.17 282.46,28.48 287.83,28.48 288.69,27.61 289.15,27.61 289.17,27.59 289.17,27.59 v3(289.32,27.44)
  BOTTOM w0.102: v1(167.34,24.46) 167.68,24.12 UH4.G12
LAN_SMBDATA_R: length 2.4
  TOP w0.102: R552.2 286.2,86.12 v2(286.66,85.66) 286.71,85.61 U31.31
LAN_TEST_EN: length 4.4
  TOP w0.102: U31.30 287.11,85.12 287.09,85.14 R561.1 287.52,87.09 287.52,88.55 v2(287.64,88.67)
LAN_TX0+: length 20.7
  TOP w0.089: L124.1 298,86.55 297.91,86.46 297.46,86.46 v3(297.15,86.77) ; v1(290.1,78.71) 290.1,78.65 290.3,78.45 290.45,78.45 290.54,78.54 290.54,79.13 290.34,79.33 U31.13
  BOTTOM w0.089: v1(290.1,78.71) 290.26,78.55 290.41,78.55 290.57,78.7 290.57,79.56 289.96,80.17 289.96,85.42 290.43,85.89 290.43,87.29 290.89,87.75 294.68,87.75 295.85,86.59 296.96,86.59 v3(297.15,86.77)
LAN_TX0+_L: length 1.4
  TOP w0.089: L124.2 299.28,87.03 299.7,86.61 299.92,86.61 R1735.1
LAN_TX0+_R: length 4.3
  TOP w0.089: R1735.2 301.44,86.59 301.68,86.59 C1326.1 302.72,86.13 v1(302.72,85.85)
  BOTTOM w0.089: TR1.12 303.51,86.17 303.03,85.69 302.88,85.69 v1(302.72,85.85)
LAN_TX0-: length 21
  TOP w0.089: v1(297.15,86.14) 297.56,86.14 L125.1 ; U31.14 290.39,79.73 290.86,79.26 290.86,78.41 290.58,78.13 290.16,78.13 v3(290.1,78.07)
  BOTTOM w0.089: v1(297.15,86.14) 297.02,86.27 295.72,86.27 294.55,87.44 291.03,87.44 290.75,87.16 290.75,85.76 290.28,85.29 290.28,80.3 290.89,79.69 290.89,78.57 290.54,78.23 290.26,78.23 v3(290.1,78.07)
LAN_TX0-_L: length 1.5
  TOP w0.089: R1736.1 299.87,86.29 299.62,86.29 299.27,85.94 L125.2
LAN_TX0-_R: length 4.1
  TOP w0.089: R1736.2 301.44,86.27 301.67,86.27 C1326.2 302.05,85.89 302.05,85.88 v3(302.72,85.21)
  BOTTOM w0.089: v3(302.72,85.21) 302.88,85.37 303.01,85.37 303.49,84.9 TR1.11
LAN_TX1+: length 10.2
  TOP w0.089: v3(297.15,83.79) 297.3,83.63 297.42,83.63 L126.1 ; v1(292.23,80.57) 292.23,80.73 292.06,80.9 290.46,80.9 290.43,80.93 U31.17
  BOTTOM w0.089: v1(292.23,80.57) 292.38,80.73 292.38,81.05 292.9,81.57 294.7,81.57 296.74,83.6 296.95,83.6 v3(297.15,83.79)
LAN_TX1+_L: length 1.6
  TOP w0.089: L126.2 299.27,84.01 299.65,83.63 300.01,83.63 R1737.1
LAN_TX1+_R: length 6.8
  TOP w0.089: v3(302.61,80.7) 302.43,80.53 302.37,80.53 301.86,81.04 301.86,81.49 C1327.1 301.85,82.12 301.85,82.29 302.09,82.53 302.09,83.36 301.8,83.65 301.56,83.65 R1737.2
  BOTTOM w0.089: v3(302.61,80.7) 302.76,80.55 302.93,80.55 303.46,81.09 TR1.8
LAN_TX1-: length 10.3
  TOP w0.089: v3(292.87,80.57) 292.83,80.57 292.19,81.21 290.59,81.21 290.48,81.33 U31.18 ; v1(297.15,83.16) 297.3,83.32 297.42,83.32 L127.1
  BOTTOM w0.089: v1(297.15,83.16) 297.02,83.28 296.87,83.28 294.84,81.25 293.03,81.25 292.71,80.93 292.71,80.73 v3(292.87,80.57)
LAN_TX1-_L: length 1.5
  TOP w0.089: L127.2 299.27,82.93 299.66,83.32 300.04,83.32 R1738.1
LAN_TX1-_R: length 6.8
  TOP w0.089: R1738.2 301.56,83.33 301.67,83.33 301.77,83.23 301.77,82.66 301.53,82.42 301.53,82.08 C1327.2 301.54,81.51 301.54,80.91 302.24,80.21 302.47,80.21 v3(302.61,80.07)
  BOTTOM w0.089: v3(302.61,80.07) 302.77,80.24 303.04,80.24 303.46,79.82 TR1.7
LAN_TX2+: length 12.5
  TOP w0.089: v1(292.28,81.97) 292.27,81.97 291.95,82.29 291.42,82.29 291.26,82.13 U31.20 ; L128.1 297.52,80.24 297.43,80.15 296.73,80.15 296.63,80.24 v3(296.63,80.36)
  BOTTOM w0.089: v3(296.63,80.36) 296.63,80.33 296.35,80.05 296.05,80.05 295.85,79.84 292.07,79.84 291.5,80.42 291.5,81.82 291.92,82.24 292.06,82.24 292.28,82.03 v1(292.28,81.97)
LAN_TX2+_L: length 1.5
  TOP w0.089: R1739.1 299.43,80.4 299.11,80.4 299.1,80.4 298.8,80.69 L128.2
LAN_TX2+_R: length 5.9
  TOP w0.089: R1739.2 300.7,80.68 301.05,80.34 301.25,80.34 301.52,80.06 301.52,79.25 C1328.1 301.82,78.67 302.23,78.25 v1(302.42,78.25)
  BOTTOM w0.089: TR1.6 303.3,78.55 303.08,78.32 303.08,78.16 302.86,77.94 302.73,77.94 v1(302.42,78.25)
LAN_TX2-: length 12.5
  TOP w0.089: L129.1 297.52,79.42 297.11,79.83 296.73,79.83 v1(296.63,79.73) ; v3(292.28,82.61) 291.29,82.61 291.12,82.45 290.52,82.45 290.43,82.53 U31.21
  BOTTOM w0.089: v1(296.63,79.73) 296.18,79.73 295.98,79.52 291.94,79.52 291.18,80.29 291.18,81.95 291.79,82.56 292.23,82.56 v3(292.28,82.61)
LAN_TX2-_L: length 1.5
  TOP w0.089: L129.2 298.8,79.65 299.24,80.08 299.54,80.08 R1740.1
LAN_TX2-_R: length 5.9
  TOP w0.089: v3(302.42,77.62) 302.11,77.94 302.1,77.94 301.66,78.38 301.48,78.38 C1328.2 301.21,79.25 301.21,79.93 301.12,80.02 300.89,80.02 R1740.2
  BOTTOM w0.089: TR1.5 303.46,77.28 303.11,77.63 302.43,77.63 v3(302.42,77.62)
LAN_TX3+: length 19.4
  TOP w0.089: v3(296.77,77.5) 296.93,77.34 297.41,77.34 297.52,77.45 L130.1 ; v1(290.91,84.67) 290.91,84.78 290.8,84.9 290.64,84.9 290.48,84.73 290.48,84.4 290.73,84.15 290.73,83.63 290.52,83.41 290.42,83.41 290.34,83.33 U31.23
  BOTTOM w0.089: v1(290.91,84.67) 291.07,84.83 295.04,84.83 295.52,84.35 297.64,84.35 298,83.99 298,77.69 297.66,77.35 296.92,77.35 v3(296.77,77.5)
LAN_TX3+_L: length 1.4
  TOP w0.089: R1741.1 299.42,77.34 299.21,77.34 298.8,77.76 L130.2
LAN_TX3+_R: length 8.5
  TOP w0.089: R1741.2 300.98,77.33 301.22,77.33 C1329.1 302.04,77.11 302.04,73.2 302.24,73 302.41,73 v3(302.56,73.15)
  BOTTOM w0.089: TR1.2 303.36,73.47 302.88,72.99 302.72,72.99 v3(302.56,73.15)
LAN_TX3-: length 20.1
  TOP w0.089: L131.1 297.52,76.55 297.05,77.02 296.93,77.02 v1(296.77,76.86) ; v3(290.91,85.31) 290.82,85.21 290.51,85.21 290.16,84.87 290.16,84.27 290.42,84.02 290.42,83.76 290.39,83.73 U31.24
  BOTTOM w0.089: v3(290.91,85.31) 291.07,85.15 295.17,85.15 295.65,84.67 297.77,84.67 298.32,84.12 298.32,77.56 297.8,77.04 296.94,77.04 v1(296.77,76.86)
LAN_TX3-_L: length 1.4
  TOP w0.089: R1742.1 299.43,77.03 299.2,77.03 298.8,76.62 L131.2
LAN_TX3-_R: length 8
  TOP w0.089: v1(302.56,72.51) 302.4,72.68 302.11,72.68 301.72,73.07 v1(301.72,75.08) 301.72,76.51 C1329.2 301.22,77.02 300.95,77.02 R1742.2
  BOTTOM w0.089: TR1.1 303.35,72.2 302.87,72.67 302.72,72.67 v1(302.56,72.51)
LANCLK_REQ#: length 189.2
  TOP w0.102: R1187.1 v1(283.29,78.53) ; v1(282.82,27.82) v2(282.82,27.12)
  IN2 w0.122: v1(165.66,17.02) 165.86,16.82 167.21,16.82 167.69,16.34 169.21,16.34 174.44,11.12 181.33,11.12 182.52,9.93 187.37,9.93 190.48,13.04 197.38,13.04 198,13.66 203.45,13.66 204.78,12.33 211.06,12.33 213.44,14.72 217.88,14.72 222.11,18.95 240.49,18.95 246.18,24.65 259.63,24.65 260.71,25.73 265.27,25.73 266.07,24.93 272.64,24.93 275.01,27.3 282.3,27.3 v1(282.82,27.82)
  IN3 w0.122: v1(282.82,27.82) 281.99,27.82 281.17,28.64 281.17,29.05 280.75,29.47 280.75,31.92 281.34,32.51 281.34,39.4 279.49,41.25 279.49,41.88 279.07,42.3 279.07,44.36 278.24,45.19 278.24,47.86 279.03,48.65 279.03,56.18 279.74,56.88 279.74,64.44 278.55,65.62 278.55,71.82 283.29,76.55 v1(283.29,78.53)
  BOTTOM w0.102: UH4.M1 165.15,17.53 v1(165.66,17.02)
LANCLK_REQ#_R: length 4.5
  TOP w0.102: R1187.2 281.63,77.68 R547.2 ; R1187.2 282.42,79.33 U31.48 ; R1187.2 v2(280.62,78.53)
LAT_ON_SW#: length 12.3
  TOP w0.102: v2(289.65,46.14) 289.35,46.44 289.35,47.33 R870.1 287.92,48.76 v1(287.79,48.76) ; v1(289.98,55.1) 289.51,54.63 U51.B63
  IN1 w0.084: v1(289.98,55.1) 289.41,54.53 289.41,50.39 v1(287.79,48.76)
LCD_A0+_PCH: length 139.7
  IN1 w0.091: v3(103.04,102.7) 103.24,102.5 108.6,102.5 108.86,102.24 120.2,102.24 120.42,102.02 120.42,101.79 120.54,101.66 120.75,101.66 120.87,101.79 120.87,102.02 121.09,102.24 121.54,102.24 121.76,102.02 121.76,101.53 121.85,101.44 122.12,101.44 122.21,101.53 122.21,102.02 122.43,102.24 122.88,102.24 123.1,102.02 123.1,101.53 123.19,101.44 123.46,101.44 123.56,101.53 123.56,102.02 123.77,102.24 124.22,102.24 124.44,102.02 124.44,101.53 124.53,101.44 124.81,101.44 124.9,101.53 124.9,102.02 125.11,102.24 125.56,102.24 125.78,102.02 125.78,101.53 125.87,101.44 126.15,101.44 126.24,101.53 126.24,101.99 126.49,102.24 126.93,102.24 127.18,101.99 127.18,101.56 127.31,101.44 127.72,101.44 127.85,101.56 127.85,102.5 128.19,102.84 134.37,102.84 135.67,101.55 136.72,101.55 138.36,99.9 145.61,99.9 145.93,99.59 152.67,99.59 159.02,93.24 159.02,90.36 160.55,88.82 160.55,73.56 162.83,71.28 162.83,62.9 163.42,62.31 163.42,57.48 164.22,56.69 164.22,51.91 163.89,51.59 160.83,51.59 160.13,50.89 160.13,48.96 159.31,48.14 156.57,48.14 153.22,44.79 153.22,43.04 153.29,42.96 153.59,42.96 v1(153.78,43.16)
  BOTTOM w0.102: UH4.AN47 154.93,41.23 154.93,41.51 155.05,41.64 155.05,42.04 154.94,42.15 154.94,42.61 154.39,43.16 v1(153.78,43.16) ; JLVDS1.15 104.1,108.46 104.16,108.4 104.26,108.4 104.33,108.33 104.33,106.07 103.65,105.39 103.65,102.54 103.51,102.4 103.35,102.4 103.25,102.5 103.13,102.5 103.04,102.58 v3(103.04,102.7)
LCD_A0-_PCH: length 139.7
  IN1 w0.091: v3(153.78,42.52) 153.56,42.75 153.2,42.75 153.01,42.95 153.01,44.88 156.48,48.36 159.22,48.36 159.91,49.05 159.91,50.97 160.74,51.8 163.8,51.8 164,52 164,56.6 163.21,57.39 163.21,62.22 162.62,62.81 162.62,71.19 160.34,73.47 160.34,88.73 158.8,90.27 158.8,93.15 152.58,99.37 145.84,99.37 145.53,99.69 138.27,99.69 136.63,101.33 135.58,101.33 134.28,102.63 128.28,102.63 128.06,102.41 128.06,101.48 127.81,101.22 127.22,101.22 126.97,101.48 126.97,101.9 126.84,102.02 126.58,102.02 126.45,101.9 126.45,101.44 126.23,101.22 125.78,101.22 125.57,101.44 125.57,101.93 125.48,102.02 125.2,102.02 125.11,101.93 125.11,101.44 124.89,101.22 124.44,101.22 124.23,101.44 124.23,101.93 124.13,102.02 123.86,102.02 123.77,101.93 123.77,101.44 123.55,101.22 123.1,101.22 122.88,101.44 122.88,101.93 122.79,102.02 122.52,102.02 122.43,101.93 122.43,101.44 122.21,101.22 121.76,101.22 121.54,101.44 121.54,101.93 121.45,102.02 121.18,102.02 121.09,101.93 121.09,101.7 120.83,101.45 120.45,101.45 120.2,101.7 120.2,101.93 120.11,102.02 108.78,102.02 108.51,102.29 103.27,102.29 v1(103.04,102.07)
  BOTTOM w0.102: UH4.AN48 154.79,41.79 154.79,41.68 154.64,41.53 154.55,41.53 154.41,41.67 154.4,41.67 154.27,41.8 154.27,41.92 154.33,41.98 154.46,41.98 154.67,42.19 154.67,42.5 154.29,42.88 154.15,42.88 v3(153.78,42.52) ; JLVDS1.14 104.6,105.96 103.92,105.27 103.92,102.42 103.62,102.13 103.11,102.13 v1(103.04,102.07)
LCD_A1+_PCH: length 139.5
  IN1 w0.091: v1(155.46,43.84) 155.46,43.73 155.34,43.61 155.19,43.61 155.03,43.77 155.03,44.66 157.11,46.74 166.32,46.74 166.58,46.99 166.58,51.94 165.59,52.93 165.59,59.14 164.79,59.94 164.79,61.26 165.18,61.65 165.18,65.63 164.2,66.61 164.2,71.85 161.93,74.13 161.93,89.39 161.2,90.11 161.2,93.09 153.33,100.96 146.5,100.96 146.12,101.34 138.96,101.34 137.38,102.92 136.24,102.92 134.94,104.21 127.52,104.21 126.91,103.61 122.59,103.61 122.5,103.7 122.5,104.19 122.25,104.44 121.87,104.44 121.62,104.19 121.62,103.7 121.52,103.61 121.25,103.61 121.16,103.7 121.16,104.12 120.91,104.38 120.53,104.38 120.27,104.12 120.27,103.7 120.18,103.61 109.43,103.61 108.75,104.29 102.17,104.29 v3(101.98,104.48)
  BOTTOM w0.102: UH4.AM49 155.15,42.37 155.15,42.87 155.05,42.97 155.05,43.79 155.1,43.84 v1(155.46,43.84) ; JLVDS1.18 102.6,108.45 102.66,108.39 102.79,108.39 102.83,108.34 102.83,106.69 102.73,106.59 102.02,106.59 101.73,106.31 101.73,105.83 102.02,105.55 102.73,105.55 102.83,105.45 102.83,104.35 102.6,104.12 102.34,104.12 v3(101.98,104.48)
LCD_A1-_PCH: length 139.5
  IN1 w0.091: v1(101.98,103.85) 102.2,104.07 108.67,104.07 109.34,103.4 120.27,103.4 120.49,103.61 120.49,104.04 120.61,104.16 120.82,104.16 120.94,104.04 120.94,103.61 121.16,103.4 121.61,103.4 121.83,103.61 121.83,104.1 121.96,104.23 122.16,104.23 122.29,104.1 122.29,103.61 122.5,103.4 127,103.4 127.61,104 134.85,104 136.15,102.7 137.29,102.7 138.87,101.12 146.03,101.12 146.41,100.74 153.24,100.74 160.99,93 160.99,90.02 161.71,89.3 161.71,74.04 163.99,71.76 163.99,66.52 164.97,65.54 164.97,61.74 164.58,61.35 164.58,59.85 165.37,59.05 165.37,52.84 166.37,51.85 166.37,47.08 166.24,46.95 157.02,46.95 154.82,44.75 154.82,43.68 155.1,43.4 155.27,43.4 v3(155.46,43.2)
  BOTTOM w0.102: UH4.AM47 155.33,41.47 155.33,41.85 155.55,42.07 155.55,42.42 155.42,42.55 155.42,43.16 v3(155.46,43.2) ; v1(101.98,103.85) 102.72,103.85 103.1,104.23 103.1,105.56 102.84,105.81 102.13,105.81 102,105.94 102,106.2 102.13,106.32 102.84,106.32 103.1,106.58 JLVDS1.17
LCD_A2+_PCH: length 139.7
  IN1 w0.091: v3(100.64,103.44) 100.59,103.38 100.59,103.21 100.7,103.1 100.82,103.1 101.03,102.89 101.95,102.89 102.5,103.44 108.64,103.44 109.15,102.92 127.27,102.92 127.87,103.53 134.66,103.53 135.95,102.23 137,102.23 138.58,100.65 145.84,100.65 146.21,100.27 152.95,100.27 159.73,93.5 159.73,90.61 161.24,89.1 161.24,73.84 163.52,71.56 163.52,63.18 164.11,62.59 164.11,57.77 164.9,56.97 164.9,47.87 164.49,47.46 156.86,47.46 154.35,44.94 154.35,43.44 155.47,42.32 156.43,42.32 156.69,42.58 156.69,43.03 156.56,43.15 156.46,43.15 156.37,43.06 156.19,43.06 156.13,43 v1(156.13,42.82)
  BOTTOM w0.102: UH4.AK49 156.29,42.22 156.29,42.14 156.13,41.97 156.04,41.97 155.8,42.21 155.8,42.29 155.87,42.36 155.87,42.45 155.63,42.69 155.63,42.8 155.87,43.04 156.03,43.04 156.13,42.94 v1(156.13,42.82) ; JLVDS1.21 101.1,108.34 101.15,108.29 101.26,108.29 101.33,108.22 101.33,107.34 100.93,106.94 100.93,104.82 101.22,104.54 101.22,103.46 101.34,103.34 101.34,103.1 101.18,102.94 101.07,102.94 100.88,103.13 100.7,103.13 100.64,103.2 v3(100.64,103.44)
LCD_A2-_PCH: length 139.8
  IN1 w0.091: v1(100.64,102.68) 102.04,102.68 102.59,103.22 108.55,103.22 109.06,102.71 127.36,102.71 127.96,103.31 134.57,103.31 135.86,102.02 136.91,102.02 138.49,100.44 145.75,100.44 146.13,100.06 152.86,100.06 159.51,93.41 159.51,90.53 161.03,89.01 161.03,73.75 163.3,71.48 163.3,63.09 163.89,62.5 163.89,57.68 164.69,56.88 164.69,47.96 164.4,47.67 156.77,47.67 154.14,45.03 154.14,43.35 155.38,42.11 156.52,42.11 156.9,42.49 156.9,43.11 156.65,43.37 156.22,43.37 v1(156.13,43.46)
  BOTTOM w0.102: UH4.AK47 156.43,41.58 156.43,41.96 156.54,42.07 156.54,43.04 v1(156.13,43.46) ; v1(100.64,102.68) 101.29,102.68 101.61,102.99 101.61,103.45 101.48,103.57 101.48,104.65 101.2,104.93 101.2,106.83 101.6,107.23 JLVDS1.20
LCD_ACLK+_PCH: length 139.5
  IN1 w0.091: v3(155.75,38.47) 155.52,38.24 155.17,38.24 154.44,38.97 154.44,39.96 153.82,40.57 153.7,40.57 151.6,42.67 151.6,43.06 151.22,43.44 151.22,44.95 151.95,45.68 152.15,45.68 156.13,49.66 158.06,49.66 158.76,50.35 158.76,53.7 160.94,55.88 160.94,71.23 158.76,73.41 158.76,77.9 159.18,78.32 159.18,88.25 157.62,89.81 157.62,91.65 152.62,96.65 150.08,96.65 149.05,97.68 140.61,97.68 140.16,98.13 134.34,98.13 132.29,100.18 129.97,100.18 129.4,100.75 119.91,100.75 119.82,100.84 119.82,101.03 119.57,101.28 119.19,101.28 118.94,101.03 118.94,100.84 118.85,100.75 118.39,100.75 118.3,100.84 118.3,101.32 118.1,101.52 117.61,101.52 117.41,101.32 117.41,100.84 117.32,100.75 117.05,100.75 116.96,100.84 116.96,101.25 116.74,101.47 116.29,101.47 116.07,101.25 116.07,100.84 115.98,100.75 115.71,100.75 115.62,100.84 115.62,101.25 115.4,101.47 114.95,101.47 114.73,101.25 114.73,100.84 114.64,100.75 114.36,100.75 114.27,100.84 114.27,101.34 114.05,101.55 113.6,101.55 113.39,101.34 113.39,100.84 113.3,100.75 101.99,100.75 101.23,101.52 100.5,101.52 99.83,102.18 99.48,102.18 v1(99.24,102.41)
  BOTTOM w0.102: UH4.AK40 156.06,38.16 v3(155.75,38.47) ; v1(99.24,102.41) 99.61,102.05 99.71,102.05 99.83,102.17 99.83,108.34 99.78,108.39 99.66,108.39 99.6,108.45 JLVDS1.24
LCD_ACLK-_PCH: length 139.6
  IN1 w0.091: v1(155.72,37.84) 155.53,38.03 155.08,38.03 154.22,38.88 154.22,39.87 153.74,40.36 153.61,40.36 151.39,42.58 151.39,42.97 151.01,43.35 151.01,45.04 151.87,45.89 152.06,45.89 156.04,49.87 157.97,49.87 158.54,50.44 158.54,53.78 160.73,55.97 160.73,71.14 158.55,73.32 158.55,77.99 158.97,78.41 158.97,88.16 157.41,89.72 157.41,91.57 152.53,96.44 149.99,96.44 148.96,97.47 140.52,97.47 140.07,97.92 134.25,97.92 132.2,99.97 129.88,99.97 129.31,100.54 119.83,100.54 119.61,100.75 119.61,100.94 119.48,101.06 119.28,101.06 119.15,100.94 119.15,100.75 118.94,100.54 118.3,100.54 118.08,100.75 118.08,101.23 118.01,101.31 117.7,101.31 117.63,101.23 117.63,100.75 117.41,100.54 116.96,100.54 116.74,100.75 116.74,101.17 116.65,101.26 116.38,101.26 116.29,101.17 116.29,100.75 116.07,100.54 115.62,100.54 115.4,100.75 115.4,101.17 115.31,101.26 115.04,101.26 114.94,101.17 114.94,100.75 114.73,100.54 114.27,100.54 114.06,100.75 114.06,101.25 113.97,101.34 113.69,101.34 113.6,101.25 113.6,100.75 113.38,100.54 101.9,100.54 101.14,101.3 100.41,101.3 99.75,101.97 99.43,101.97 v3(99.24,101.78)
  BOTTOM w0.102: JLVDS1.23 100.1,102.06 99.82,101.78 v3(99.24,101.78) ; v1(155.72,37.84) 156.03,37.52 UH4.AK39
LCD_B0+_PCH: length 139.1
  IN1 w0.084: v5(157.67,39.2) 157.67,39.32 157.51,39.48 157.32,39.48 157.05,39.75 157.05,41.59 157.56,42.1 157.56,42.1 157.58,42.12
  IN1 w0.091: v3(120.76,105.86) 120.73,105.86 120.34,106.25 120.34,106.99 120.63,107.28 134.9,107.28 137.32,104.86 139.72,104.86 139.97,105.12 146.68,105.12 147.37,104.43 149.59,104.43 151.22,102.8 155.52,102.8 158.94,99.39 158.94,98 160.18,96.76 161.51,96.76 162.66,95.61 162.66,94.38 163.23,93.81 163.23,93.23 163.56,92.9 164.28,92.9 164.52,92.66 164.52,90.4 165.2,89.72 165.2,87.23 166.46,85.97 166.46,80.06 166.28,79.89 164.81,79.89 164.53,79.6 164.53,78.35 164.78,78.1 165.7,78.1 165.83,77.98 165.83,77.65 165.7,77.53 164.74,77.53 164.53,77.31 164.53,76.86 164.74,76.64 166.99,76.64 167.11,76.51 167.11,76.35 166.95,76.18 164.74,76.18 164.53,75.97 164.53,75.36 164.73,75.16 167.34,75.16 167.47,75.04 167.47,74.61 167.34,74.48 165.59,74.48 165.34,74.23 165.34,73.85 165.59,73.6 167.29,73.6 167.42,73.47 167.42,73.11 167.29,72.98 166.76,72.98 166.51,72.73 166.51,72.22 166.76,71.97 167.6,71.97 167.75,71.82 167.75,62.04 167.46,61.75 167.46,53.96 168.83,52.58 168.83,50.97 169.72,50.08 169.72,47.27 167.34,44.88 165.44,44.88 165.05,44.49 164.46,44.49 164.06,44.88 161.57,44.88 161.45,44.75 158.96,44.75 158.43,44.23 158.43,42.97 157.58,42.12
  BOTTOM w0.102: UH4.AH43 157.44,39.43 v5(157.67,39.2) ; JLVDS2.10 120.91,106.67 120.53,106.3 120.53,106.09 v3(120.76,105.86)
LCD_B0-_PCH: length 139.1
  IN1 w0.084: v5(157.69,39.82) 157.56,39.69 157.4,39.69 157.26,39.83 157.26,41.5 157.71,41.95 157.71,41.95 157.73,41.97
  IN1 w0.091: v1(120.13,105.86) 120.13,107.08 120.54,107.49 134.99,107.49 137.41,105.08 139.63,105.08 139.88,105.33 146.77,105.33 147.46,104.64 149.68,104.64 151.31,103.01 155.61,103.01 159.15,99.48 159.15,98.09 160.27,96.97 161.6,96.97 162.87,95.7 162.87,94.47 163.44,93.9 163.44,93.32 163.65,93.11 164.37,93.11 164.74,92.75 164.74,90.48 165.41,89.81 165.41,87.32 166.67,86.05 166.67,79.98 166.37,79.67 164.9,79.67 164.74,79.51 164.74,78.44 164.86,78.32 165.79,78.32 166.04,78.06 166.04,77.56 165.79,77.31 164.83,77.31 164.74,77.22 164.74,76.95 164.83,76.86 167.07,76.86 167.33,76.6 167.33,76.26 167.04,75.97 164.83,75.97 164.74,75.88 164.74,75.45 164.82,75.38 167.43,75.38 167.68,75.12 167.68,74.52 167.43,74.27 165.68,74.27 165.55,74.14 165.55,73.94 165.68,73.81 167.38,73.81 167.63,73.56 167.63,73.02 167.38,72.77 166.85,72.77 166.72,72.64 166.72,72.31 166.85,72.18 167.69,72.18 167.96,71.9 167.96,61.95 167.67,61.66 167.67,54.05 169.05,52.67 169.05,51.05 169.94,50.17 169.94,47.18 167.43,44.67 165.53,44.67 165.13,44.27 164.37,44.27 163.97,44.67 161.66,44.67 161.53,44.54 159.05,44.54 158.65,44.14 158.65,42.89 157.73,41.97
  BOTTOM w0.102: JLVDS2.11 119.91,106.73 120.26,106.37 120.26,105.99 v1(120.13,105.86) ; UH4.AH45 157.45,40.06 v5(157.69,39.82)
LCD_B1+_PCH: length 139.3
  IN1 w0.091: v3(123.69,105.91) 123.26,106.33 123.26,106.53 123.32,106.59 124.74,106.59 124.87,106.47 124.87,106.26 124.74,106.13 124.5,106.13 124.3,105.93 124.3,105.16 124.2,105.06 123.2,105.06 122.94,104.81 122.94,104.35 123.2,104.1 125.01,104.1 125.27,104.35 125.27,105.11 125.39,105.24 125.71,105.24 125.84,105.11 125.84,104.34 126.09,104.09 126.58,104.09 126.83,104.34 126.83,104.97 126.95,105.1 127.96,105.1 128.21,105.35 128.21,105.83 128.29,105.91 128.66,105.91 128.73,105.83 128.73,104.98 129.03,104.69 132.74,104.69 133.1,105.05 134.78,105.05 136.43,103.39 138.04,103.39 138.17,103.26 138.17,102.8 139.16,101.81 146.34,101.81 146.72,101.43 154.73,101.43 156.15,100.01 156.15,98.82 156.66,98.31 157.36,98.31 157.5,98.17 157.5,97.47 161.67,93.3 161.67,92.22 161.94,91.95 162.38,91.95 162.5,91.82 162.5,91.47 162.38,91.35 161.92,91.35 161.67,91.09 161.67,90.49 161.92,90.23 162.64,90.23 162.81,90.07 162.81,88.87 163.06,88.62 163.62,88.62 163.75,88.49 163.75,88.06 163.62,87.93 162.65,87.93 162.4,87.68 162.4,86.97 162.65,86.72 163.67,86.72 163.8,86.59 163.8,86.39 163.67,86.26 162.65,86.26 162.4,86.01 162.4,85.63 162.65,85.37 163.46,85.37 163.58,85.25 163.58,84.97 163.46,84.85 162.64,84.85 162.41,84.62 162.41,74.31 165.81,70.91 165.81,70.49 165.72,70.4 164.93,70.4 164.68,70.15 164.68,69.77 164.93,69.52 165.72,69.52 165.81,69.42 165.81,69.02 165.72,68.93 164.93,68.93 164.68,68.68 164.68,68.32 164.93,68.07 166.25,68.07 166.37,67.94 166.37,67.74 166.25,67.61 165.81,67.61 165.56,67.36 165.56,66.98 165.81,66.73 166.25,66.73 166.37,66.6 166.37,66.4 166.25,66.27 165.9,66.27 165.67,66.04 165.67,63.68 166.06,63.28 166.06,53.42 167.46,52.02 167.46,49.6 167.85,49.21 167.85,49.02 167.76,48.93 167.3,48.93 167.05,48.68 167.05,48.14 167.3,47.89 167.83,47.89 167.95,47.76 167.95,47.44 166.77,46.25 157.3,46.25 155.93,44.88 155.93,44.27 156.15,44.04 156.56,44.04 156.66,43.94 v1(156.66,43.82)
  BOTTOM w0.102: v3(123.69,105.91) 123.5,106.1 123.5,106.3 123.91,106.7 JLVDS2.7 ; UH4.AH49 157.23,42.16 157.16,42.09 156.89,42.09 156.76,42.22 156.76,42.49 156.89,42.62 157.21,42.62 157.27,42.68 157.27,42.97 157.21,43.04 156.8,43.04 156.74,43.1 156.74,43.33 156.8,43.39 156.93,43.39 156.98,43.44 156.98,43.76 156.91,43.82 v1(156.66,43.82)
LCD_B1-_PCH: length 139.3
  IN1 w0.091: v1(123.05,105.91) 123.05,106.62 123.24,106.81 124.83,106.81 125.09,106.55 125.09,106.17 124.83,105.92 124.58,105.92 124.51,105.84 124.51,105.07 124.29,104.85 123.28,104.85 123.16,104.72 123.16,104.44 123.28,104.32 124.93,104.32 125.05,104.44 125.05,105.2 125.3,105.45 125.8,105.45 126.05,105.2 126.05,104.43 126.18,104.3 126.49,104.3 126.61,104.43 126.61,105.06 126.87,105.31 127.87,105.31 128,105.44 128,105.92 128.2,106.12 128.75,106.12 128.95,105.92 128.95,105.07 129.11,104.9 132.65,104.9 133.01,105.26 134.87,105.26 136.52,103.6 138.13,103.6 138.38,103.35 138.38,102.89 139.25,102.02 146.43,102.02 146.81,101.64 154.82,101.64 156.37,100.1 156.37,98.91 156.75,98.52 157.45,98.52 157.71,98.26 157.71,97.56 161.89,93.39 161.89,92.3 162.03,92.16 162.46,92.16 162.72,91.91 162.72,91.38 162.46,91.13 162.01,91.13 161.89,91.01 161.89,90.57 162.01,90.45 162.73,90.45 163.02,90.16 163.02,88.96 163.15,88.83 163.71,88.83 163.96,88.58 163.96,87.97 163.71,87.72 162.74,87.72 162.61,87.59 162.61,87.06 162.74,86.93 163.76,86.93 164.01,86.68 164.01,86.3 163.76,86.05 162.74,86.05 162.61,85.92 162.61,85.72 162.74,85.59 163.55,85.59 163.8,85.34 163.8,84.88 163.55,84.63 162.73,84.63 162.63,84.53 162.63,74.4 166.02,71 166.02,70.4 165.8,70.19 165.02,70.19 164.89,70.06 164.89,69.86 165.02,69.73 165.8,69.73 166.02,69.51 166.02,68.93 165.81,68.72 165.02,68.72 164.89,68.59 164.89,68.41 165.02,68.28 166.33,68.28 166.59,68.03 166.59,67.65 166.33,67.4 165.9,67.4 165.77,67.27 165.77,67.07 165.9,66.94 166.33,66.94 166.59,66.69 166.59,66.31 166.33,66.05 165.98,66.05 165.88,65.95 165.88,63.76 166.27,63.37 166.27,53.51 167.68,52.1 167.68,49.69 168.06,49.3 168.06,48.93 167.85,48.71 167.39,48.71 167.26,48.59 167.26,48.23 167.39,48.1 167.91,48.1 168.17,47.85 168.17,47.35 166.85,46.04 157.39,46.04 156.14,44.79 156.14,44.35 156.24,44.25 156.45,44.25 v3(156.66,44.46)
  BOTTOM w0.102: JLVDS2.8 122.91,106.72 123.24,106.4 123.23,106.39 123.23,106.09 v1(123.05,105.91) ; v3(156.66,44.46) 157.24,43.87 157.24,43.38 157.54,43.09 157.54,42.08 157.23,41.77 UH4.AH47
LCD_B2+_PCH: length 138.7
  IN1 w0.091: v3(126.72,105.82) 126.61,105.82 126.5,105.94 126.5,106.01 126.3,106.21 126.3,106.51 126.39,106.59 129.38,106.59 129.51,106.46 129.51,105.62 129.76,105.37 130.28,105.37 130.53,105.62 130.53,106.46 130.65,106.59 131.26,106.59 131.39,106.46 131.39,106.07 131.64,105.82 132.2,105.82 132.45,106.07 132.45,106.46 132.58,106.59 132.94,106.59 133.07,106.46 133.07,106.11 133.32,105.85 133.77,105.85 134.02,106.11 134.02,106.46 134.14,106.59 134.49,106.59 134.62,106.46 134.62,105.98 134.87,105.73 135.31,105.73 136.89,104.15 140.05,104.15 140.31,104.42 144.91,104.42 145.02,104.32 145.02,102.75 145.27,102.5 145.82,102.5 146.07,102.75 146.07,104 146.2,104.12 146.62,104.12 146.75,104 146.75,102.37 147,102.12 147.51,102.12 147.76,102.37 147.76,103.62 147.88,103.74 148.17,103.74 148.29,103.62 148.29,102.37 148.55,102.12 149.07,102.12 149.32,102.37 149.32,103.12 149.45,103.25 149.8,103.25 149.93,103.12 149.93,102.32 150.13,102.12 155.16,102.12 158.22,99.05 158.22,97.72 159.99,95.95 160.93,95.95 161.45,95.43 161.45,94.5 162.54,93.41 162.54,92.78 163.2,92.12 163.2,90.68 164.49,89.39 164.49,86.44 164.78,86.15 165.3,86.15 165.42,86.03 165.42,85.67 165.3,85.54 164.52,85.54 164.27,85.29 164.27,84.84 164.52,84.59 165.28,84.59 165.41,84.46 165.41,84.17 165.28,84.04 163.3,84.04 163.1,83.84 163.1,83.36 163.3,83.16 165.31,83.16 165.44,83.03 165.44,82.83 165.31,82.7 163.37,82.7 163.11,82.45 163.11,82.07 163.37,81.82 165.3,81.82 165.42,81.69 165.42,81.32 165.3,81.2 163.41,81.2 163.14,80.93 163.14,74.56 166.5,71.2 166.5,68.82 167.06,68.26 167.06,63.56 166.75,63.25 166.75,53.7 168.15,52.3 168.15,50.68 169.04,49.79 169.04,47.55 167.05,45.57 157.71,45.57 157.13,44.99 157.13,44.08 157.32,43.89 157.64,43.89 157.78,43.75 v1(157.78,43.66)
  BOTTOM w0.102: UH4.AF47 158.22,41.81 157.78,42.25 v1(157.78,43.66) ; JLVDS2.4 126.91,106.71 126.55,106.35 126.55,105.99 v3(126.72,105.82)
LCD_B2-_PCH: length 138.7
  IN1 w0.091: v1(126.09,105.82) 126.09,106.6 126.3,106.81 129.47,106.81 129.72,106.55 129.72,105.71 129.85,105.59 130.19,105.59 130.31,105.71 130.31,106.55 130.57,106.8 131.35,106.8 131.6,106.55 131.6,106.16 131.73,106.03 132.11,106.03 132.24,106.16 132.24,106.55 132.49,106.8 133.03,106.8 133.28,106.55 133.28,106.19 133.41,106.07 133.68,106.07 133.8,106.19 133.8,106.55 134.06,106.8 134.58,106.8 134.83,106.55 134.83,106.07 134.96,105.95 135.4,105.95 136.98,104.37 139.96,104.37 140.23,104.63 145,104.63 145.23,104.4 145.23,102.84 145.36,102.71 145.73,102.71 145.85,102.84 145.85,104.09 146.11,104.34 146.71,104.34 146.96,104.09 146.96,102.46 147.09,102.33 147.42,102.33 147.54,102.46 147.54,103.7 147.8,103.96 148.25,103.96 148.51,103.7 148.51,102.46 148.63,102.33 148.98,102.33 149.11,102.46 149.11,103.21 149.36,103.46 149.89,103.46 150.14,103.21 150.14,102.41 150.22,102.33 155.25,102.33 158.44,99.14 158.44,97.8 160.08,96.16 161.02,96.16 161.66,95.52 161.66,94.59 162.76,93.49 162.76,92.87 163.42,92.21 163.42,90.76 164.7,89.48 164.7,86.53 164.86,86.37 165.38,86.37 165.64,86.12 165.64,85.58 165.38,85.33 164.61,85.33 164.48,85.2 164.48,84.93 164.61,84.81 165.37,84.81 165.62,84.55 165.62,84.08 165.37,83.83 163.39,83.83 163.31,83.75 163.31,83.45 163.39,83.37 165.4,83.37 165.65,83.12 165.65,82.74 165.4,82.49 163.45,82.49 163.33,82.36 163.33,82.16 163.45,82.03 165.38,82.03 165.64,81.78 165.64,81.23 165.38,80.98 163.5,80.98 163.36,80.84 163.36,74.65 166.72,71.28 166.72,68.9 167.27,68.35 167.27,63.47 166.96,63.16 166.96,53.79 168.36,52.39 168.36,50.77 169.25,49.88 169.25,47.46 167.14,45.35 157.8,45.35 157.34,44.9 157.34,44.17 157.41,44.1 157.59,44.1 v3(157.78,44.29)
  BOTTOM w0.102: v3(157.78,44.29) 158.21,43.86 158.21,43.14 158.04,42.97 158.04,42.36 158.13,42.28 UH4.AF49 ; v1(126.09,105.82) 126.29,106.02 126.29,106.32 125.91,106.7 JLVDS2.5
LCD_BCLK+_PCH: length 139.5
  IN1 w0.091: v1(157.68,37.89) 157.68,37.97 157.33,38.32 156.62,38.32 156.18,38.76 156.18,39.27 155.75,39.7 155.75,40.28 156.18,40.71 156.18,41.23 155.76,41.66 153.28,41.66 152.08,42.86 152.08,44.93 156.19,49.04 158.72,49.04 159.23,49.55 159.23,51.37 159.69,51.83 159.69,53.55 159.94,53.8 160.6,53.8 160.85,53.55 160.85,53.12 160.98,52.99 161.31,52.99 161.44,53.12 161.44,53.54 161.69,53.79 162.61,53.79 162.86,53.54 162.86,53.15 162.94,53.07 163.24,53.07 163.32,53.15 163.32,54.12 163.19,54.25 160.86,54.25 160.61,54.5 160.61,54.88 160.86,55.14 163.19,55.14 163.32,55.26 163.32,55.47 163.19,55.59 161.69,55.59 161.44,55.84 161.44,57.02 161.69,57.27 162.38,57.27 162.5,57.4 162.5,57.78 162.38,57.91 161.66,57.91 161.41,58.16 161.41,59.26 161.66,59.51 161.96,59.51 162.08,59.64 162.08,60 161.96,60.13 161.66,60.13 161.41,60.38 161.41,60.96 161.66,61.21 161.87,61.21 161.99,61.34 161.99,61.73 161.87,61.86 161.64,61.86 161.41,62.08 161.41,62.71 161.66,62.96 161.79,62.96 161.92,63.09 161.92,63.48 161.79,63.61 161.61,63.61 161.41,63.81 161.41,71.43 159.23,73.61 159.23,77.7 159.65,78.13 159.65,88.45 158.12,89.98 158.12,92.86 157.85,93.13 157.72,93.13 157.42,92.83 157.13,92.83 156.79,93.18 156.79,93.46 157.09,93.76 157.09,93.89 156.9,94.08 156.77,94.08 156.46,93.77 156.17,93.77 155.83,94.11 155.83,94.4 156.14,94.71 156.14,94.84 155.95,95.03 155.82,95.03 155.51,94.72 155.22,94.72 154.88,95.06 154.88,95.35 155.19,95.66 155.19,95.79 155,95.98 154.87,95.98 154.56,95.67 154.28,95.67 153.94,96.02 153.94,96.3 154.25,96.61 154.25,96.74 154.05,96.93 153.92,96.93 153.64,96.65 153.36,96.65 153.02,96.99 153.02,97.28 153.3,97.56 153.3,97.69 152.83,98.16 151.73,98.16 151.51,98.37 151.51,98.59 151.42,98.69 151.15,98.69 151.05,98.59 151.05,98.32 150.8,98.07 150.42,98.07 150.17,98.32 150.17,98.59 150.08,98.69 149.8,98.69 149.71,98.59 149.71,98.37 149.5,98.16 149.05,98.16 148.83,98.37 148.83,98.59 148.74,98.69 148.46,98.69 148.37,98.59 148.37,98.37 148.16,98.16 147.7,98.16 147.49,98.37 147.49,98.59 147.4,98.69 147.12,98.69 147.03,98.59 147.03,98.37 146.81,98.16 146.36,98.16 146.15,98.37 146.15,98.59 146.06,98.69 145.78,98.69 145.69,98.59 145.69,98.41 145.44,98.16 145.03,98.16 144.78,98.41 144.78,98.87 144.65,99 144.44,99 144.31,98.87 144.31,98.46 144.06,98.21 143.66,98.21 143.43,98.44 143.43,98.89 143.32,99 142.9,99 142.81,98.91 142.81,98.41 142.56,98.16 142.18,98.16 141.92,98.41 141.92,98.91 141.83,99 137.01,99 136.68,99.32 136.68,100.29 136.56,100.42 135.74,100.42 135.61,100.29 135.61,99.81 135.36,99.56 134.64,99.56 134.38,99.81 134.38,100.9 134.26,101.03 133.9,101.03 133.77,100.9 133.77,100.51 133.52,100.25 132.91,100.25 132.66,100.51 132.66,101.32 132.53,101.44 132.2,101.44 132.07,101.32 132.07,100.91 131.82,100.66 131.22,100.66 130.97,100.91 130.97,101.72 130.84,101.85 129.41,101.85 129.29,101.72 129.29,101.65 v3(129.71,101.22)
  BOTTOM w0.102: JLVDS2.1 129.91,106.67 129.52,106.29 129.52,101.41 v3(129.71,101.22) ; UH4.AF39 157.85,37.89 v1(157.68,37.89)
LCD_BCLK-_PCH: length 139.5
  IN1 w0.091: v3(157.74,38.53) 156.71,38.53 156.39,38.85 156.39,39.35 155.96,39.79 155.96,40.19 156.39,40.63 156.39,41.32 155.85,41.87 153.37,41.87 152.29,42.95 152.29,44.84 156.28,48.83 158.81,48.83 159.44,49.46 159.44,51.28 159.9,51.74 159.9,53.46 160.03,53.59 160.51,53.59 160.64,53.46 160.64,53.03 160.89,52.78 161.4,52.78 161.65,53.03 161.65,53.45 161.78,53.58 162.52,53.58 162.65,53.45 162.65,53.06 162.85,52.86 163.33,52.86 163.53,53.06 163.53,54.21 163.28,54.46 160.95,54.46 160.82,54.59 160.82,54.8 160.95,54.92 163.28,54.92 163.53,55.17 163.53,55.55 163.28,55.81 161.78,55.81 161.65,55.93 161.65,56.93 161.78,57.06 162.46,57.06 162.72,57.31 162.72,57.87 162.46,58.12 161.75,58.12 161.63,58.25 161.63,59.17 161.75,59.3 162.04,59.3 162.3,59.55 162.3,60.09 162.04,60.35 161.75,60.35 161.63,60.47 161.63,60.87 161.75,61 161.96,61 162.21,61.25 162.21,61.82 161.96,62.07 161.73,62.07 161.63,62.17 161.63,62.62 161.75,62.75 161.88,62.75 162.13,63 162.13,63.57 161.88,63.82 161.7,63.82 161.63,63.9 161.63,71.52 159.45,73.7 159.45,77.62 159.87,78.04 159.87,88.53 158.33,90.07 158.33,92.95 157.94,93.35 157.63,93.35 157.33,93.05 157.22,93.05 157.01,93.26 157.01,93.37 157.31,93.67 157.31,93.98 156.99,94.3 156.68,94.3 156.37,93.98 156.26,93.98 156.04,94.2 156.04,94.31 156.36,94.62 156.36,94.93 156.04,95.25 155.73,95.25 155.42,94.93 155.31,94.93 155.09,95.15 155.09,95.26 155.41,95.57 155.41,95.88 155.09,96.19 154.78,96.19 154.48,95.89 154.37,95.89 154.15,96.1 154.15,96.21 154.46,96.52 154.46,96.82 154.14,97.14 153.83,97.14 153.55,96.86 153.45,96.86 153.23,97.08 153.23,97.19 153.51,97.47 153.51,97.77 152.91,98.37 151.82,98.37 151.72,98.46 151.72,98.68 151.51,98.9 151.06,98.9 150.84,98.68 150.84,98.41 150.71,98.28 150.51,98.28 150.38,98.41 150.38,98.68 150.17,98.9 149.72,98.9 149.5,98.68 149.5,98.46 149.41,98.37 149.13,98.37 149.04,98.46 149.04,98.68 148.83,98.9 148.37,98.9 148.16,98.68 148.16,98.46 148.07,98.37 147.79,98.37 147.7,98.46 147.7,98.68 147.48,98.9 147.03,98.9 146.82,98.68 146.82,98.46 146.73,98.37 146.45,98.37 146.36,98.46 146.36,98.68 146.14,98.9 145.69,98.9 145.48,98.68 145.48,98.5 145.35,98.37 145.12,98.37 144.99,98.5 144.99,98.96 144.74,99.21 144.35,99.21 144.1,98.96 144.1,98.55 143.97,98.43 143.75,98.43 143.64,98.53 143.64,98.98 143.41,99.21 142.81,99.21 142.59,99 142.59,98.5 142.47,98.37 142.26,98.37 142.14,98.5 142.14,99 141.92,99.21 137.09,99.21 136.9,99.41 136.9,100.38 136.64,100.63 135.65,100.63 135.4,100.38 135.4,99.9 135.27,99.77 134.72,99.77 134.6,99.9 134.6,100.99 134.35,101.24 133.81,101.24 133.56,100.99 133.56,100.59 133.43,100.47 133,100.47 132.87,100.59 132.87,101.41 132.62,101.66 132.11,101.66 131.86,101.41 131.86,101 131.73,100.87 131.31,100.87 131.18,101 131.18,101.81 130.93,102.06 129.32,102.06 129.07,101.81 v1(129.07,101.22)
  BOTTOM w0.102: v1(129.07,101.22) 129.26,101.41 129.26,106.32 128.91,106.67 JLVDS2.2 ; UH4.AF40 158,38.16 157.74,38.42 v3(157.74,38.53)
LCD_CBL_DET#: length 134.7
  TOP w0.102: RH330.2 169.26,38.43 168.8,37.97 167.54,37.97 167.36,38.15 v3(167.36,38.39)
  IN2 w0.102: v3(167.36,38.39) 168,39.03 168,41.14 168.21,41.35 168.21,43.37
  IN2 w0.122: v1(100.84,100.21) 101.17,99.87 135.53,99.87 135.8,99.61 136.64,99.61 138.11,98.15 139.29,98.15 139.97,98.83 148.24,98.83 150.32,96.75 154.91,96.75 158.67,92.99 158.67,89.17 162.31,85.53 162.31,73.94 162.66,73.59 162.66,62.35 163.61,61.4 163.61,57.24 164.42,56.42 164.42,54.42 166.57,52.27 166.57,49.35 168.53,47.38 168.53,44.24 168.21,43.92 168.21,43.37
  BOTTOM w0.102: JLVDS1.25 99.1,106.13 98.79,105.81 98.79,100.59 99.18,100.21 v1(100.84,100.21) ; UH4.G42 167.68,38.71 v3(167.36,38.39)
LCD_SMBCLK: length 10
  TOP w0.102: v1(291.28,57.02) 291.8,56.5 292.18,56.5 292.33,56.35 U51.B5 ; R418.2 298.3,55.31 298.1,55.31 v3(297.9,55.11)
  IN1 w0.084: v3(297.9,55.11) 297.76,55.25 294.39,55.25 294,55.64 293.98,55.64 293.04,56.58 291.55,56.58 291.28,56.86 v1(291.28,57.02)
LCD_SMBDAT: length 6
  TOP w0.102: U51.A4 294.21,56.1 v3(294.21,56.09) ; R420.2 298.28,55.53 298.12,55.53 v1(297.9,55.75)
  IN1 w0.084: v1(297.9,55.75) 297.9,55.74 297.63,55.47 294.47,55.47 294.21,55.73 v3(294.21,56.09)
LCD_TST: length 249.3
  TOP w0.102: v1(109.22,104.43) v2(109.82,104.43) ; U46.A36 266.34,81.34 v1(267.33,82.33) 267.33,82.76 R767.2
  IN2 w0.122: v1(267.33,82.33) 267.33,82.33 265.84,80.84 260.36,80.84 259.48,81.72 256.77,81.72 255.76,80.71 255.76,74.74 254.99,73.96 253.13,73.96 252.71,73.54 252.71,67.29 252.02,66.6 252.02,63.98 250.25,62.21 242.65,62.21 236.42,55.98 234.1,55.98 233.05,54.92 231.07,54.92 221.17,45.02 215.02,45.02 211.74,41.73 208.65,41.73 204.48,37.56 199.54,37.56 193.35,43.76 187.37,43.76 181.57,49.57 181.57,51.38 180.99,51.96 180.04,51.96 178.94,50.87 174.23,50.87 171.64,53.46 171.64,58.83 170.27,60.2 170.02,60.2 169.71,60.5 169.71,63.59 170.39,64.27 170.39,67.25 169.77,67.87 169.77,70.14 168.87,71.04 168.87,76.17 169.93,77.23 169.93,78.55 168.26,80.22 168.26,81.53 166.93,82.87 166.93,95.19 164.81,97.3 161.84,97.3 160.34,98.8 159.65,98.8 155.94,102.51 147.53,102.51 147.16,102.14 138.35,102.14 137.9,102.59 137.05,102.59 135.52,104.12 114.4,104.12 113.71,104.81 109.59,104.81 v1(109.22,104.43)
  BOTTOM w0.102: v1(109.22,104.43) 109.22,105.07 106.35,107.93 106.35,108.29 106.6,108.54 JLVDS1.10
LCD_VCC_TEST_EN: length 199.7
  TOP w0.102: U46.A40 264.34,81.06 264.16,81.25 264.16,81.71 v1(263.69,82.17)
  IN2 w0.122: v1(263.69,82.17) 262.48,83.39 257.29,83.39 256.1,82.19 253.45,82.19 241.54,70.29 241.54,69.25 236.72,64.43 236.72,62.54 228.09,53.91 228.09,53 220.86,45.76 214.71,45.76 213.19,44.24 195.22,44.24 194.19,45.26 187.13,45.26 182.31,50.08 182.31,53.49 177.62,58.19 173.45,58.19 171.14,60.49 171.14,61.16 170.52,61.79 170.52,63.31 171.14,63.93 171.14,67.8 170.52,68.42 170.52,72.76 169.73,73.55 169.73,75.98 170.67,76.92 170.67,78.86 169.01,80.53 169.01,81.87 167.84,83.03 167.84,86.42 168.7,87.28 168.7,95.11 164.98,98.83 162.49,98.83 161.09,100.23 159.28,100.23 155.61,103.9 151.31,103.9 151.14,103.73 139.79,103.73 v1(139.17,103.11)
  BOTTOM w0.102: v1(139.17,103.11) 139.4,102.88 139.4,101.69 v2(139.62,101.47) 140.23,100.86 140.23,98.17 140.5,97.89 D6.2
LDDC_CLK_PCH: length 136.5
  IN3 w0.122: v3(160.29,90.98) 160.29,90.69 159.83,90.23 159.83,81.6 159.18,80.95 159.18,73.76 160.97,71.98 160.97,52.48 159.65,51.16 159.65,47.92 162.62,44.95 162.62,43.11 162.24,42.72 162.24,40.09 v1(162.58,39.75)
  IN4 w0.084: v3(160.29,90.98) 160.07,91.21 159.74,91.21 152.88,98.07 150.29,98.07 148.41,99.95 137.77,99.95 136.91,100.8 136.2,100.8 133.45,103.55 115.21,103.55 113.93,102.27 108.93,102.27 108.73,102.07 108.73,101.78 v1(108.99,101.52)
  BOTTOM w0.102: UH4.T40 162.58,38.75 162.58,39.62 162.58,39.62 162.58,39.75 v1(162.58,39.75) ; JLVDS1.11 106.1,108.45 105.96,108.32 105.96,108 108.78,105.18 108.78,101.72 v1(108.99,101.52) 108.78,101.31 108.78,97.29 105.9,94.41 105.9,91.12 R159.2 107.12,90.78 C1332.1
LDDC_DATA_PCH: length 137.3
  IN3 w0.122: v1(166.22,42.81) 165.66,43.37 163.14,43.37 162.87,43.63 162.87,45.05 159.9,48.03 159.9,51.05 161.22,52.37 161.22,72.08 159.43,73.87 159.43,80.85 160.08,81.5 160.08,90.13 160.74,90.79 160.74,91.32 160.44,91.62 v1(160.29,91.62)
  IN4 w0.084: v1(160.29,91.62) 160.09,91.42 159.83,91.42 152.96,98.28 150.37,98.28 148.5,100.16 137.85,100.16 137,101.01 136.29,101.01 133.53,103.77 115.13,103.77 113.85,102.48 108.84,102.48 108.52,102.16 108.52,101.69 v3(108.35,101.52)
  BOTTOM w0.102: UH4.K47 166.14,41.78 165.79,42.13 165.79,42.55 166.05,42.81 v1(166.22,42.81) ; C1333.1 104.47,90.78 R160.2 105.67,91.09 105.67,94.5 108.55,97.38 108.55,101.32 v3(108.35,101.52) 108.56,101.72 108.56,105.08 105.74,107.9 105.74,108.32 105.6,108.45 JLVDS1.12
LED_10_GRN#: length 28.8
  TOP w0.102: U15.2 291.76,87.56 v1(291.19,86.99) 290.66,86.46 290.66,86.21 289.68,85.24 289.33,85.24 289.11,85.03 U31.25 ; R1091.1 299.81,69.8 v2(298.7,70.91) 296.21,73.4 294.09,73.4 293.59,73.9 291.94,73.9 v1(291.22,74.62)
  IN3 w0.122: v1(291.19,86.99) 291.71,86.47 291.71,84.3 290.92,83.51 290.92,74.91 v1(291.22,74.62)
LED_10_GRN#_R: length 27.3
  TOP w0.102: R1091.2 C1324.1 298.89,67.84 v1(298.98,67.75) 299.31,67.42 v2(300.59,67.42)
  IN4 w0.084: JLOM1.11 316.11,67.03 313.78,64.7 310.24,64.7 309.5,65.45 304.68,65.45 303.01,67.11 299.62,67.11 v1(298.98,67.75)
LED_100_ORG#: length 31.8
  TOP w0.102: U31.27 288.31,85.08 288.44,85.2 288.44,87.94 288.76,88.27 v1(289.12,88.27) 291.18,88.27 291.24,88.21 U15.1 ; v1(290.56,74.64) 291.7,73.49 293.32,73.49 293.99,72.83 v2(294.58,72.83) 295.97,72.83 297.03,71.76 R1090.1
  IN3 w0.122: v1(289.12,88.27) 289.02,88.17 289.02,85.38 290.63,83.77 290.63,74.71 v1(290.56,74.64)
LED_100_ORG#_R: length 29.7
  TOP w0.102: R1090.2 C1325.1 297.93,68.12 v1(298.3,67.75) 299.05,67 v2(299.05,66.29)
  IN4 w0.084: JLOM1.13 316.32,68.83 316.32,66.93 313.87,64.49 310.13,64.49 309.38,65.24 304.59,65.24 302.93,66.9 299.15,66.9 v1(298.3,67.75)
LED_SATA_DIAG_OUT#: length 149
  TOP w0.102: v1(264.51,68.48) 264.94,68.91 264.94,69.39 264.84,69.49 U46.A10 ; v1(169.75,71.9) 169.35,71.9 v2(169.04,71.59)
  IN1 w0.084: v1(169.75,71.9) 169.29,71.44 169.29,61.41 168.99,61.11 168.99,58.28 169.87,57.4 169.87,54.17 170.36,53.68 170.36,51.6 173.04,48.92 181.23,48.92 183.61,46.54 186.31,46.54 186.76,46.99 187.3,46.99 190.35,43.94 192.66,43.94 195.21,41.39 195.21,39.63 198.85,35.99 218.04,35.99 239.54,57.49 239.54,59.11 240.36,59.92 240.36,68.13 241.92,69.69 242.64,69.69 243.25,70.3 254.19,70.3 254.81,69.68 257.55,69.68 258.42,70.55 263.37,70.55 264.03,69.89 264.03,69 264.51,68.51 v1(264.51,68.48)
  BOTTOM w0.102: D62.1 170.2,72.35 v1(169.75,71.9)
LED_WWAN_OUT#: length 48.5
  IN1 w0.084: v1(276.81,49.15) 275.15,49.15 274.14,48.13 268.53,48.13 265.35,44.95 v1(252.02,44.95)
  BOTTOM w0.102: v1(252.02,44.95) 251.49,45.48 251.49,46.63 v2(253.46,48.6) 255.16,50.3 Q77.3 255.16,53 254.46,53.71 254.46,54.67 255.33,55.53 R719.1 ; v1(276.81,49.15) 278.81,49.15 279.84,48.12 279.84,44.56 280.2,44.2 JMINI1.42
LG_3V:
  vias: v2(253.75,13.04)
LG_5V: length 8.1
  TOP w0.102: 245.59,11.02 244.7,11.02 v4(244.42,11.3)
  IN1 w1.016: 244.7,11.26 242.39,11.26 240.32,13.33 238.77,13.33
  vias: v1(236.43,11.83) v1(236.82,12.38) v1(244.89,10.12) v1(245.56,10.12)
LG_+V1.05S_VCCPP: length 12
  IN1 w1.016: 119.09,4.02 119.09,5.15 120,6.06 120,10.77 121.54,12.32
  BOTTOM w0.102: v1(123.26,12.66) 123.26,10.95 v2(123.93,10.27)
  vias: v1(118.84,2.94) v1(119.47,2.94) v1(122.62,12.66)
LG_+V1.05SP: length 9.8
  IN1 w1.016: 158.17,60.92 158.53,60.56 158.53,56.36 156.28,54.11 154.46,54.11 154.41,54.16
  vias: v1(152.84,54.59) v1(153.47,54.59) v1(158.27,63.04) v1(158.27,62.38) v2(152.3,54.53)
LGATE1:
  vias: v1(145.4,80.73) v1(145.4,80.1) v1(146.72,77.11) v1(146.72,76.48) v2(147.45,76.91)
LGATE1G: length 10.7
  IN1 w1.016: 137.38,84.8 136.2,85.98 134.36,85.98 132.24,88.1 132.24,91.46
  BOTTOM w0.102: v1(127.86,93.18) 127.86,93.67 v2(128.1,93.91)
  vias: v1(128.75,93.18) v1(134.4,92.26) v1(134.4,91.63) v1(139.79,83.97) v1(140.43,83.97)
LID_CL#: length 330.2
  TOP w0.102: v1(245.64,75.83) 246.85,75.83 v2(249.84,78.82) 254.13,83.12 R807.1 ; JLID1.2 29.5,7.62 28.96,7.08 28.96,3.62 v1(28.76,3.41) ; v1(257.75,87.47) 258.03,87.75 U58.2
  IN1 w0.084: v1(257.75,87.47) 257.75,87.08 257.42,86.75 257.42,83.58 256.22,82.38 252.16,82.38 246.27,76.49 246.27,76.46 v1(245.64,75.83)
  IN3 w0.122: v1(245.64,75.83) 245.64,66.4 245.47,66.23 245.47,62.6 243.13,60.25 243.13,56.78 242.08,55.74 242.08,49.74 240.14,47.8 240.14,39.49 238.61,37.96 238.61,28.47 236.06,25.92 236.06,22.72 232.81,19.47 224.08,19.47 219.36,14.74 v1(219.36,13.74)
  IN4 w0.084: v1(28.76,3.41) 29.61,2.56 32.56,2.56 37.09,7.1 41.94,7.1 46.41,11.57 56.58,11.57 57.18,10.97 59.14,10.97 59.86,11.69 66.02,11.69 66.71,11.01 68.79,11.01 69.4,11.62 77.16,11.62 80.3,14.76 93.77,14.76 94.84,13.69 98.93,13.69 99.86,14.61 112.87,14.61 114.09,15.83 128.22,15.83 133.13,10.93 147.98,10.93 148.67,11.61 153.95,11.61 154.89,10.67 154.89,9.46 155.33,9.03 156.49,9.03 161.31,4.21 178.48,4.21 179.53,5.27 182.9,5.27 184.05,4.11 191,4.11 194.21,7.33 201.85,7.33 206.36,11.84 206.36,12.42 207.74,13.8 209.91,13.8 210.42,13.29 218.66,13.29 219.11,13.74 v1(219.36,13.74)
LID_CL_SIO#: length 11.3
  TOP w0.102: v2(254.63,84.24) 254.85,84.24 R807.2 R805.2 C716.1 256.14,81.21 v1(256.9,80.45) ; U46.B54 259.82,78.31 v1(260.28,77.85)
  IN1 w0.084: v1(256.9,80.45) 257.51,79.84 257.51,78.34 258,77.85 v1(260.28,77.85)
LPC_LAD0: length 180.2
  TOP w0.102: v1(285.03,64.56) 285.26,64.33 U51.A30 ; U46.A27 270.4,76.56 v1(270.97,75.99)
  IN1 w0.084: v1(285.03,64.56) 284.83,64.56 282.82,66.57 282.82,68.02 282.53,68.31 280.57,68.31 272.9,75.99 v1(270.97,75.99)
  IN2 w0.102: v1(172.36,36.88) 172.48,36.99 174.55,36.99
  IN2 w0.122: v1(256.12,42.48) 255.64,42 247.24,42 245.08,39.84 237.33,39.84 227.92,30.43 194.94,30.43 193.6,31.78 189.08,31.78 187.57,33.29 184.71,33.29 181.17,36.83 174.72,36.83 174.55,36.99
  IN3 w0.122: v3(273.61,49.26) 273.13,49.74 273.13,50.28 273.56,50.7 273.56,69.15 272.16,70.54 272.16,75.42 271.59,75.99 v1(270.97,75.99)
  BOTTOM w0.102: v3(273.61,49.26) 273.6,49.25 272.82,49.25 272.1,48.54 269.78,48.54 269.52,48.28 U37.26 U39.26 265.59,48.28 264.91,47.61 264.91,45.9 263.15,44.13 263.15,37.39 261.46,35.7 JMINI3.16 257.81,35.7 254.96,38.55 254.96,41.32 v1(256.12,42.48) ; UH4.C38 170.05,36.9 170.54,37.38 171.86,37.38 v1(172.36,36.88)
LPC_LAD1: length 184.7
  TOP w0.102: v1(285.66,61.63) 285.16,62.13 285.16,62.48 285.01,62.63 U51.B32 ; U46.A26 270.29,76.06 v1(270.34,76.01)
  IN1 w0.084: v1(270.34,76.01) 270.34,75.79 270.56,75.56 271.19,75.56 271.4,75.78 272.8,75.78 281.82,66.76 282.23,66.76 286.1,62.89 286.1,62.07 v1(285.66,61.63)
  IN2 w0.102: 174.55,37.31 172.16,37.31 v1(171.73,36.88)
  IN2 w0.122: 174.55,37.31 175.57,37.31 176.14,37.88 177.34,37.88 178.14,37.08 181.27,37.08 184.81,33.54 187.67,33.54 189.18,32.03 193.7,32.03 195.05,30.68 227.82,30.68 237.23,40.09 244.91,40.09 247.12,42.29 255.28,42.29 v3(256.13,43.14)
  IN3 w0.122: v1(270.34,76.01) 270.76,76.43 271.5,76.43 272.41,75.52 272.41,70.65 273.84,69.21 273.84,50.13 v1(273.61,49.9)
  BOTTOM w0.102: v3(256.13,43.14) 256.57,42.69 256.57,42.19 255.22,40.83 255.22,38.63 257.34,36.5 JMINI3.14 261.17,36.5 262.92,38.25 262.92,44.45 264.57,46.1 264.57,49.24 265.57,50.23 U39.23 U37.23 268.7,50.23 268.75,50.17 271.25,50.17 271.9,49.53 273.24,49.53 v1(273.61,49.9) ; UH4.A38 170.6,36.98 171.63,36.98 v1(171.73,36.88)
LPC_LAD2: length 187.4
  TOP w0.102: U51.A31 284.76,64.21 284.25,64.73 282.04,64.73 279.6,67.17 v2(279.6,69.05) 279.6,69.17 280.15,69.73 v1(280.19,69.73) ; v1(267.36,75.81) 267.8,75.38 268.61,75.38 U46.B26
  IN1 w0.084: v1(267.36,75.81) 267.79,76.24 268.94,76.24 270.2,77.51 272,77.51 279.77,69.73 v1(280.19,69.73)
  IN2 w0.102: v1(171.58,36.27) 171.78,36.47 174.55,36.47
  IN2 w0.122: v1(257.03,43.08) 257.03,42.01 256.7,41.68 247.37,41.68 245.28,39.59 237.43,39.59 228.02,30.18 194.84,30.18 193.49,31.53 188.98,31.53 187.46,33.04 184.05,33.04 181.78,35.31 181.44,35.31 180.17,36.58 174.87,36.58 174.76,36.47 174.55,36.47
  IN3 w0.122: v1(273.11,52.59) 273.31,52.79 273.31,69.04 271.64,70.71 271.64,74.23 271.22,74.66 268.9,74.66 268.37,75.19 267.99,75.19 v1(267.36,75.81)
  BOTTOM w0.102: UH4.B37 170.26,36.58 170.66,36.58 170.79,36.71 171.13,36.71 v1(171.58,36.27) ; v1(257.03,43.08) 257.03,42.26 255.53,40.77 255.53,38.69 256.92,37.3 JMINI3.12 261.27,37.3 262.69,38.72 262.69,44.73 264.06,46.11 264.06,51.2 265.04,52.18 U39.20 U37.20 268.91,52.18 269.51,52.78 272.93,52.78 v1(273.11,52.59)
LPC_LAD3: length 175
  TOP w0.102: v1(268,74.75) 268.06,74.81 U46.B25 ; U51.B33 284.51,62.67 284.72,62.46 v1(284.72,62.26)
  IN1 w0.084: v1(284.72,62.26) 284.72,63.68 282.08,66.32 281.66,66.32 274.66,73.32 271,73.32 270.6,72.92 270.2,72.92 268.37,74.75 v1(268,74.75)
  IN2 w0.102: v1(170.96,36.27) 171.58,35.65 171.84,35.65 172.22,36.03 174.55,36.03
  IN2 w0.122: v3(256.96,41.16) 256.88,41.07 247.12,41.07 245.39,39.34 237.54,39.34 228.13,29.93 194.74,29.93 193.39,31.28 188.87,31.28 187.36,32.79 183.95,32.79 181.68,35.06 181.34,35.06 180.75,35.65 176.48,35.65 176.1,36.03 174.55,36.03
  IN3 w0.122: v1(268,74.75) 268.44,74.31 268.44,72.86 271.73,69.56 271.73,67.42 271.9,67.26 271.9,64.32 272.56,63.66 272.56,56.99 v1(271.4,55.83)
  BOTTOM w0.102: UH4.C37 169.6,36.41 169.9,36.1 170.21,36.1 170.37,36.27 v1(170.96,36.27) ; v1(271.4,55.83) 270.99,55.42 270.06,55.42 268.77,54.13 U37.17 U39.17 265.03,54.13 263.81,52.91 263.81,46.21 262.46,44.87 262.46,39.06 261.5,38.1 JMINI3.10 256.5,38.1 255.84,38.76 255.84,40.75 256.25,41.16 v3(256.96,41.16)
LPC_LDRQ1#: length 151.7
  TOP w0.102: v1(270.4,74.21) 270.24,74.06 U46.A22 ; v1(166.07,35.44) 166.07,35.56 v2(166.43,35.91)
  IN2 w0.102: 174.55,39.27 174.53,39.24 172.9,39.24 170.56,36.9 169.23,36.9 168.26,35.93 166.55,35.93 v1(166.07,35.44)
  IN2 w0.122: 174.55,39.27 176.88,39.27 177.32,38.82 179.03,38.82 179.35,38.5 180.56,38.5 184.38,34.67 188,34.67 190.15,32.52 193.91,32.52 195.25,31.18 227.61,31.18 237.02,40.59 244.49,40.59 247.79,43.88 254.89,43.88 256.92,45.91 273.21,45.91 v1(273.63,46.33)
  IN3 w0.122: v1(273.63,46.33) 271.38,48.58 271.38,54.51 271.89,55.02 271.89,55.96 272.81,56.89 272.81,68.84 269.93,71.72 269.93,73.75 v1(270.4,74.21)
  BOTTOM w0.102: v1(166.07,35.44) 166.41,35.78 UH4.K36
LPC_LDRQ#_MEC: length 12.7
  TOP w0.102: v1(283.52,68.09) 283.95,67.66 283.95,66.8 R823.1 284.52,65.34 v2(284.38,65.2) ; U51.B29 286.51,62.26 v1(286.55,62.21)
  IN3 w0.122: v1(283.52,68.09) 284.32,67.29 285.64,67.29 287.42,65.52 287.42,64.2 286.55,63.34 v1(286.55,62.21)
LPC_LFRAME#: length 169.8
  TOP w0.102: v1(285.66,62.26) 285.51,62.41 U51.B31 ; v1(261.99,39.88) 263.17,41.06 v2(263.17,44.51) 263.17,48.6 v1(264.7,50.12) ; v1(270.38,73.34) 270.16,73.56 U46.A21
  IN1 w0.084: v1(285.66,62.26) 285.65,62.28 285.65,63.05 282.17,66.53 281.75,66.53 274.75,73.53 270.56,73.53 v1(270.38,73.34)
  IN2 w0.102: v1(168.67,35.39) 169.14,35.86 171,35.86 171.32,35.54 171.4,35.54 171.49,35.44 171.5,35.44 171.54,35.41 172.07,35.41 172.41,35.75 174.55,35.75
  IN2 w0.122: v1(256.54,40.41) 256.3,40.65 247.05,40.65 245.46,39.06 237.72,39.06 228.35,29.68 194.64,29.68 193.29,31.03 188.77,31.03 187.26,32.54 183.84,32.54 181.58,34.81 181.24,34.81 180.65,35.4 176.38,35.4 176.03,35.75 174.55,35.75
  IN3 w0.122: v1(270.38,73.34) 270.38,71.63 273.06,68.94 273.06,53.63 272.66,53.23 v1(272.66,49.96)
  BOTTOM w0.102: v1(261.99,39.88) 261.99,39.43 261.46,38.9 JMINI3.8 258.05,38.9 v1(256.54,40.41) ; v1(168.67,35.39) 168.95,35.67 UH4.D36 ; v1(272.66,49.96) 272.09,49.96 271.65,50.4 269.06,50.4 268.58,50.88 U37.22 U39.22 265.45,50.88 v1(264.7,50.12)
