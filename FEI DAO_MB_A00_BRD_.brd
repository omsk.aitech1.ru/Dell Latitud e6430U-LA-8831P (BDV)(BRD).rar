# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS#4: length 66.9
  IN1 w0.091: v1(51.84,62.46) 52,62.46 52.33,62.13 52.33,61.74 52.52,61.55 53.54,61.55 56,64.01 61.77,64.01 61.9,64.14 68.74,64.14 69.68,65.07 72.44,65.07 72.53,64.98 72.53,64.82 72.76,64.59 73.1,64.59 73.33,64.82 73.33,64.98 73.42,65.07 84.49,65.07 85.7,63.86 100.21,63.86 101.08,62.99 104.61,62.99 105.41,62.19 105.41,61.96 v3(105.03,61.59)
  BOTTOM w0.102: U1.BG51 108.99,60.65 105.52,60.65 105.31,60.87 105.31,61.32 v3(105.03,61.59) ; JDIMM2.135 53.98,61.85 53.87,61.74 52.38,61.74 52.14,61.98 52.14,62.25 51.93,62.46 v1(51.84,62.46)
DDR_B_DQS#5: length 67.8
  IN1 w0.091: v1(59.42,69.54) 59.66,69.78 59.66,70.01 59.85,70.2 64.42,70.2 64.83,69.79 68.45,69.79 69.17,70.52 74.92,70.52 76.32,69.12 80.6,69.12 80.7,69.21 80.7,69.58 80.89,69.77 81.21,69.77 81.41,69.58 81.41,69.21 81.5,69.12 81.68,69.12 81.77,69.21 81.77,69.58 81.96,69.77 82.29,69.77 82.48,69.58 82.48,69.21 82.57,69.12 82.76,69.12 82.85,69.21 82.85,69.58 83.04,69.77 83.37,69.77 83.56,69.58 83.56,69.21 83.65,69.12 83.83,69.12 83.93,69.21 83.93,69.58 84.12,69.77 84.44,69.77 84.64,69.58 84.64,69.21 84.73,69.12 84.91,69.12 85,69.21 85,69.46 85.21,69.66 85.51,69.66 85.71,69.46 85.71,69.21 85.81,69.12 85.99,69.12 86.08,69.21 86.08,69.3 86.29,69.51 86.58,69.51 86.79,69.3 86.79,69.21 86.88,69.12 100.6,69.12 103.2,66.52 110.71,66.52 v3(110.92,66.73)
  BOTTOM w0.102: JDIMM2.152 62.45,66.95 62.34,67.06 62.01,67.06 61.83,67.24 61.83,67.97 61.2,68.61 60.03,68.61 59.62,69.02 59.62,69.34 59.42,69.54 v1(59.42,69.54) ; U1.BA59 111.98,65.25 112.32,65.59 112.32,65.86 112.25,65.93 112.25,66.37 111.89,66.73 v3(110.92,66.73)
DDR_B_DQS#6: length 76.7
  IN1 w0.091: v3(113.09,70.22) 113.09,70.33 112.97,70.46 112.06,70.46 111.71,70.11 105.56,70.11 101.24,74.43 74.51,74.43 72.92,76.02 64.91,76.02 63.92,75.03 60.07,75.03 59.7,74.65 56.7,74.65 53.76,71.72 52.39,71.72 52.19,71.92 52.19,72.68 52.09,72.78 v1(51.84,72.78)
  BOTTOM w0.102: JDIMM2.169 52.34,72.05 52.14,72.25 52.14,72.48 51.84,72.78 v1(51.84,72.78) ; v3(113.09,70.22) 113.09,70.34 113.18,70.42 113.71,70.42 113.92,70.22 113.92,69.26 114.29,68.89 114.3,68.89 114.34,68.84 114.35,68.84 114.41,68.79 114.41,66.01 114.51,65.9 U1.AT60
DDR_B_DQS#7: length 83.7
  IN1 w0.091: v3(117.18,69.7) 117.18,69.7 117.4,69.49 117.51,69.49 117.61,69.59 117.61,71.94 109.88,79.67 104.44,79.67 104.06,79.29 99.23,79.29 99.14,79.2 99.14,78.67 98.91,78.44 98.56,78.44 98.34,78.67 98.34,79.2 98.25,79.29 97.97,79.29 97.88,79.2 97.88,78.54 97.65,78.31 97.31,78.31 97.08,78.54 97.08,79.2 96.99,79.29 96.71,79.29 96.62,79.2 96.62,78.47 96.43,78.28 96.01,78.28 95.82,78.47 95.82,79.2 95.73,79.29 95.45,79.29 95.36,79.2 95.36,78.47 95.17,78.28 94.75,78.28 94.56,78.47 94.56,79.2 94.47,79.29 77.5,79.29 75.98,80.81 63.35,80.81 62.04,79.51 59.79,79.51 59.64,79.65 59.64,79.89 v1(59.42,80.11)
  BOTTOM w0.102: v1(59.42,80.11) 59.57,79.96 59.57,79.7 60.16,79.1 61.24,79.1 61.83,78.52 61.83,77.72 62.2,77.35 62.27,77.35 62.47,77.15 JDIMM2.186 ; U1.AK59 117.91,65.27 118.24,65.6 118.24,68.98 117.7,69.53 117.35,69.53 117.18,69.7 v3(117.18,69.7)
DDR_B_MA0: length 69.6
  IN1 w0.084: v1(104.68,51.7) 104.68,52.15 104.56,52.28 103.69,52.28 103.56,52.15 103.56,51.68 103.43,51.56 103.24,51.56 103.12,51.68 103.12,51.81 102.99,51.94 102.8,51.94 102.67,51.81 102.67,51.68 102.54,51.56 102.35,51.56 102.23,51.68 102.23,51.74 102.1,51.87 101.87,51.87
  IN1 w0.132: 101.87,51.87 94.21,51.87 93.08,50.74 92.58,50.74 92.45,50.61 92.45,50.22 92.32,50.1 91.69,50.1 91.56,50.22 91.56,50.35 91.43,50.48 91.05,50.48 90.93,50.35 90.93,50.23 90.79,50.1 90.53,50.1 90.4,50.23 90.4,50.35 90.26,50.48 90,50.48 89.87,50.35 89.87,50.23 89.74,50.1 89.47,50.1 89.34,50.23 89.34,50.35 89.21,50.48 88.94,50.48 88.81,50.35 88.81,50.23 88.68,50.1 88.42,50.1 88.28,50.23 88.28,50.35 88.15,50.48 87.89,50.48 87.76,50.35 87.76,50.23 87.62,50.1 87.36,50.1 87.23,50.23 87.23,50.35 87.09,50.48 86.83,50.48 86.7,50.35 86.7,50.23 86.57,50.1 86.3,50.1 86.17,50.23 86.17,50.35 86.04,50.48 85.77,50.48 85.64,50.35 85.64,50.23 85.51,50.1 85.25,50.1 85.11,50.23 85.11,50.35 84.98,50.48 84.72,50.48 84.59,50.35 84.59,50.23 84.45,50.1 84.19,50.1 84.06,50.23 84.06,50.35 83.92,50.48 83.66,50.48 83.53,50.35 83.53,50.23 83.4,50.1 83.13,50.1 83,50.23 83,50.35 82.87,50.48 82.6,50.48 82.47,50.35 82.47,50.23 82.34,50.1 82.07,50.1 81.95,50.22 81.95,50.35 81.82,50.48 81.51,50.48 81.38,50.35 81.38,50.22 81.26,50.1 77.69,50.1 77.56,50.23 77.56,50.35 77.43,50.47 77.16,50.47 77.03,50.35 77.03,50.23 76.9,50.1 76.64,50.1 76.5,50.23 76.5,50.35 76.38,50.48 76.1,50.48 75.98,50.35 75.98,50.23 75.84,50.1 75.57,50.1 75.44,50.22 75.44,50.25 75.32,50.38 75.07,50.38 74.95,50.25 74.95,50.22 74.82,50.1 74.13,50.1 74,50.23 74,50.35 73.87,50.48 73.6,50.48 73.47,50.35 73.47,50.23 73.34,50.1 69.06,50.1 68.93,50.22 68.93,50.35 68.8,50.48 68.53,50.48 68.4,50.35 68.4,49.08 68.28,48.96 68,48.96 67.87,49.08 67.87,50.35 67.75,50.48 67.47,50.48 67.35,50.35 67.35,49.78 67.22,49.65 66.94,49.65 66.82,49.78 66.82,50.32 66.66,50.48 66.41,50.48 66.29,50.35 66.29,49.08 66.16,48.96 65.85,48.96 65.73,49.08 65.73,50.8 64.86,51.67 61.02,51.67 60.55,51.2 v3(60.44,51.2)
  BOTTOM w0.102: v1(104.68,51.7) 105.27,51.11 108.83,51.11 109.49,51.11 U1.BF32
  BOTTOM w0.17: v3(60.44,51.2) 61.04,50.59 62.04,50.59 62.21,50.75 JDIMM2.98
DDR_B_MA1: length 70
  IN1 w0.084: 101.87,50.9 107.15,50.9 v1(107.95,51.7)
  IN1 w0.132: v3(51.46,49.27) 51.46,48.95 51.33,48.82 50.38,48.82 50.25,48.95 50.25,49.69 50.38,49.81 54.22,49.81 54.69,50.28 61.78,50.28 63.9,48.16 69.07,48.16 69.2,48.29 69.2,49.17 69.33,49.3 73.32,49.3 73.45,49.17 73.45,49.09 73.58,48.97 73.85,48.97 73.98,49.09 73.98,49.17 74.1,49.3 92.77,49.3 94.37,50.9 101.87,50.9
  BOTTOM w0.102: v1(107.95,51.7) 108.33,51.31 108.75,51.31 108.75,51.31 109.2,51.31 109.39,51.5 109.68,51.5 U1.BE33
  BOTTOM w0.17: JDIMM2.97 52.64,50.45 v3(51.46,49.27)
DDR_B_MA2: length 70.3
  IN1 w0.084: v1(107.29,51.7) 106.9,51.3 101.87,51.3
  IN1 w0.132: v3(58.91,51.2) 59.43,50.68 61.55,50.68 61.69,50.81 61.69,51.14 61.81,51.27 62.09,51.27 62.21,51.14 62.21,50.53 62.34,50.41 62.62,50.41 62.74,50.53 62.74,51.14 62.87,51.27 63.14,51.27 63.27,51.14 63.27,49.35 63.4,49.22 63.67,49.22 63.8,49.35 63.8,51.14 63.93,51.27 64.22,51.27 64.34,51.14 64.34,50.64 64.47,50.52 65.2,50.52 65.33,50.39 65.33,50.12 65.2,50 64.45,50 64.33,49.87 64.33,48.68 64.45,48.56 64.71,48.56 64.84,48.68 64.84,48.76 64.96,48.89 65.22,48.89 65.35,48.76 65.35,48.68 65.47,48.56 66.79,48.56 66.91,48.69 66.91,49.12 67.04,49.25 67.32,49.25 67.44,49.12 67.44,48.68 67.57,48.56 68.67,48.56 68.8,48.68 68.8,49.57 68.93,49.7 92.6,49.7 94.2,51.3 101.87,51.3
  BOTTOM w0.102: v1(107.29,51.7) 107.77,52.17 108.7,52.17 108.8,52.07 110.28,52.07 U1.BD33
  BOTTOM w0.17: v3(58.91,51.2) 59.96,50.15 JDIMM2.96
DDR_B_MA3: length 74.3
  IN1 w0.084: v1(114.1,50.21) 113.71,50.61 110.23,50.61 110.13,50.5 101.87,50.5
  IN1 w0.132: v3(52.98,49.27) 53.43,48.82 54.54,48.82 54.67,48.95 54.67,49.7 54.79,49.82 61.67,49.82 63.73,47.76 69.41,47.76 69.54,47.89 69.54,48.03 69.67,48.16 69.94,48.16 70.07,48.03 70.07,47.48 70.2,47.35 70.47,47.35 70.6,47.48 70.6,48.09 70.73,48.21 71,48.21 71.13,48.09 71.13,47.48 71.25,47.35 71.53,47.35 71.66,47.48 71.66,48.03 71.78,48.16 72.06,48.16 72.18,48.03 72.18,47.45 72.31,47.32 72.59,47.32 72.71,47.45 72.71,48.04 72.84,48.17 73.11,48.17 73.24,48.04 73.24,47.47 73.37,47.34 73.64,47.34 73.77,47.47 73.77,48.44 73.9,48.57 74.17,48.57 74.3,48.44 74.3,48.09 74.42,47.96 75.06,47.96 75.19,48.09 75.19,48.77 75.32,48.9 92.93,48.9 94.53,50.5 101.87,50.5
  BOTTOM w0.102: U1.AU30 113.78,50.53 v1(114.1,50.21)
  BOTTOM w0.17: v3(52.98,49.27) 53.57,49.85 JDIMM2.95
DDR_B_MA4: length 71.4
  IN1 w0.084: 101.87,48.91 103.18,48.91 103.39,49.12 106.56,49.12 v1(107.21,49.78)
  IN1 w0.132: v3(58.91,48.45) 59.97,47.4 61.84,47.4 63.62,45.61 67.33,45.61 67.93,45.01 74.46,45.01 75.37,45.92 86.51,45.92 86.64,46.05 86.64,47.18 86.77,47.3 87.05,47.3 87.17,47.18 87.17,46.05 87.3,45.92 87.57,45.92 87.7,46.05 87.7,47.18 87.83,47.3 88.1,47.3 88.23,47.18 88.23,46.05 88.36,45.92 88.63,45.92 88.76,46.05 88.76,47.18 88.88,47.3 89.16,47.3 89.29,47.18 89.29,46.05 89.42,45.92 89.68,45.92 89.81,46.05 89.81,47.18 89.94,47.3 90.22,47.3 90.34,47.18 90.34,46.05 90.47,45.92 90.74,45.92 90.87,46.05 90.87,47.18 91,47.3 91.27,47.3 91.4,47.18 91.4,46.81 91.53,46.68 91.81,46.68 91.94,46.81 91.94,47.02 92.11,47.19 93.48,47.19 95.19,48.91 101.87,48.91
  BOTTOM w0.102: v1(107.21,49.78) 107.68,50.24 110.28,50.24 U1.BD30
  BOTTOM w0.17: v3(58.91,48.45) 59.41,48.95 JDIMM2.92
DDR_B_MA5: length 73.5
  IN1 w0.084: 101.87,50.1 104.71,50.1 104.86,50.25 110.23,50.25 110.7,49.78 113.02,49.78 v1(113.45,50.21)
  IN1 w0.132: 101.87,50.1 94.7,50.1 93.1,48.5 81.85,48.5 81.1,47.75 75.42,47.75 75.03,47.36 74.41,47.36 74,46.94 73.41,46.94 72.8,46.33 69.63,46.33 68.66,47.3 63.63,47.3 61.56,49.37 57.43,49.37 57.31,49.24 57.31,48.89 57.18,48.76 56.9,48.76 56.78,48.89 56.78,49.3 56.65,49.42 56.38,49.42 56.25,49.3 56.25,48.92 56.12,48.79 55.85,48.79 55.72,48.92 55.72,49.3 55.59,49.42 55.32,49.42 55.19,49.3 55.19,48.36 55.07,48.24 52.42,48.24 v3(51.46,47.28)
  BOTTOM w0.102: v1(113.45,50.21) 113.13,50.53 U1.AV30
  BOTTOM w0.17: v3(51.46,47.28) 52.83,48.65 JDIMM2.91
DDR_B_MA6: length 71.5
  IN1 w0.084: 103.04,49.31 105.82,49.31 105.93,49.42 v1(105.93,49.78)
  IN1 w0.132: v3(60.44,48.45) 60.23,48.45 60.1,48.33 60.1,47.92 60.23,47.8 62,47.8 63.79,46.01 66.26,46.01 66.34,46.09 66.34,46.33 66.41,46.41 66.78,46.41 66.86,46.33 66.86,46.09 66.93,46.01 67.29,46.01 67.37,46.09 67.37,46.43 67.45,46.51 67.87,46.51 67.95,46.43 67.95,45.56 68.08,45.43 68.35,45.43 68.48,45.56 68.48,45.84 68.55,45.92 68.92,45.92 68.99,45.84 68.99,45.56 69.12,45.43 73.34,45.43 73.42,45.51 73.42,45.82 73.49,45.9 73.82,45.9 73.89,45.82 73.89,45.51 73.97,45.43 74.31,45.43 74.39,45.51 74.39,45.82 74.47,45.9 74.78,45.9 75.2,46.32 75.58,46.32 75.71,46.45 75.71,46.83 75.83,46.95 76.15,46.95 76.28,46.82 76.28,46.45 76.4,46.32 76.68,46.32 76.81,46.45 76.81,46.82 76.94,46.95 77.2,46.95 77.33,46.82 77.33,46.45 77.46,46.32 77.74,46.32 77.86,46.45 77.86,46.82 77.99,46.95 78.26,46.95 78.39,46.82 78.39,46.45 78.52,46.32 78.79,46.32 78.92,46.45 78.92,46.82 79.05,46.95 81.31,46.95 81.44,46.82 81.44,46.39 81.51,46.32 81.95,46.32 82.02,46.4 82.02,47.55 82.1,47.62 82.47,47.62 82.55,47.55 82.55,46.4 82.62,46.32 83,46.32 83.08,46.4 83.08,47.63 83.15,47.7 83.53,47.7 83.6,47.63 83.6,46.98 83.68,46.9 84.06,46.9 84.13,46.98 84.13,47.63 84.21,47.7 84.58,47.7 84.66,47.63 84.66,46.94 84.74,46.86 85.11,46.86 85.19,46.94 85.19,47.63 85.27,47.7 85.64,47.7 85.72,47.63 85.72,46.94 85.79,46.86 86.17,46.86 86.25,46.94 86.25,47.57 86.38,47.7 93.43,47.7 95.03,49.31 103.04,49.31
  BOTTOM w0.102: U1.BG30 109.01,50.45 106.61,50.45 v1(105.93,49.78)
  BOTTOM w0.17: v3(60.44,48.45) 61.07,47.82 61.45,47.82 61.98,48.35 JDIMM2.90
DDR_B_MA7: length 72.2
  IN1 w0.084: v1(107.83,49.78) 106.99,48.93 103.86,48.93 103.43,48.51 101.87,48.51
  IN1 w0.132: v3(60.44,46.48) 60.23,46.48 60.1,46.61 60.1,46.81 60.23,46.94 61.65,46.94 63.38,45.21 65.83,45.21 66.5,44.54 75.28,44.54 75.41,44.67 75.41,45.4 75.53,45.52 75.81,45.52 75.93,45.4 75.93,44.97 76.06,44.84 76.34,44.84 76.46,44.97 76.46,45.4 76.59,45.52 80.9,45.52 81.03,45.39 81.03,44.96 81.16,44.83 81.43,44.83 81.56,44.96 81.56,45.39 81.69,45.52 81.96,45.52 82.09,45.39 82.09,44.96 82.22,44.83 82.49,44.83 82.62,44.96 82.62,45.39 82.75,45.52 83.01,45.52 83.15,45.39 83.15,44.96 83.28,44.83 83.54,44.83 83.67,44.96 83.67,45.39 83.81,45.52 84.07,45.52 84.2,45.39 84.2,44.96 84.33,44.83 84.6,44.83 84.73,44.96 84.73,45.39 84.86,45.52 85.13,45.52 85.26,45.39 85.26,44.96 85.39,44.83 85.66,44.83 85.79,44.96 85.79,45.39 85.92,45.52 86.18,45.52 86.32,45.39 86.32,44.96 86.45,44.83 86.71,44.83 86.84,44.96 86.84,45.39 86.98,45.52 87.24,45.52 87.37,45.39 87.37,44.96 87.5,44.83 87.77,44.83 87.9,44.96 87.9,45.39 88.03,45.52 88.3,45.52 88.43,45.39 88.43,44.96 88.56,44.83 88.83,44.83 88.96,44.96 88.96,45.39 89.09,45.52 89.35,45.52 89.49,45.39 89.49,44.96 89.62,44.83 89.88,44.83 90.01,44.96 90.01,45.39 90.15,45.52 90.41,45.52 90.54,45.39 90.54,44.94 90.67,44.82 91.14,44.82 91.27,44.94 91.27,46.1 91.4,46.22 91.67,46.22 91.8,46.1 91.8,45.47 91.93,45.35 92.2,45.35 92.33,45.47 92.33,46.64 92.47,46.79 93.64,46.79 95.36,48.51 101.87,48.51
  BOTTOM w0.102: U1.BD29 110.33,50.04 108.09,50.04 v1(107.83,49.78)
  BOTTOM w0.17: v3(60.44,46.48) 61.1,47.15 JDIMM2.86
DDR_B_MA8: length 70.6
  IN1 w0.084: 101.87,49.7 105.22,49.7 v1(105.29,49.78)
  IN1 w0.132: 101.87,49.7 94.86,49.7 93.26,48.1 82.01,48.1 81.26,47.35 75.67,47.35 74.61,46.3 73.33,46.3 72.89,45.86 69.54,45.86 68.49,46.9 66.34,46.9 65.85,46.41 63.96,46.41 61.46,48.91 57.83,48.91 57.7,48.78 57.7,48.54 57.58,48.41 57.36,48.41 57.23,48.28 57.23,47.28 57.11,47.16 56.42,47.16 56.3,47.28 56.3,48.26 56.17,48.39 55.91,48.39 55.78,48.26 55.78,46.87 55.65,46.74 55.38,46.74 55.25,46.87 55.25,47.71 55.12,47.84 54.85,47.84 54.72,47.71 54.72,46.87 54.6,46.74 54.32,46.74 54.19,46.87 54.19,47.65 54.07,47.78 53.11,47.78 52.98,47.65 v3(52.98,47.28)
  BOTTOM w0.102: v1(105.29,49.78) 106.42,50.9 108.92,50.9 108.92,50.91 109.36,50.91 109.67,50.6 U1.BE30
  BOTTOM w0.17: v3(52.98,47.28) 53.76,48.05 JDIMM2.89
DDR_B_MA9: length 73.2
  IN1 w0.132: v1(100.81,45.62) 99.39,45.62 99.26,45.75 99.26,46.12 99.13,46.25 98.86,46.25 98.73,46.12 98.73,45.75 98.6,45.62 98.34,45.62 98.2,45.75 98.2,46.12 98.07,46.25 97.81,46.25 97.68,46.12 97.68,45.75 97.54,45.62 97.28,45.62 97.15,45.75 97.15,46.12 97.02,46.25 96.75,46.25 96.62,46.12 96.62,42.96 96.48,42.82 77.33,42.82 77.05,42.54 62.82,42.54 61.98,43.37 56.45,43.37 55.3,44.52 51.36,44.52 51.12,44.76 51.12,45.2 51.29,45.37 v3(51.46,45.37)
  BOTTOM w0.102: 108.53,49.02 108.64,49.02 109.02,49.4 109.28,49.4 109.61,49.74 U1.BE28
  BOTTOM w0.17: v3(51.46,45.37) 52.4,46.31 53.31,46.31 53.85,46.85 JDIMM2.85 ; v1(100.81,45.62) 100.81,47.13 102.7,49.02 108.53,49.02
DDR_B_MA10: length 70.3
  IN1 w0.084: v1(104.07,54.09) 103.67,54.49 101.87,54.49
  IN1 w0.132: 101.87,54.49 92.01,54.49 90.01,52.49 69.52,52.49 68.42,53.59 67.11,53.59 66.84,53.32 65.89,53.32 65.6,53.61 64.65,53.61 64.01,54.25 58.95,54.25 58.72,54.02 58.72,53.03 58.59,52.9 58.32,52.9 58.19,53.04 58.19,54.15 58.05,54.28 57.09,54.28 55.94,53.13 51.55,53.13 51.43,53.25 51.43,53.7 v3(51.46,53.73)
  BOTTOM w0.102: U1.BD43 110.3,56.19 109.06,56.19 108.91,56.34 105.14,56.34 104.07,55.27 v1(104.07,54.09)
  BOTTOM w0.17: v3(51.46,53.73) 52.02,53.17 53.88,53.17 54.16,53.45 JDIMM2.107
DDR_B_MA11: length 71.6
  IN1 w0.084: 101.87,48.11 103.73,48.11 104.37,48.75 108.5,48.75 109.34,49.59 114.69,49.59 v1(115.09,49.19)
  IN1 w0.132: v3(58.91,46.48) 58.91,46.75 58.79,46.88 58.36,46.88 58.23,47.01 58.23,47.28 58.36,47.41 58.59,47.41 58.72,47.53 58.72,47.81 58.59,47.94 57.83,47.94 57.7,47.81 57.7,46.12 57.83,45.99 61.95,45.99 63.13,44.81 65.62,44.81 66.29,44.14 76.2,44.14 76.97,44.91 80.39,44.91 80.89,44.42 91.83,44.42 95.53,48.11 101.87,48.11
  BOTTOM w0.102: v1(115.09,49.19) 114.74,49.54 U1.AT28
  BOTTOM w0.17: v3(58.91,46.48) 59.52,45.88 61.45,45.88 62.12,46.55 JDIMM2.84
DDR_B_MA12: length 74.8
  IN1 w0.084: 101.87,47.71 103.78,47.71 104.63,48.56 108.96,48.56 109.16,48.76 113.35,48.76 v1(113.78,49.19)
  IN1 w0.132: 101.87,47.71 95.69,47.71 92,44.02 76.84,44.02 76.55,43.73 66.13,43.73 65.45,44.42 62.88,44.42 61.76,45.53 56.84,45.53 56.71,45.66 56.71,46.22 56.58,46.35 56.26,46.35 56.13,46.21 56.13,45.04 56,44.92 55.73,44.92 55.6,45.04 55.6,46.21 55.47,46.35 55.2,46.35 55.07,46.21 55.07,45.04 54.94,44.92 54.67,44.92 54.54,45.04 54.54,46.21 54.41,46.35 52.44,46.35 52.32,46.22 52.32,45.95 52.44,45.82 52.86,45.82 52.98,45.69 v3(52.98,45.37)
  BOTTOM w0.102: U1.AV28 113.78,49.3 v1(113.78,49.19)
  BOTTOM w0.17: JDIMM2.83 53.86,46.25 v3(52.98,45.37)
DDR_B_MA13: length 68.8
  IN1 w0.084: v1(106.56,57.73) 106.54,57.75 102.61,57.75 102.21,58.16 101.87,58.16
  IN1 w0.132: 101.87,58.16 94.76,58.16 93.74,59.18 88.63,59.18 87.41,60.4 84.77,60.4 84.64,60.27 84.64,59.33 84.52,59.2 73.9,59.2 73.07,60.04 65.91,60.04 65.56,60.4 64.66,60.4 64.29,60.02 62.35,60.02 61.59,59.27 56.11,59.27 55.99,59.14 55.99,57.62 55.86,57.49 52.02,57.49 v3(51.46,58.05)
  BOTTOM w0.102: v1(106.56,57.73) 107.21,58.38 108.83,58.38 109.02,58.19 110.07,58.19 110.29,58.4 U1.BD46
  BOTTOM w0.17: v3(51.46,58.05) 52.68,56.83 54.1,56.83 54.32,57.05 JDIMM2.119
DDR_B_MA14: length 70.8
  IN1 w0.084: v1(114.33,48.2) 113.93,47.8 109.46,47.8 108.95,47.29 101.87,47.29
  IN1 w0.132: 101.87,47.29 95.84,47.29 93.89,45.35 93.89,43.9 93.76,43.77 93.47,43.77 93.34,43.9 93.34,44.27 93.21,44.39 92.94,44.39 92.81,44.27 92.81,43.75 92.68,43.62 77,43.62 76.72,43.34 65.97,43.34 65.29,44.02 62.72,44.02 61.6,45.14 56.98,45.14 56.85,45.01 56.85,44.71 56.98,44.59 58.79,44.59 58.91,44.46 v3(58.91,43.93)
  BOTTOM w0.102: U1.AT26 114.64,48.51 v1(114.33,48.2)
  BOTTOM w0.17: JDIMM2.80 60.33,45.35 v3(58.91,43.93)
DDR_B_MA15: length 71.4
  IN1 w0.084: 101.87,46.9 108.93,46.9 108.96,46.92 113.99,46.92 114.05,46.99 v1(114.05,47.27)
  IN1 w0.132: v3(60.44,43.93) 60.34,44.03 60.34,44.61 60.47,44.74 61.43,44.74 62.55,43.62 65.12,43.62 65.8,42.94 76.88,42.94 77.17,43.22 96.09,43.22 96.22,43.35 96.22,43.62 96.09,43.75 94.42,43.75 94.29,43.88 94.29,44.15 94.42,44.28 96.07,44.28 96.19,44.4 96.19,44.68 96.07,44.81 94.44,44.81 94.32,44.93 94.32,45.21 94.44,45.33 96.04,45.33 96.17,45.46 96.17,45.74 96.04,45.86 95.5,45.86 95.37,45.99 95.37,46.26 95.5,46.39 95.74,46.39 95.88,46.52 95.88,46.77 96,46.9 101.87,46.9
  BOTTOM w0.102: v1(114.05,47.27) 113.73,46.95 U1.AU22
  BOTTOM w0.17: v3(60.44,43.93) 61.26,44.75 JDIMM2.78
DDR_B_RAS#: length 69.8
  IN1 w0.084: v1(107.31,55.73) 106.87,55.29 101.87,55.29
  IN1 w0.132: 101.87,55.29 87.47,55.29 87.34,55.15 87.34,54.53 87.21,54.4 86.94,54.4 86.81,54.53 86.81,55.15 86.68,55.29 86.3,55.29 86.17,55.15 86.17,53.46 86.03,53.32 85.77,53.32 85.64,53.46 85.64,55.15 85.51,55.29 85.24,55.29 85.11,55.15 85.11,53.46 84.98,53.32 84.71,53.32 84.58,53.46 84.58,55.15 84.45,55.29 84.18,55.29 84.05,55.15 84.05,53.46 83.92,53.32 83.66,53.32 83.52,53.46 83.52,55.15 83.39,55.29 83.13,55.29 83,55.15 83,53.46 82.86,53.32 82.47,53.32 82.34,53.45 82.34,54.45 82.21,54.58 81.89,54.58 81.77,54.45 81.77,54.21 81.64,54.08 76.45,54.08 75.22,55.31 67.89,55.31 66.96,56.24 64.62,56.24 63.96,55.59 60.93,55.59 v3(60.44,55.1)
  BOTTOM w0.102: U1.BF40 107.93,55.11 v1(107.31,55.73)
  BOTTOM w0.17: v3(60.44,55.1) 60.93,54.61 62.11,54.61 62.36,54.35 JDIMM2.110
DDR_B_WE#: length 73
  IN1 w0.084: 101.87,57.76 102.09,57.76 103.03,56.82 106.3,56.82 v1(107.21,57.73)
  IN1 w0.132: v3(51.46,55.76) 51.46,56.77 51.78,57.09 56.03,57.09 57.6,58.67 61.72,58.67 62.4,59.34 65.76,59.34 66.06,59.64 68.22,59.64 69.07,58.78 84.91,58.78 85.04,58.92 85.04,59.83 85.18,59.97 85.44,59.97 85.57,59.83 85.57,58.92 85.7,58.78 85.97,58.78 86.1,58.92 86.1,59.83 86.23,59.97 86.5,59.97 86.63,59.83 86.63,58.92 86.76,58.78 87.02,58.78 87.16,58.92 87.16,59.56 87.28,59.69 87.56,59.69 87.69,59.56 87.69,58.92 87.82,58.78 93.58,58.78 94.6,57.76 101.87,57.76
  BOTTOM w0.102: U1.BD45 110.29,57.98 108.89,57.98 108.7,58.17 107.65,58.17 v1(107.21,57.73)
  BOTTOM w0.17: JDIMM2.113 54,55.25 53.7,54.95 52.28,54.95 v3(51.46,55.76)
DDR_CKE0_DIMMA: length 55
  IN4 w0.084: v1(112.38,48.2) 111.95,47.77 110.45,47.77 109.35,46.67 108.63,46.67 108.02,46.06
  IN4 w0.132: 108.02,46.06 100.62,46.06 99.67,45.11 99.67,44.34 98.86,43.53 77.85,43.53 77.42,43.96 76.82,43.96 76.58,44.19 75.7,44.19 75.6,44.29 75.6,45.2 75.47,45.33 75.05,45.33 74.92,45.2 74.92,44.41 74.8,44.28 74.35,44.28 74.22,44.41 74.22,45.2 74.1,45.33 73.7,45.33 73.58,45.2 73.58,44.43 73.45,44.31 73.06,44.31 72.93,44.43 72.93,45.2 72.8,45.33 72.4,45.33 72.27,45.2 72.27,44.46 72.14,44.33 71.65,44.33 71.52,44.46 71.52,45.84 v3(70.45,46.9)
  BOTTOM w0.102: U1.AY26 112.69,48.51 112.64,48.47 v1(112.38,48.2)
  BOTTOM w0.17: v3(70.45,46.9) 69.8,46.25 JDIMM1.73
DDR_CKE1_DIMMA: length 53
  IN4 w0.084: v1(111.08,48.2) 110.41,48.2 109.21,47 108.58,47 108.04,46.46
  IN4 w0.132: 108.04,46.46 100.45,46.46 99.17,45.18 98.9,45.18 98.8,45.07 98.8,44.03 98.7,43.93 98.39,43.93 98.29,44.03 98.29,45.07 98.19,45.18 97.87,45.18 97.77,45.07 97.77,44.03 97.67,43.93 97.37,43.93 97.24,44.06 97.24,45.07 97.13,45.18 96.81,45.18 96.71,45.07 96.71,44.06 96.57,43.93 96.31,43.93 96.18,44.06 96.18,45.07 96.08,45.18 95.75,45.18 95.65,45.07 95.65,44.06 95.52,43.93 95.25,43.93 95.12,44.06 95.12,44.62 95.02,44.72 94.7,44.72 94.59,44.62 94.59,44.03 94.49,43.93 94.17,43.93 94.07,44.03 94.07,44.5 93.96,44.6 93.64,44.6 93.54,44.5 93.54,44.03 93.44,43.93 93.11,43.93 93.01,44.03 93.01,44.5 92.91,44.6 92.58,44.6 92.48,44.5 92.48,44.03 92.38,43.93 92.05,43.93 91.95,44.03 91.95,44.5 91.85,44.6 91.53,44.6 91.42,44.5 91.42,44.06 91.29,43.93 78.02,43.93 77.92,44.03 v3(77.92,44.47)
  BOTTOM w0.102: v1(111.08,48.2) 111.39,48.51 U1.BB26
  BOTTOM w0.165: 77.4,46.55 77.63,46.32 77.63,45.73 77.5,45.6 76.84,45.6 76.71,45.47 76.71,45.06 76.84,44.93 77.79,44.93 77.92,44.8 v3(77.92,44.47)
  BOTTOM w0.17: JDIMM1.74 77.4,46.55
DDR_CKE2_DIMMB: length 74.7
  IN1 w0.084: 101.87,44.35 103.17,45.66 109.6,45.66 110.16,46.22 113.12,46.22 113.12,46.22 114.11,46.22 114.72,46.83 114.98,46.83 v1(115.4,47.26)
  IN1 w0.132: v3(52.98,43.34) 55.57,40.76 62.23,40.76 62.71,40.28 83.95,40.28 84.08,40.41 84.08,41.05 84.21,41.18 84.48,41.18 84.61,41.05 84.61,40.41 84.74,40.28 85.01,40.28 85.14,40.41 85.14,41.05 85.27,41.18 85.54,41.18 85.67,41.05 85.67,40.41 85.8,40.28 86.06,40.28 86.2,40.41 86.2,41.05 86.33,41.18 86.59,41.18 86.72,41.05 86.72,40.41 86.86,40.28 87.12,40.28 87.25,40.41 87.25,41.05 87.38,41.18 97.13,41.18 99.84,43.89 101.41,43.89 101.87,44.35
  BOTTOM w0.102: U1.AR22 115.11,46.81 115.4,47.1 v1(115.4,47.26)
  BOTTOM w0.17: v3(52.98,43.34) 53.53,42.79 53.98,42.79 54.44,43.25 JDIMM2.73
DDR_CKE3_DIMMB: length 75.1
  IN1 w0.132: v3(60.36,41.87) 60.36,42.19 60.23,42.32 56.16,42.32 56.04,42.45 56.04,42.71 56.16,42.83 61.76,42.83 62.59,42 63.2,42 63.34,41.87 63.34,41.49 63.47,41.36 63.73,41.36 63.86,41.49 63.86,41.87 64,42 64.26,42 64.39,41.87 64.39,41.49 64.52,41.36 64.79,41.36 64.92,41.49 64.92,41.87 65.05,42 65.32,42 65.45,41.87 65.45,41.49 65.58,41.36 65.85,41.36 65.98,41.49 65.98,41.87 66.11,42 67.16,42 67.29,41.87 67.29,41.5 67.42,41.37 67.69,41.37 67.82,41.5 67.82,41.87 67.95,42 68.21,42 68.35,41.87 68.35,41.5 68.48,41.37 68.74,41.37 68.87,41.5 68.87,41.87 69.01,42 77.27,42 77.56,42.28 96.7,42.28 97.16,42.74 97.16,43.89 97.29,44.02 98.37,44.02 98.51,44.15 98.51,44.41 98.37,44.55 97.29,44.55 97.16,44.68 97.16,44.99 97.24,45.07 100.91,45.07 v1(101.46,45.62)
  BOTTOM w0.102: 108.57,48.74 108.83,48.74 109.27,49.18 U1.BF27
  BOTTOM w0.17: 108.57,48.74 103.4,48.74 101.46,46.8 v1(101.46,45.62) ; JDIMM2.74 62.04,43.55 61.32,42.83 60.91,42.83 60.36,42.28 v3(60.36,41.87)
DDR_CS0_DIMMA#: length 54.2
  IN4 w0.084: 101.87,56.9 101.89,56.87 102.07,56.87 102.63,56.31 105.68,56.31 105.87,56.13 106.17,56.13 107.91,54.38 110.96,54.38 v1(111.19,54.62)
  IN4 w0.132: 101.87,56.9 94.15,56.9 91.77,59.28 91.66,59.28 91.57,59.37 91.57,59.6 91.48,59.7 91.18,59.7 91.09,59.6 91.09,59.37 91,59.28 90.64,59.28 90.55,59.37 90.55,60.06 90.45,60.16 90.13,60.16 90.02,60.06 90.02,59.37 89.93,59.28 89.59,59.28 89.5,59.37 89.5,60.06 89.39,60.16 89.07,60.16 88.97,60.06 88.97,59.37 88.88,59.28 88.53,59.28 88.44,59.37 88.44,60.06 88.34,60.16 88.01,60.16 87.91,60.06 87.91,59.37 87.82,59.28 87.47,59.28 87.38,59.37 87.38,60.06 87.28,60.16 86.96,60.16 86.85,60.06 86.85,59.37 86.76,59.28 86.42,59.28 86.33,59.37 86.33,60.06 86.22,60.16 85.9,60.16 85.8,60.06 85.8,59.37 85.71,59.28 85.36,59.28 85.27,59.37 85.27,60.06 85.17,60.16 84.84,60.16 84.74,60.06 84.74,59.37 84.65,59.28 84.3,59.28 84.21,59.37 84.21,60.06 84.11,60.16 83.79,60.16 83.68,60.06 83.68,59.37 83.59,59.28 83.25,59.28 83.16,59.37 83.16,60.06 83.05,60.16 82.73,60.16 82.63,60.06 82.63,59.37 82.54,59.28 82.19,59.28 82.1,59.37 82.1,60.06 82,60.16 81.67,60.16 81.57,60.06 81.57,59.41 81.44,59.28 80.01,59.28 79.91,59.38 79.91,59.63 80.04,59.75 v3(80.23,59.75)
  BOTTOM w0.102: U1.BB40 111.52,54.94 v1(111.19,54.62)
  BOTTOM w0.165: v3(80.23,59.75) 80.23,58.86 79.71,58.34 77.71,58.34 77.5,58.55
  BOTTOM w0.17: JDIMM1.114 77.5,58.55
DDR_CS1_DIMMA#: length 52.1
  IN4 w0.084: v1(111.65,56.06) 111.65,55.89 111.51,55.76 110.76,55.76 110.17,56.34 109.72,56.34 109.01,57.05 106.25,57.05 106.07,57.24 105.27,57.24 104.42,58.09 103.93,58.09 103.03,58.99 102.05,58.99 101.87,59.17
  IN4 w0.132: 101.87,59.17 95.24,59.17 91.01,63.39 82.55,63.39 82.07,62.92 81.31,62.92 80.97,62.58 79.24,62.58 79.11,62.45 79.11,62.14 79.01,62.04 78.68,62.04 78.58,62.14 78.58,62.45 78.45,62.58 77.34,62.58 77.21,62.45 77.21,62.14 77.1,62.04 76.78,62.04 76.68,62.14 76.68,62.45 76.55,62.58 76.28,62.58 76.15,62.45 76.15,62.14 76.05,62.04 75.72,62.04 75.62,62.14 75.62,62.45 75.49,62.58 74.05,62.58 73.94,62.48 73.94,62.14 73.84,62.04 73.49,62.04 73.39,62.14 73.39,62.48 73.28,62.58 71,62.58 v3(70.45,62.03)
  BOTTOM w0.102: U1.BC41 111.19,55.6 111.36,55.76 v1(111.65,56.06)
  BOTTOM w0.165: 69.42,60.65 70.45,61.68 v3(70.45,62.03)
  BOTTOM w0.17: 69.42,60.65 69.42,60.65 JDIMM1.121
DDR_CS2_DIMMB#: length 72.7
  IN1 w0.084: 101.87,56.27 107.42,56.27 v1(107.96,55.73)
  IN1 w0.132: v3(58.91,56.97) 58.81,56.86 58.81,56.65 58.93,56.52 63.3,56.52 64.63,57.85 66.94,57.85 68.52,56.27 85.09,56.27 85.23,56.4 85.23,57.17 85.36,57.3 85.62,57.3 85.75,57.17 85.75,56.4 85.89,56.27 86.24,56.27 86.37,56.4 86.37,57.19 86.5,57.32 86.77,57.32 86.9,57.19 86.9,56.4 87.03,56.27 87.3,56.27 87.43,56.4 87.43,57.19 87.56,57.32 87.82,57.32 87.96,57.19 87.96,56.4 88.09,56.27 88.35,56.27 88.48,56.4 88.48,57.19 88.62,57.32 88.88,57.32 89.01,57.19 89.01,56.4 89.14,56.27 89.41,56.27 89.54,56.4 89.54,57.19 89.67,57.32 89.94,57.32 90.07,57.19 90.07,56.4 90.2,56.27 90.47,56.27 90.6,56.4 90.6,57.19 90.73,57.32 90.99,57.32 91.13,57.19 91.13,56.4 91.26,56.27 91.52,56.27 91.65,56.4 91.65,57.19 91.79,57.32 92.05,57.32 92.18,57.19 92.18,56.4 92.31,56.27 92.58,56.27 92.71,56.4 92.71,57.19 92.84,57.32 93.11,57.32 93.24,57.19 93.24,56.4 93.37,56.27 101.87,56.27
  BOTTOM w0.102: U1.BE41 109.64,55.67 109.29,55.32 108.37,55.32 v1(107.96,55.73)
  BOTTOM w0.17: JDIMM2.114 62.3,55.55 61.84,56.01 59.87,56.01 v3(58.91,56.97)
DDR_CS3_DIMMB#: length 71.8
  IN1 w0.084: 101.87,58.7 104.87,58.7 v1(105.97,59.8)
  IN1 w0.132: v3(52.98,58.05) 52.98,58.56 52.86,58.68 51.49,58.68 51.36,58.81 51.36,59.09 51.49,59.22 53.48,59.22 53.61,59.09 53.61,58.62 53.74,58.5 54.08,58.5 54.21,58.62 54.21,59.28 54.34,59.41 54.69,59.41 54.82,59.28 54.82,58.16 54.95,58.03 55.32,58.03 55.45,58.16 55.45,59.7 55.58,59.83 61.36,59.83 62.12,60.58 64.08,60.58 64.44,60.93 65.78,60.93 66.14,60.58 73.29,60.58 73.67,60.2 81.4,60.2 81.53,60.07 81.53,59.89 81.66,59.76 83.98,59.76 84.11,59.89 84.11,60.81 84.23,60.93 87.64,60.93 88.85,59.72 93.97,59.72 94.99,58.7 101.87,58.7
  BOTTOM w0.102: U1.BE47 109.62,58.5 109.29,58.83 106.93,58.83 v1(105.97,59.8)
  BOTTOM w0.17: v3(52.98,58.05) 53.5,57.53 54.06,57.53 54.18,57.65 JDIMM2.121
DDR_HVREF_RST: length 83.1
  TOP w0.102: RC46.2 RC47.2 CC177.1 136.64,21.93 136.64,20.05 QC2.2 136.01,17.9 v2(135.57,17.47) 135.57,14.49 v1(135.56,14.48)
  IN3 w0.122: v1(73.75,11.11) 76.09,8.77 78.37,8.77 78.91,8.23 85.14,8.23 88.19,11.29 92.05,11.29 97.84,17.08 130.58,17.08 132.6,15.07 134.97,15.07 v1(135.56,14.48)
  BOTTOM w0.102: v1(73.75,11.11) 73.79,11.15 QD1.2 74.95,12.79 75.1,12.94 QD2.2
DDR_HVREF_RST_GATE: length 210.9
  TOP w0.102: U51.A34 282.02,61.6 v1(281.23,62.39) ; v1(156.52,7.48) 156.06,7.02 148.44,7.02 148.19,7.27 148.19,12.46 148,12.65 148,13.79 147.16,14.63 141.55,14.63 v2(141.08,15.1) 139.96,16.22 139.96,17.84 139.41,18.39 139.41,18.73 138.41,19.73 138.41,21.3 138.78,21.66 139.36,21.66 139.69,21.99 139.69,22.89 RC47.1
  IN1 w0.084: v1(174.06,13.73) 171.91,13.73 170.3,12.12 170.3,9.85 167.41,6.96 157.04,6.96 v1(156.52,7.48)
  IN2 w0.122: v1(281.83,28.95) 280.47,27.59 272.24,27.59 270.4,29.43 268.16,29.43 266.8,28.07 264.76,28.07 264.01,27.33 258.1,27.33 257.36,28.07 253.07,28.07 252.19,27.19 247.26,27.19 239.98,19.91 221.33,19.91 218.78,17.36 212.56,17.36 211.42,16.23 198.26,16.23 196.71,14.67 186.87,14.67 185.16,12.97 174.82,12.97 v1(174.06,13.73)
  IN3 w0.122: v1(281.23,62.39) 280.03,61.19 280.03,56.82 279.28,56.07 279.28,48.54 278.49,47.75 278.49,45.3 279.32,44.46 279.32,42.4 279.74,41.98 279.74,41.35 281.59,39.51 281.59,32.41 281,31.82 281,29.58 281.63,28.95 v1(281.83,28.95)
DDR_HVREF_RST_PCH: length 57.6
  TOP w0.102: RC46.1 139.13,24.34 139.13,23.87 139.92,23.09 139.92,21.89 139.44,21.41 138.92,21.41 138.66,21.16 138.66,19.81 139.64,18.83 139.64,18.55 140.37,17.83 140.37,16.34 141.73,14.98 v2(145.57,14.98) 147.29,14.98 148.43,13.84 v1(148.43,13.54)
  IN3 w0.122: v1(148.43,13.54) 149.14,12.83 158.87,12.83 161.11,15.07 170.58,15.07 173.64,18.13 173.64,19.96 173.97,20.29 v1(173.97,22.7)
  BOTTOM w0.102: UH4.A12 170.74,23.81 171.71,23.81 171.95,23.57 172.99,23.57 173.86,22.7 v1(173.97,22.7) 174.25,22.42 RH300.2
DDR_ON: length 338.8
  TOP w0.102: v1(43.59,64.28) v4(44.18,64.28) ; v1(291.91,60.71) 292.05,60.85 U51.B14 ; R876.2 v1(295.83,63.52)
  TOP w0.254: PR206.1 v1(43.59,64.28)
  IN1 w0.084: v1(295.83,63.52) 295.83,62.33 295.55,62.06 294.29,62.06 292.94,60.71 v1(291.91,60.71)
  IN4 w0.084: v1(43.59,64.28) 44.43,65.12 44.43,78.24 48.97,82.78 61.99,82.78 64.78,85.57 65.4,85.57 68.82,88.99 86.48,88.99 86.76,89.27 91.59,89.27 92.25,89.93 100.88,89.93 109.49,98.54 114.74,98.54 116.11,99.91 131.02,99.91 133.5,97.43 135.26,97.43 136.19,96.51 136.19,94.96 137.44,93.71 139.39,93.71 139.61,93.93 152.97,93.93 159.36,87.53 160.34,87.53 167.68,80.19 167.68,71.24 168.56,70.36 168.56,57.99 167.65,57.08 167.65,55.09 170.99,51.74 171.77,51.74 173.32,50.18 181.96,50.18 183.74,48.4 183.74,47.55 187.81,43.49 189.38,43.49 192.94,39.93 194.21,39.93 198.45,35.69 217.25,35.69 219.24,37.67 229.77,37.67 236.04,43.94 252.77,43.94 254.29,45.46 258.17,45.46 259.24,46.53 265.8,46.53 267.09,47.82 269.6,47.82 272.48,50.7 275.41,50.7 275.6,50.89 277.55,50.89 280.5,53.85 285.51,53.85 285.63,53.73 292.39,53.73 293.27,54.61 293.27,59.35 v1(291.91,60.71)
DDR_XDP_WAN_SMBCLK: length 339.4
  TOP w0.102: R1157.2 284.92,40.24 284.52,40.24 284.12,39.84 284.01,39.84 v1(283.81,40.04)
  IN1 w0.084: v1(182.58,23.46) 182.23,23.46 182.13,23.56 182.13,23.71 182.33,23.9 182.99,23.9 184.28,22.62 187.45,22.62 188.86,21.21 189.68,21.21 190.58,20.31 198.82,20.31 200.08,19.05 202.07,19.05 202.69,19.67 240.54,19.67 242.44,21.57 256.56,21.57 257.51,22.52 261.81,22.52 262.59,23.31 282.87,23.31 283.29,23.73 283.87,23.73 v1(284.04,23.56)
  IN3 w0.122: v1(182.58,23.46) 182.16,23.88 182.16,24.23 181.89,24.5 181.89,31.8 182.98,32.89 182.98,36.56 182.36,37.18 182.36,42.04 181.48,42.92 180.52,42.92 177.19,46.24 176.6,46.24 170.3,52.54 170.3,53.18 167.58,55.9 167.58,62.16 167.47,62.27 167.47,68.12 166.87,68.72 166.87,74.29 165.55,75.61 165.55,89.74 168.21,92.4 168.21,94.05 167.9,94.37 167.67,94.37 v3(167.48,94.56) ; v1(284.04,23.56) 284.21,23.73 284.51,23.73 284.84,24.06 284.84,28.57 285.21,28.94 285.21,30.69 284.5,31.39 284.5,39.59 284.23,39.85 283.99,39.85 v1(283.81,40.04) ; v1(73.4,82.91) 73.59,83.1 73.59,83.37 72.5,84.46 69.19,84.46 67.29,82.56 65.36,82.56 65.08,82.84 65.08,83.26 v1(64.85,83.48)
  IN4 w0.084: v3(167.48,94.56) 167.32,94.4 167.3,94.4 163.25,94.4 162.9,94.05 160.25,94.05 153.21,101.09 150.61,101.09 149.63,102.07 138.74,102.07 137.81,103 137,103 132.8,107.21 115.45,107.21 113.46,105.22 100.11,105.22 94.75,99.87 94.48,99.87 87.56,92.95 79.12,92.95 78.35,92.18 78.35,91.76 v1(78.14,91.54)
  BOTTOM w0.102: JDIMM2.202 64.55,81.95 64.74,81.76 64.84,81.76 65.05,81.98 65.05,83.28 v1(64.85,83.48) ; v1(73.4,82.91) 73.6,83.11 73.6,84.07 74.3,84.76 75.06,84.76 75.25,84.95 JDIMM1.202 77.41,84.95 77.59,84.76 78.02,84.76 78.35,85.09 78.35,91.33 v1(78.14,91.54) ; RH363.2 182.57,21.71 QH5.1 182.57,22.42 182.57,23.45 v1(182.58,23.46)
DDR_XDP_WAN_SMBDAT: length 338.5
  TOP w0.102: v1(283.81,39.4) 284.01,39.61 284.21,39.61 284.62,40.01 284.92,40.01 R1158.2
  IN1 w0.084: v1(181.48,23.46) 181.84,23.46 181.92,23.55 181.92,23.8 182.24,24.11 183.08,24.11 184.37,22.83 187.54,22.83 188.95,21.42 189.77,21.42 190.67,20.52 198.91,20.52 200.17,19.26 201.99,19.26 202.6,19.88 240.45,19.88 242.35,21.78 256.47,21.78 257.43,22.73 261.72,22.73 262.51,23.52 282.78,23.52 283.2,23.94 283.78,23.94 v3(284.04,24.2)
  IN3 w0.122: v1(181.48,23.46) 181.91,23.89 181.91,24.12 181.64,24.39 181.64,31.9 182.73,32.99 182.73,36.45 182.11,37.07 182.11,41.94 181.38,42.67 180.41,42.67 177.09,46 176.49,46 170.06,52.43 170.06,53.07 167.34,55.79 167.34,62.05 167.22,62.17 167.22,68.01 166.62,68.61 166.62,74.19 165.3,75.51 165.3,89.84 167.96,92.51 167.96,93.95 167.79,94.12 167.67,94.12 v1(167.48,93.93) ; v1(74.03,82.91) 73.84,83.1 73.84,83.48 72.6,84.71 69.09,84.71 67.19,82.81 65.46,82.81 65.33,82.95 65.33,83.33 v1(65.49,83.48) ; v1(283.81,39.4) 284.01,39.61 284.13,39.61 284.25,39.48 284.25,31.29 284.96,30.58 284.96,29.04 284.59,28.68 284.59,24.17 284.41,23.98 284.26,23.98 v3(284.04,24.2)
  IN4 w0.084: v1(78.77,91.54) 78.56,91.75 78.56,92.09 79.21,92.74 87.65,92.74 94.57,99.66 94.84,99.66 100.19,105.01 113.55,105.01 115.53,107 132.71,107 136.91,102.79 137.73,102.79 138.65,101.86 149.54,101.86 150.53,100.88 153.12,100.88 160.16,93.84 162.98,93.84 163.34,94.19 167.21,94.19 v1(167.48,93.93)
  BOTTOM w0.102: JDIMM2.200 64.55,81.35 64.74,81.54 64.93,81.54 65.28,81.89 65.28,83.28 v1(65.49,83.48) ; v1(181.48,23.46) 181.27,23.67 QH5.4 181.27,25.21 RH364.2 ; v1(74.03,82.91) 73.83,83.11 73.83,83.98 74.39,84.54 75.06,84.54 75.25,84.35 JDIMM1.200 77.45,84.35 77.64,84.54 78.12,84.54 78.58,85 78.58,91.35 v1(78.77,91.54)
DEEP_S3_WAKE: length 189
  TOP w0.102: R881.1 293.96,70.18 v1(293.63,70.51) ; v1(187.19,22.17) v2(187.19,24.67) 185.06,26.81 183.36,26.81 182.31,25.77 177.39,25.77 RH365.1 174.4,27.18 173.37,26.15 173.37,24.71 172.8,24.14 171.3,24.14 170.46,24.98 169.13,24.98 168.66,25.45 v1(168.66,25.48)
  IN2 w0.122: v1(300.96,36.85) 300.49,37.32 299.08,37.32 298.39,38.01 292.98,38.01 291.9,36.93 285.3,36.93 280.31,31.94 263.58,31.94 261.65,33.87 257.71,33.87 256.75,32.9 246.79,32.9 245.13,31.24 240.95,31.24 238.64,28.93 235.52,28.93 230.37,23.78 218.51,23.78 215.6,20.86 202.3,20.86 201.72,21.44 187.92,21.44 v1(187.19,22.17)
  BOTTOM w0.102: v1(293.63,70.51) 294.73,69.4 296,69.4 298.01,67.4 298.01,64.75 299.42,63.34 299.42,46.4 302.1,43.72 302.1,38 v1(300.96,36.85) ; v1(168.66,25.48) 168.31,25.82 UH4.E16
DEVICE_DET#: length 2.5
  TOP w0.102: R1125.2 291.76,66.1 v2(291.76,65.05) 291.76,64.22 291.76,64.22 U51.A17
DF_TVS: length 4.4
  BOTTOM w0.102: RH358.2 151.28,15.12 v2(151.28,16.6) UH4.AY1
DF_TVS_R: length 4
  BOTTOM w0.102: v2(151.68,14.06) 150.25,14.06 RH358.1 RH149.2 RH150.2
DH_1.5V: length 12.9
  TOP w0.102: v1(23.04,60.79) 22.43,60.79 v2(22.36,60.72)
  IN1 w1.016: 33.75,65.43 33.75,63.04 31.82,61.11 24.73,61.11
  vias: v1(23.7,60.79) v1(35.24,66) v1(35.67,65.52)
DISP_ON: length 25.6
  TOP w0.102: D67.1 D69.1 96.36,87.98 96.98,88.61 R1138.1 96.98,93.7 v2(97.69,94.41) v1(97.69,96.42)
  BOTTOM w0.102: JLVDS1.27 98.1,106.78 96.11,104.78 96.11,97.58 97.26,96.42 v1(97.69,96.42)
DL_1.5V: length 1
  TOP w0.102: v1(37.18,68.29) v2(36.23,68.29)
  vias: v1(30.03,66.61) v1(30.66,66.61) v1(37.18,67.65)
DMI_COMP_R: length 5.7
  BOTTOM w0.102: RH111.2 143.62,30.29 v2(143.9,30.01) 143.94,29.97 UH4.BJ24 147.29,29.97 147.79,30.46 UH4.BG25
DMI_CRX_PTX_N0: length 34.6
  IN4 w0.091: v3(127.54,32.51) 127.77,32.74 128.05,32.74 128.24,32.93 128.24,34.36 129.27,35.38 136.84,35.38 138.37,33.86 144.25,33.86 145.23,32.87 145.95,32.87 147.89,30.93 149.88,30.93 150.08,30.73 150.08,30.2 150.33,29.95 151.21,29.95 151.32,29.84 v1(151.32,29.49)
  BOTTOM w0.102: U1.M2 126.51,36.43 126.51,35.99 126.55,35.95 126.55,35.39 127.75,34.19 128.22,33.71 128.22,32.96 127.98,32.72 127.61,32.72 127.54,32.65 v3(127.54,32.51) ; v1(151.32,29.49) 151.32,29.64 UH4.AW24
DMI_CRX_PTX_N1: length 37.6
  IN4 w0.084: v5(125.71,38.8) 125.47,39.04 125.33,39.04 125.25,38.96 125.25,35.71 126.3,34.66 126.3,34.48 126.42,34.36 126.42,34.23
  IN4 w0.091: 126.42,34.23 126.42,31.95 127.09,31.27 129.29,31.27 130.52,32.51 135.19,32.51 137.83,29.87 144.15,29.87 145.18,28.84 146.67,28.84 147.47,28.04 151.41,28.04 151.54,28.17 151.54,28.36 151.41,28.48 v1(151.33,28.48)
  BOTTOM w0.102: v5(125.71,38.8) 125.63,38.8 125.27,38.44 U1.P6 ; UH4.AW20 151.65,28.16 v1(151.33,28.48)
DMI_CRX_PTX_N2: length 40
  IN4 w0.084: 144.57,25.01 144.59,25.01 144.59,25 146.46,25 146.79,25.33 146.79,25.9 147.89,27 150.49,27 150.7,27.21 v1(150.7,27.47)
  IN4 w0.091: v3(126.18,29.11) 125.84,28.77 125.84,28.72 126,28.56 129.35,28.56 130.98,30.19 134.42,30.19 136.76,27.84 136.76,26.57 137.34,26 138.97,26 139.96,25.01 144.57,25.01
  BOTTOM w0.102: UH4.BB18 150.38,27.15 v1(150.7,27.47) ; v3(126.18,29.11) 126.18,29.06 126.11,28.99 126,28.99 125.85,29.14 125.85,29.35 125.63,29.57 125.63,30.02 126.35,30.73 126.35,33.61 124.88,35.08 124.88,35.27 125.02,35.41 125.02,35.75 124.88,35.89 124.88,36.05 125,36.17 125.05,36.17 U1.P1
DMI_CRX_PTX_N3: length 38.8
  IN4 w0.084: v5(125.73,40.66) 125.98,40.92 126.07,40.92 126.19,40.8 126.19,40.45 127.16,39.48 127.16,38.41 129.54,36.04 132.13,36.04 132.31,36.22 132.65,36.22 132.66,36.21 132.68,36.21 ; v1(152.65,27.47) 152.56,27.38 152.56,27.01 152.67,26.91 152.91,26.91 153.16,27.16 153.16,30.63 152.88,30.91 152.32,30.91 151.92,31.3 151.92,31.53 151.61,31.85 150.22,31.85 149.69,32.37
  IN4 w0.091: 132.68,36.21 137.47,36.21 138.3,35.38 143.77,35.38 145.66,33.5 146.78,33.5 147.9,32.37 149.69,32.37
  BOTTOM w0.102: UH4.AV18 152.65,27.34 v1(152.65,27.47) ; U1.P10 125.6,40.66 v5(125.73,40.66)
DMI_CRX_PTX_P0: length 34.6
  IN4 w0.091: v1(151.34,30.53) 151.34,30.31 151.15,30.12 150.4,30.12 150.25,30.27 150.25,30.8 149.95,31.1 147.96,31.1 146.02,33.04 145.31,33.04 144.32,34.03 138.44,34.03 136.91,35.56 129.19,35.56 128.06,34.43 128.06,33 127.98,32.91 127.77,32.91 v3(127.54,33.14)
  BOTTOM w0.102: UH4.AY24 151.02,30.2 151.34,30.52 v1(151.34,30.53) ; v3(127.54,33.14) 127.75,32.93 127.89,32.93 128.01,33.05 128.01,33.62 127.6,34.04 126.34,35.3 126.34,35.86 126.3,35.9 126.3,36.25 125.99,36.56 U1.N3
DMI_CRX_PTX_P1: length 37.6
  IN4 w0.084: v5(125.7,39.41) 125.49,39.2 125.26,39.2 125.09,39.03 125.09,35.64 126.14,34.59 126.14,34.41 126.25,34.3 126.25,34.23
  IN4 w0.091: v3(151.34,27.47) 150.93,27.87 147.4,27.87 146.6,28.67 145.11,28.67 144.08,29.69 137.76,29.69 135.12,32.33 130.59,32.33 129.36,31.1 127.02,31.1 126.25,31.88 126.25,34.23
  BOTTOM w0.102: U1.P7 125.32,39.04 v5(125.7,39.41) ; UH4.AY20 151.34,27.67 v3(151.34,27.47)
DMI_CRX_PTX_P2: length 40
  IN4 w0.084: 144.57,24.83 144.59,24.83 144.59,24.84 146.53,24.84 146.96,25.26 146.96,25.83 147.96,26.83 150.35,26.83 v1(150.63,26.55)
  IN4 w0.091: 144.57,24.83 139.89,24.83 138.9,25.82 137.27,25.82 136.59,26.5 136.59,27.77 134.35,30.02 131.05,30.02 129.42,28.39 125.93,28.39 125.67,28.65 125.67,28.87 v3(125.42,29.11)
  BOTTOM w0.102: U1.P3 125.13,36.59 124.66,36.13 124.66,35.8 124.81,35.66 124.81,35.5 124.66,35.35 124.66,34.99 126.13,33.52 126.13,30.82 125.42,30.11 v3(125.42,29.11) ; v1(150.63,26.55) 151.02,26.94 UH4.AY18
DMI_CRX_PTX_P3: length 38.9
  IN4 w0.084: v3(152.65,26.5) 152.65,26.5 152.89,26.74 152.98,26.74 153.33,27.09 153.33,30.7 152.95,31.07 152.39,31.07 152.09,31.37 152.09,31.6 151.67,32.01 150.3,32.01 149.76,32.55 ; 132.68,36.39 132.65,36.39 132.65,36.38 132.24,36.38 132.06,36.2 129.6,36.2 127.32,38.48 127.32,39.55 126.36,40.52 126.36,40.87 126.14,41.08 125.95,41.08 v5(125.72,41.31)
  IN4 w0.091: 132.68,36.39 137.54,36.39 138.37,35.56 143.85,35.56 145.73,33.67 146.85,33.67 147.98,32.55 149.76,32.55
  BOTTOM w0.102: UH4.AU18 152.65,26.65 v3(152.65,26.5) ; v5(125.72,41.31) 125.59,41.31 U1.P11
DMI_CTX_PRX_N0: length 29.3
  IN4 w0.091: v1(149.4,30.51) 148.98,30.09 148.36,30.09 148.32,30.13 147.09,30.13 144.1,33.11 136.41,33.11 135.73,33.8 129.98,33.8 129.04,32.86 128.78,32.86 128.72,32.92 v3(128.72,33.15)
  BOTTOM w0.102: v1(149.4,30.51) 149.75,30.17 UH4.BC24 ; v3(128.72,33.15) 129,33.44 129,33.62 127.45,35.17 127.45,35.35 127.44,35.36 127.44,36.39 127.34,36.49 127.03,36.49 126.76,36.22 126.76,35.98 126.86,35.88 127,35.88 127.11,35.98 U1.K1
DMI_CTX_PRX_N1: length 34.6
  IN4 w0.084: 147.89,28.91 147.91,28.91 147.91,28.91 149.58,28.91 149.65,28.85 149.65,28.7 v1(149.43,28.48) ; 126.89,34.19 126.89,34.21 126.9,34.21 126.9,34.26 126.9,34.26 126.9,36.61 126.1,37.4 126.1,38.81 126.33,39.04 126.47,39.04 v5(126.68,39.25)
  IN4 w0.091: 147.89,28.91 147.61,28.91 147.21,29.31 145.95,29.31 144.85,30.41 137.96,30.41 135.39,32.98 130.32,32.98 129.09,31.75 127.36,31.75 126.89,32.21 126.89,34.19
  BOTTOM w0.102: U1.M8 126.36,39.63 126.68,39.31 v5(126.68,39.25) ; UH4.BE20 149.43,28.3 v1(149.43,28.48)
DMI_CTX_PRX_N2: length 33.5
  IN4 w0.084: 146.17,26.14 146.17,26.34
  IN4 w0.091: v3(127.45,29.11) 127.22,29.35 127.22,29.71 127.3,29.78 129.9,29.78 130.77,30.66 134.97,30.66 139.7,25.93 145.96,25.93 146.17,26.14 ; 146.17,26.34 v1(146.36,26.54)
  BOTTOM w0.102: U1.N4 125.66,37.23 125.66,35.84 125.55,35.73 125.55,35.72 125.54,35.71 125.54,35.41 127.05,33.89 127.05,31.81 127.24,31.62 127.24,29.32 v3(127.45,29.11) ; v1(146.36,26.54) 146.92,26.54 147.38,27 UH4.BG18
DMI_CTX_PRX_N3: length 34.9
  IN4 w0.091: v3(125.63,33.41) 125.49,33.27 125.1,33.27 124.86,33.03 124.86,31.24 125.66,30.43 129.63,30.43 130.88,31.69 134.86,31.69 139,27.55 144.84,27.55 145.32,28.02 145.58,28.02 145.67,27.93 145.67,27.76 v1(145.49,27.58)
  BOTTOM w0.102: U1.R2 124.53,36.51 124.01,36.51 123.71,36.21 123.71,35.96 123.81,35.86 123.81,35.19 124.28,34.71 124.28,33.77 124.99,33.07 125.29,33.07 v3(125.63,33.41) ; v1(145.49,27.58) 146.2,28.29 146.58,28.29 147.11,28.29 147.4,28 147.41,27.99 UH4.BG20
DMI_CTX_PRX_P0: length 29.3
  IN4 w0.091: v1(149.42,29.49) 148.98,29.92 148.29,29.92 148.25,29.96 147.02,29.96 144.03,32.94 136.34,32.94 135.66,33.62 130.05,33.62 129.12,32.69 128.82,32.69 128.72,32.58 v3(128.72,32.39)
  BOTTOM w0.102: U1.K3 127.17,36.75 127.38,36.75 127.66,36.47 127.66,35.26 129.22,33.71 129.22,32.89 v3(128.72,32.39) ; v1(149.42,29.49) 149.11,29.79 UH4.BE24
DMI_CTX_PRX_P1: length 34.5
  IN4 w0.084: v3(150.06,28.48) 149.92,28.48 149.81,28.58 149.81,28.91 149.65,29.08 147.91,29.08 147.91,29.08 147.89,29.08 ; 127.07,34.19 127.07,36.68 126.27,37.47 126.27,38.74 126.4,38.87 126.56,38.87 126.68,38.75 v5(126.68,38.6)
  IN4 w0.091: 127.07,34.19 127.07,32.29 127.43,31.92 129.02,31.92 130.25,33.15 135.46,33.15 138.04,30.58 144.93,30.58 146.02,29.48 147.28,29.48 147.68,29.08 147.89,29.08
  BOTTOM w0.102: UH4.BC20 149.85,27.99 149.98,28.11 149.98,28.4 v3(150.06,28.48) ; v5(126.68,38.6) 126.3,38.98 U1.M7
DMI_CTX_PRX_P2: length 33.4
  IN4 w0.091: v1(145.73,26.55) 146,26.28 146,26.21 145.89,26.11 139.77,26.11 135.04,30.83 130.7,30.83 129.83,29.96 127.22,29.96 127.04,29.78 127.04,29.34 v3(126.81,29.11)
  BOTTOM w0.102: U1.P4 125.45,37.24 125.45,35.93 125.34,35.82 125.34,35.82 125.32,35.8 125.32,35.32 126.84,33.8 126.84,31.72 127.02,31.53 127.02,29.32 v3(126.81,29.11) ; UH4.BJ18 146.9,27.07 146.81,27.16 146.68,27.16 146.59,27.07 146.59,27.07 146.46,26.94 146.12,26.94 v1(145.73,26.55)
DMI_CTX_PRX_P3: length 34.9
  IN4 w0.091: v3(125.63,32.78) 125.63,32.91 125.54,32.99 125.43,32.99 125.32,33.1 125.17,33.1 125.03,32.96 125.03,31.31 125.74,30.6 129.55,30.6 130.81,31.86 134.93,31.86 139.07,27.72 144.77,27.72 145.25,28.19 145.65,28.19 145.84,28.01 145.84,27.77 146.03,27.58 v1(146.12,27.58)
  BOTTOM w0.102: v3(125.63,32.78) 125.57,32.84 124.91,32.84 124.07,33.68 124.07,34.62 123.59,35.1 123.59,35.77 123.5,35.87 123.5,36.3 124.01,36.81 U1.T3 ; UH4.BJ20 147.01,27.99 147.12,27.87 147.12,27.75 147.04,27.67 147.04,27.51 146.91,27.39 146.64,27.39 146.56,27.47 146.56,28 146.49,28.08 146.29,28.08 146.12,27.91 v1(146.12,27.58)
DMIC0: length 143.8
  TOP w0.102: v1(40.65,34.54) 40.28,34.54 39.49,35.33 37.01,35.33 36.18,36.16 U72.4
  IN1 w0.084: v1(40.65,34.54) 40.86,34.33 41.84,34.33 42.57,35.06 42.57,51.17 45.72,54.32 45.72,71.4 44.44,72.67 44.44,79.51 43.97,79.99 43.97,83.87 46.27,86.17 59.63,86.17 60.18,85.62 67.8,85.62 68.2,85.21 86.98,85.21 90.88,89.11 90.88,96.77 90.54,97.11 v3(90.14,97.11)
  BOTTOM w0.102: JLVDS1.40 91.6,108.51 91.51,108.42 91.51,107.88 91.86,107.53 91.86,107.01 89.65,104.8 89.65,100.97 88.81,100.12 83.97,100.12 83.58,99.74 83.58,98.98 83.48,98.88 D9.2 83.24,98.37 83.37,98.37 83.58,98.16 83.58,98.01 83.87,97.72 84.19,97.72 84.57,97.34 89.91,97.34 v3(90.14,97.11)
DMIC_CLK: length 140.5
  TOP w0.102: v3(40.65,33.9) 39.45,33.9 39.26,33.72 LE3.2
  IN1 w0.084: v3(40.65,33.9) 40.86,34.12 41.93,34.12 42.78,34.97 42.78,51.08 45.93,54.23 45.93,71.49 44.65,72.76 44.65,79.6 44.18,80.08 44.18,83.78 46.35,85.96 59.54,85.96 60.1,85.4 67.72,85.4 68.12,85 87.07,85 91.09,89.02 91.09,96.86 90.65,97.3 v1(90.65,97.77)
  BOTTOM w0.102: JLVDS1.38 92.6,108.54 92.37,108.32 92.37,107.81 92.09,107.53 92.09,106.92 89.88,104.71 89.88,100.87 88.91,99.9 84.07,99.9 83.81,99.64 83.81,98.98 83.91,98.88 D9.3 84.13,98.35 83.94,98.35 83.81,98.22 83.81,98.1 83.97,97.95 84.28,97.95 84.66,97.57 90.44,97.57 v1(90.65,97.77)
DMIC_CLK_L: length 6.4
  TOP w0.102: U72.2 35.59,35.16 37.04,33.72 LE3.1 37.71,33.24 37.94,33 39.44,33 v2(39.92,33.49)
DOCK_AC_OFF_EC: length 2.7
  TOP w0.102: 257.48,72.06 257.32,71.89 256.44,71.89 R1629.1 ; 257.48,72.06 v2(257.49,72.06) ; 257.48,72.06 U46.A63
DOCK_DET#: length 7.6
  TOP w0.102: v2(266.53,85.2) 266.53,83.59 R755.1 266.05,82.47 v1(266.36,82.15) ; U46.B41 265.09,79.28 v1(265.02,79.21)
  IN1 w0.084: v1(266.36,82.15) 266.36,81.3 265.02,79.96 v1(265.02,79.21)
DOCK_HP_DET: length 4.7
  TOP w0.102: U46.A7 263.34,69.45 263.47,69.33 263.47,68.97 263.16,68.67 263.15,68.67 R1082.2 261.84,67.36 v2(261.84,65.88)
DOCK_MIC_DET: length 6.1
  TOP w0.102: U46.B8 263.59,71.53 v1(264.09,72.03) ; v1(263.61,68.5) 263.61,68.17 R1081.2
  BOTTOM w0.102: v1(263.61,68.5) 263.66,68.55 v2(263.66,69.71) 263.66,71.6 v1(264.09,72.03)
DOCK_SMB_ALERT#: length 3.1
  TOP w0.102: U46.A51 258.27,78.06 257.37,78.95 v2(257.11,78.95) 256.4,78.95 R785.1
DSWODVREN: length 3.4
  TOP w0.102: v4(172.37,26.16) 171.96,26.56 v1(171.96,26.75) 171.96,27.53 RH127.1
  BOTTOM w0.102: v1(171.96,26.75) 171.72,27 UH4.A18
DYN_TUR_CURRNT_SET#: length 367.9
  TOP w0.102: U51.A35 282.05,61.1 v2(281.5,61.64) 281.34,61.81 281.14,61.81 280.79,62.16 280.79,62.43 R1171.2 280.67,63.18 v1(280.99,63.18) ; PQ1306.5 37.57,27.45 38.32,26.71 38.32,26.08 v1(38.87,25.54)
  IN1 w0.084: v1(38.87,25.54) 39.32,25.08 41.19,25.08 41.65,25.54 41.65,29.65 43.55,31.54 43.55,50.64 46.85,53.94 46.85,71.74 45.88,72.71 45.88,77.7 45.32,78.27 45.32,80.4 v1(44.99,80.73)
  IN4 w0.084: v1(44.99,80.73) 50.91,86.65 64.91,86.65 68.37,90.1 85.8,90.1 86.14,90.44 88.29,90.44 89.95,92.1 97.89,92.1 105.62,99.83 114.13,99.83 116.59,102.29 130.44,102.29 134.03,98.7 135.83,98.7 138.81,95.72 153.08,95.72 159.96,88.84 160.84,88.84 169.7,79.98 169.7,76.67 168.43,75.39 168.43,71.44 169.22,70.65 169.22,60.37 171.02,58.57 171.02,53.45 173.66,50.82 182.35,50.82 184.96,48.21 184.96,47.67 187.63,45 191.05,45 198.98,37.07 216.72,37.07 232.9,53.25 236.23,53.25 237.71,54.73 242.79,54.73 244.85,56.78 244.85,57.73 245.65,58.53 252.69,58.53 253.37,59.2 270.19,59.2 273.33,62.35 276.01,62.35 277.03,63.37 280.8,63.37 v1(280.99,63.18)
DYN_TURB_PWR_ALRT#: length 3.7
  TOP w0.102: U46.A46 261.34,81.27 260.46,82.15 v2(259.64,82.15) 259.43,82.37 259.43,82.89 R796.2
EC_32KHZ_ECE5048: length 43.8
  TOP w0.102: v1(268.61,81.23) 268.61,80.68 268.09,80.16 U46.B35 ; v1(288.04,51.57) 287.58,51.11 287.58,50.01 288.16,49.44 R867.1
  BOTTOM w0.102: v1(288.04,51.57) 288.19,51.72 288.19,52.32 286.5,54.01 286.5,55.46 285.49,56.47 285.49,60.61 285.18,60.92 285.18,63.62 279.1,69.71 279.1,72.69 274.14,77.66 274.14,78.78 273.35,79.56 272.67,79.56 v2(272.08,80.16) 271.01,81.23 v1(268.61,81.23)
EDP_COMP: length 8.3
  BOTTOM w0.102: U1.AF3 120.25,36.63 120.25,36.33 120.37,36.21 120.37,33.34 RC2.2
  BOTTOM w0.305: U1.AD2 120.62,36.44 120.77,36.29 120.77,35.48 120.95,35.3 v2(120.95,33.97) RC2.2
EN_1.8VSP: length 6.9
  TOP w0.102: v2(96.46,3.93) 97,3.4 PR303.2
  TOP w0.254: PR303.2 PR306.2 99.26,3.89 v1(99.26,4.18)
  BOTTOM w0.254: PR304.1 PC304.1 98.6,3.29 99.26,3.95 v1(99.26,4.18) 99.26,4.22 98.85,4.63 PU300.5
EN_+V1.05S_VCCPP: length 5.9
  TOP w0.254: v1(126.24,9.29) 126.23,9.29 125.71,8.77 PR307.2 PR503.2 ; v1(126.99,11.14) PU500.3
  BOTTOM w0.102: 126.22,9.27 126.09,9.14 v2(126.09,8.67)
  BOTTOM w0.254: v1(126.24,9.29) 126.22,9.27 PC506.1 126.22,10.86 126.5,11.14 v1(126.99,11.14)
EN_+V1.05SP: length 13.2
  BOTTOM w0.254: PU400.3 156.94,67.33 157.22,67.61 v2(157.22,69.81) 157.23,69.81 158.11,70.69 PC407.1 159.23,71.82 161.65,71.82 162.62,72.78 PR403.2 PR409.2 PR408.2
EN_INVPWR: length 204.9
  TOP w0.102: U51.A25 287.76,64.24 v1(288.05,64.53) 287.56,65.02 287.56,65.61 287.52,65.66 R882.2
  IN2 w0.102: 174.55,41.15 173.73,41.97 173.7,41.97 172.3,43.37
  IN2 w0.122: 172.3,43.37 169.39,46.28 169.39,49.93 167.82,51.5 167.82,51.73 165.59,53.96 165.59,58.74 164.51,59.83 164.51,61.34 163.2,62.65 163.2,73.79 162.82,74.17 162.82,85.73 159.17,89.38 159.17,93.19 153.49,98.88 v1(152.33,98.88) ; v1(288.05,64.53) 286.71,65.87 282.76,65.87 281.69,64.8 276.95,64.8 271.06,58.91 253.55,58.91 251.49,56.86 244.98,56.86 242.91,54.79 240.16,54.79 238.02,52.65 238.02,51.88 235.74,49.6 232.14,49.6 223.75,41.22 223.75,40.71 218.8,35.75 214.13,35.75 212.39,34.01 198.49,34.01 198.49,34.01 197.57,34.01 193.51,38.07 192.39,38.07 191.75,38.72 187.44,38.72 185.5,40.66 175.04,40.66 174.55,41.15
  BOTTOM w0.102: v1(152.33,98.88) 152.17,99.03 v2(150.93,99.03) Q22.2
EN_LCDPWR: length 3.3
  BOTTOM w0.102: v2(139.05,96.24) 139.5,96.7 D6.1 138.53,97.24 138.18,97.59 Q20.2
ENAB_3VLAN: length 6
  BOTTOM w0.102: R1638.1 R564.2 308.21,44.85 v2(308.88,44.85) ; R1638.1 307.5,45.74 306.95,45.74 306.78,45.92 Q35.3 ; R1638.1 C477.1 309.45,46.08 309.46,46.09 Q34.3
