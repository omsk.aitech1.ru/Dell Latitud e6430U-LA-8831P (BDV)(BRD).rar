# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ENTRIP1: length 16.4
  TOP w0.254: v1(247.83,6.47) 248.06,6.47 248.27,6.68 PU100.1 ; v1(245.52,15.91) 245.22,15.91 244.82,15.52 244.82,15.2 244.52,14.9 PQ104.6
  IN1 w0.254: v1(245.52,15.91) 246.66,15.91 247.83,14.74 v1(247.83,6.47)
  BOTTOM w0.102: v2(247.01,6.27) 247.63,6.27 v1(247.83,6.47)
  BOTTOM w0.254: v1(247.83,6.47) 247.92,6.56 PR106.1
ENTRIP2: length 22.4
  TOP w0.254: PQ104.3 241.38,13.6 241.13,13.34 v2(241.13,7.08) 241.13,7.01 243.22,4.91 250.6,4.91 251.05,5.36 v1(251.05,5.93) 250.77,6.2 PU100.6
  BOTTOM w0.254: v1(251.05,5.93) 250.22,6.75 PR105.2
ENVDD_PCH: length 214.4
  TOP w0.102: v1(165.8,49.6) 166.24,49.17 v2(167.56,49.17) v1(168.31,49.92) ; v1(266.04,78.58) 266.47,79.01 266.47,79.48 266.59,79.6 U46.B38
  IN2 w0.102: 167.69,43.37 167.69,42.48 166.05,40.85 166.05,40.15 v1(165.65,39.75)
  IN2 w0.122: 167.69,43.37 167.69,44.1 168.03,44.44 168.03,47.18 165.8,49.4 v1(165.8,49.6) 165.32,50.09 165.32,50.12 164.87,50.57 164.87,51.89 163.81,52.95 163.81,56.22 162,58.03 162,73.03 161.52,73.51 161.52,85.61 158.17,88.96 158.17,92.78 154.73,96.23 149.14,96.23 v1(148.38,96.99) ; v1(266.04,78.58) 265.56,79.05 265.56,79.3 264.89,79.97 260.06,79.97 258.73,78.64 258.73,75.35 258.56,75.18 258.56,71.27 257.12,69.82 256.5,69.82 255.52,68.84 255.52,64.72 254.34,63.54 253.34,63.54 250.76,60.97 243.17,60.97 236.17,53.97 234.7,53.97 232.83,52.1 231.37,52.1 221.51,42.25 221.51,41.64 217.87,37.99 213.18,37.99 211.51,36.32 198.78,36.32 194.78,40.32 193.32,40.32 191.96,41.68 187.69,41.68 182.06,47.31 178.41,47.31 v1(177.89,47.83)
  BOTTOM w0.102: v1(148.38,96.99) 146.41,95.02 141.76,95.02 141.35,95.43 D6.3 ; v1(168.31,49.92) 168.94,50.56 172.52,50.56 173.49,49.58 176.14,49.58 v1(177.89,47.83) ; v1(165.8,49.6) 165.88,49.53 165.88,49.07 RH134.2 ; v1(165.65,39.75) 165.33,40.06 UH4.M45
ESATA_CD#: length 167.6
  TOP w0.102: v1(179.37,40.14) 178.39,40.14 177.62,40.92 175.93,40.92 174.08,42.76 173,42.76 172.32,43.44 RH163.2
  IN1 w0.084: v1(179.37,40.14) 179.61,40.38 181.13,40.38 182.28,39.24 v1(185.79,39.24)
  IN2 w0.122: v1(185.79,47.82) 186.87,47.82 188.94,45.76 194.42,45.76 195.4,44.79 213.02,44.79 214.5,46.26 219.74,46.26 236.22,62.74 236.22,67.82 237.29,68.89 237.29,79.51 v1(237.72,79.94)
  IN3 w0.122: v1(161.54,10.26) 163.35,8.45 174.83,8.45 175.1,8.71 179.67,8.71 184.62,13.66 184.62,17.34 184.8,17.53 184.8,21.09 185.02,21.3 185.02,22.54 186.02,23.54 186.02,25.53 185.46,26.09 185.46,26.66 188.05,29.25 188.05,32.95 187.32,33.69 187.32,36.96 185.79,38.5 v1(185.79,39.24) 185.79,39.24 v1(185.79,47.82)
  BOTTOM w0.102: UH4.U2 162.73,19.05 162.73,18.48 162.15,17.9 162.15,16.95 161.11,15.92 v2(161.11,11.77) 161.11,10.69 v1(161.54,10.26) ; R746.1 237.52,79.74 v1(237.72,79.94)
ESATA_CD#_R: length 4.3
  TOP w0.102: v1(236.64,77.37) 236.93,77.08 U44.18
  BOTTOM w0.102: v2(237.06,80.3) 236.6,79.84 R746.2 R751.2 236.6,77.41 v1(236.64,77.37)
ESATA_PE1: length 4.4
  TOP w0.102: U44.9 242.99,77.58 R743.2 243.88,77.38 245.13,77.38 v2(245.39,77.65)
ESATA_PE2: length 4.3
  TOP w0.102: v2(245.37,76.3) 245.27,76.4 243.77,76.4 243.33,76.84 R745.2 243.17,77.08 U44.8
ESATA_PRX_DTX_N4: length 1.8
  TOP w0.102: C665.1 240.34,73.94 240.34,74.05 240.17,74.22 240.17,74.49 240.05,74.61 U44.4
ESATA_PRX_DTX_N4_C: length 136.1
  TOP w0.102: C665.2 240.35,72.37 240.35,72.17 v3(240.24,72.06) 240.43,71.87 240.43,71.54 R1722.2
  IN3 w0.122: v1(234.27,23.43) 234.66,23.82 234.66,27.19 235.17,27.7 235.17,45.83 234.84,46.16 234.84,48.7 237.76,51.62 237.76,61.63 240.36,64.23 240.36,67.08 239.54,67.91 239.54,69.84 240.63,70.93 240.63,71.67 v3(240.24,72.06)
  IN4 w0.091: v1(160.6,21.82) 160.8,21.63 161.07,21.63 161.28,21.42 161.28,19.36 161.69,18.95 163.35,18.95 164.62,17.68 166.64,17.68 168.43,15.88 175.67,15.88 176.24,16.45 179.95,16.45 180.23,16.74 187.12,16.74 188.01,17.63 190.08,17.63 193.29,20.84 198.13,20.84 198.77,21.49 204.89,21.49 205.44,22.04 230.96,22.04 231.51,22.6 234.13,22.6 234.56,23.03 234.56,23.13 v1(234.27,23.43)
  BOTTOM w0.102: UH4.Y7 160.93,21.5 v1(160.6,21.82)
ESATA_PRX_DTX_N4_RP: length 30.2
  TOP w0.102: U44.12 240.05,79.49 240.17,79.61 240.17,79.81 v1(239.99,79.99) 240.28,80.28 240.28,80.6 R1723.1
  IN1 w0.091: v1(239.99,79.99) 240.24,80.24 240.24,80.74 240.67,81.17 243.41,81.17 251.32,89.09 257.23,89.09 260.76,92.61 260.76,93.07 v3(260.53,93.29)
  BOTTOM w0.102: v3(260.53,93.29) 260.66,93.42 260.66,93.78 C1238.1
ESATA_PRX_DTX_P4: length 1.8
  TOP w0.102: C666.1 240.61,73.91 240.61,74.16 240.44,74.33 240.44,74.49 240.55,74.61 U44.5
ESATA_PRX_DTX_P4_C: length 136.1
  TOP w0.102: C666.2 240.62,72.41 240.62,72.32 v1(240.88,72.06) 240.7,71.88 240.7,71.54 R1724.2
  IN3 w0.122: v1(240.88,72.06) 240.88,70.83 239.78,69.73 239.78,68.01 240.61,67.19 240.61,64.13 238.01,61.53 238.01,51.51 235.08,48.59 235.08,46.27 235.42,45.93 235.42,27.6 234.9,27.08 v1(234.9,23.43)
  IN4 w0.091: v3(160.6,21.18) 160.83,21.41 160.99,21.41 161.07,21.33 161.07,19.27 161.61,18.74 163.26,18.74 164.53,17.46 166.55,17.46 168.34,15.67 175.76,15.67 176.33,16.24 180.04,16.24 180.32,16.52 187.21,16.52 188.1,17.41 190.17,17.41 193.38,20.63 198.22,20.63 198.86,21.27 204.97,21.27 205.53,21.83 231.04,21.83 231.6,22.39 234.22,22.39 234.78,22.95 234.78,23.3 v1(234.9,23.43)
  BOTTOM w0.102: v3(160.6,21.18) 160.92,20.86 UH4.Y5
ESATA_PRX_DTX_P4_RP: length 30.2
  TOP w0.102: R1725.1 240.56,80.29 240.56,80.06 v3(240.62,79.99) 240.44,79.81 240.44,79.64 240.55,79.53 U44.11
  IN1 w0.091: v3(240.62,79.99) 240.45,80.16 240.45,80.65 240.76,80.96 243.5,80.96 251.41,88.87 257.32,88.87 260.97,92.52 260.97,93.1 v1(261.16,93.29)
  BOTTOM w0.102: C1239.1 260.92,93.91 260.92,93.53 v1(261.16,93.29)
ESATA_PTX_DRX_N4: length 1.8
  TOP w0.102: C664.1 238.83,73.92 238.83,74 238.94,74.11 238.94,74.51 239.05,74.63 U44.2
ESATA_PTX_DRX_N4_C: length 138.5
  TOP w0.102: R1720.2 238.92,71.5 238.92,71.97 v1(239,72.06) 238.83,72.23 238.83,72.4 C664.2
  IN3 w0.122: v1(239,72.06) 238.93,71.99 238.93,71.4 237.06,69.53 237.06,54.7 237.26,54.51 237.26,51.83 233.82,48.39 233.82,27.81 233.29,27.28 233.29,21.94 v1(233.46,21.78)
  IN4 w0.091: v1(233.46,21.78) 233.25,21.57 233.25,21.4 232.92,21.07 220,21.07 219.51,20.59 199.33,20.59 198.69,19.94 193.77,19.94 190.44,16.61 188.32,16.61 187.49,15.78 180.62,15.78 179.2,14.36 167.79,14.36 166.62,13.19 161.32,13.19 159.77,14.74 159.77,17.47 159.66,17.59 159.25,17.59 v1(159.18,17.51)
  BOTTOM w0.102: v1(159.18,17.51) 159.58,17.91 159.58,18.79 159.4,18.97 159.4,19.35 UH4.AD3
ESATA_PTX_DRX_N4_RP: length 24.4
  TOP w0.102: U44.14 239.05,79.53 238.94,79.64 238.94,79.82 v3(239.12,80.01) 238.88,80.25 238.88,80.46 R1721.1
  IN1 w0.091: v3(239.12,80.01) 238.88,80.25 238.88,81.1 239.51,81.73 242.56,81.73 252.92,92.1 252.92,92.58 v1(253.25,92.91)
  BOTTOM w0.102: C1237.1 252.76,93.94 252.76,93.79 253.1,93.44 253.1,93.05 v1(253.25,92.91)
ESATA_PTX_DRX_P4: length 1.8
  TOP w0.102: C663.1 238.56,73.94 238.56,74.11 238.67,74.22 238.67,74.5 238.55,74.61 U44.1
ESATA_PTX_DRX_P4_C: length 138.5
  TOP w0.102: R1718.2 238.33,71.22 238.65,71.54 238.65,71.77 v1(238.37,72.06) 238.37,72.07 238.54,72.24 238.54,72.41 C663.2
  IN3 w0.122: v1(232.82,21.78) 233.05,22 233.05,27.38 233.58,27.91 233.58,48.49 237.01,51.93 237.01,54.4 236.82,54.6 236.82,69.63 238.68,71.5 238.68,71.74 v1(238.37,72.06)
  IN4 w0.091: v1(232.82,21.78) 232.94,21.78 233.04,21.68 233.04,21.49 232.84,21.28 219.91,21.28 219.42,20.8 199.24,20.8 198.6,20.16 193.69,20.16 190.35,16.82 188.24,16.82 187.41,16 180.53,16 179.11,14.58 167.7,14.58 166.53,13.41 161.41,13.41 159.99,14.83 159.99,17.56 159.75,17.8 159.52,17.8 v3(159.18,18.14)
  BOTTOM w0.102: v3(159.18,18.14) 158.93,17.9 158.69,17.9 158.59,18 158.59,18.24 158.88,18.54 158.88,18.84 159.02,18.97 159.13,18.97 159.21,18.89 UH4.AD1
ESATA_PTX_DRX_P4_RP: length 24.5
  TOP w0.102: R1719.1 238.61,80.36 238.61,80.13 v1(238.49,80.01) 238.67,79.82 238.67,79.61 238.55,79.49 U44.15
  IN1 w0.091: v3(252.61,92.91) 252.7,92.83 252.7,92.17 242.47,81.95 239.43,81.95 238.67,81.19 238.67,80.19 v1(238.49,80.01)
  BOTTOM w0.102: C1236.1 252.14,94.15 252.49,93.8 252.49,93.68 252.84,93.33 252.84,93.13 v3(252.61,92.91)
ESATA_USB_PWR_EN#: length 68.2
  TOP w0.102: U46.B44 263.59,79.41 v1(263.39,79.21) ; v1(264.59,82.17) 264.28,82.48 R769.2
  IN1 w0.084: v1(263.39,79.21) 263.39,80.3 264.13,81.04 264.13,81.71 v1(264.59,82.17)
  IN4 w0.084: v1(300.94,70.76) 298.75,72.96 282.39,72.96 278.95,76.4 273.54,76.4 270.04,79.9 264.08,79.9 v1(263.39,79.21)
  BOTTOM w0.102: U75.4 305.59,52.38 305.24,52.73 305.24,53.44 v2(304.46,54.22) 301.66,57.02 301.66,63.62 300.94,64.34 v1(300.94,70.76)
EXPCLK_REQ#: length 20
  TOP w0.102: v2(178.95,19.62) 179.7,18.87 v1(179.7,18.68)
  IN1 w0.084: v1(179.7,18.68) 179.24,19.14 178.94,19.14 176.99,21.08 175.93,21.08 174.7,22.31 172.69,22.31 172.12,22.88 170.85,22.88 168.81,24.92 166.44,24.92 v1(166.01,24.49)
  BOTTOM w0.102: UH4.L12 165.77,24.25 v1(166.01,24.49) ; v1(179.7,18.68) 178.76,19.62 RH94.1
EXT_MIC: length 23.6
  TOP w0.254: v1(16.02,36.43) 15.72,36.13 v2(15.72,31.54) 15.72,28.43 14.56,27.28 9.76,27.28 8.89,28.15 JHP1.4
  BOTTOM w0.254: v1(16.02,36.43) D82.3 18.47,36.43 18.75,36.71 C1211.1 19.6,36.71 19.84,36.47 L104.1
FAN1_PWM#: length 11.6
  TOP w0.102: v1(163.57,101.34) v2(163.57,100.4) 163.11,99.95 160.48,99.95 159.99,99.45 v1(159.99,99.29)
  BOTTOM w0.102: v1(159.99,99.29) 160.53,98.74 160.53,97.43 160.37,97.27 JFAN1.2 ; R402.2 164.01,100.9 v1(163.57,101.34) 163.17,101.74 U9.15
FAN1_TACH_FB: length 14.9
  TOP w0.102: v1(161.03,97.48) 161.03,97.6 161.73,98.3 v2(161.74,98.3) 162.08,98.64 164.13,98.64 164.47,98.97 164.47,103.41 v1(163.48,104.4)
  BOTTOM w0.102: JFAN1.3 161.62,97.23 161.36,97.48 v1(161.03,97.48) ; U9.10 163.33,104.24 v1(163.48,104.4) 164.5,105.41 R426.2
FB_3V: length 5.5
  TOP w0.254: PU100.5 250.27,5.95 v1(250.3,5.93)
  BOTTOM w0.102: PC120.1 252.62,5.29 v2(253.22,4.7)
  BOTTOM w0.254: v1(250.3,5.93) 250.17,5.8 PR103.2 PR101.2 PC120.1
FB_5V: length 5.7
  TOP w0.254: PU100.2 v1(248.77,6)
  BOTTOM w0.102: v2(246.02,4.72) 246.59,5.29 PR102.1
  BOTTOM w0.254: v1(248.77,6) 249.15,5.62 PR104.1 PC121.2 PR102.1
FB_+V1.05S_VCCPP: length 2.6
  TOP w0.254: PR510.2 PR507.2 127.15,11.9 126.88,11.64 PU500.4
FB_+V1.05SP: length 2.3
  BOTTOM w0.254: PR406.2 157.78,67.9 PR407.2 157.76,67.59 157.44,67.26 PU400.4
FDI_CTX_PRX_N0: length 36.6
  IN1 w0.084: v5(124.3,39.33) 124.3,39.19 124.47,39.02 124.77,39.02 124.95,38.85 124.95,38.2 125.47,37.68 125.47,34.88 125.16,34.57 125.16,34.19
  IN1 w0.091: 125.16,34.19 125.16,31.26 125.4,31.03 128.94,31.03 129.77,31.86 135.84,31.86 138.63,29.07 138.63,27.83 139.73,26.73 142.31,26.73 142.93,26.11 143.88,26.11 145.03,24.96 145.83,24.96 145.97,25.09 145.97,25.33 145.85,25.45 v1(145.72,25.45)
  BOTTOM w0.102: v5(124.3,39.33) 124.09,39.33 123.75,38.99 U1.U7 ; v1(145.72,25.45) 146.15,25.02 146.49,25.02 146.67,25.19 146.83,25.19 146.9,25.13 UH4.BJ14
FDI_CTX_PRX_N1: length 43.3
  IN1 w0.084: v5(123.31,41.36) 123.31,41.18 123.46,41.04 123.64,41.04 123.97,40.71 123.97,40.4 124.31,40.06 126.93,40.06 127.44,39.56 127.44,35.33 127.69,35.08
  IN1 w0.091: 127.69,35.08 128.89,33.88 129.99,33.88 131.63,35.51 137.12,35.51 138.51,34.12 138.51,32.56 139.79,31.29 139.79,30.17 139.92,30.04 139.92,28.37 140.26,28.02 143.13,28.02 143.3,27.86 144.78,27.86 145.17,28.25 146.69,28.25 147.92,27.03 149.41,27.03 150.2,26.24 150.2,25.23 150.33,25.09 150.54,25.09 150.7,25.25 v1(150.7,25.53)
  BOTTOM w0.102: v5(123.31,41.36) 122.88,40.93 U1.W11 ; v1(150.7,25.53) 151.02,25.22 UH4.AY14
FDI_CTX_PRX_N2: length 37
  IN1 w0.091: v3(125.64,32.1) 125.89,31.86 128.85,31.86 129.5,32.51 136.11,32.51 139.27,29.34 139.27,28.1 140,27.38 142.81,27.38 143.02,27.16 147.15,27.16 147.76,26.55 147.76,25.34 147.99,25.11 148.65,25.11 148.8,25.26 v1(148.8,25.52)
  BOTTOM w0.102: v1(148.8,25.52) 148.8,25.33 UH4.BE14 ; U1.W1 123.11,36.13 123,36.13 122.84,35.97 122.84,35.87 122.94,35.76 122.94,35.66 122.84,35.56 122.84,35.45 122.95,35.34 122.95,35.19 122.84,35.08 122.84,34.96 122.95,34.86 122.95,34.73 122.84,34.62 122.84,34.48 122.95,34.37 122.95,34.25 122.84,34.14 122.84,33.97 122.95,33.86 122.95,33.71 122.84,33.6 122.84,33.47 122.95,33.36 122.95,33.23 122.84,33.12 122.84,33.01 122.95,32.9 122.95,32.73 122.84,32.62 122.84,32.48 122.96,32.37 123.08,32.37 123.18,32.26 123.18,32.15 123.43,31.89 123.56,31.89 123.65,31.98 123.76,31.98 123.96,31.79 125.35,31.79 125.46,31.9 125.58,31.9 125.64,31.95 v3(125.64,32.1)
FDI_CTX_PRX_N3: length 40.9
  IN1 w0.084: v5(122.34,38.62) 122.55,38.83 122.65,38.83 122.75,38.73 122.75,37.45 122.94,37.26 122.94,34.78 123.06,34.66 123.06,34.26 123.06,34.26 123.06,34.21 123.05,34.21 123.05,34.19
  IN1 w0.091: 123.05,34.19 123.05,29.8 123.96,28.89 124.67,28.89 125.21,28.36 129.39,28.36 130.4,29.37 135.2,29.37 136.49,28.08 136.49,26.25 138.58,24.17 140.97,24.17 142.04,23.09 142.48,23.09 v3(142.69,22.88)
  BOTTOM w0.102: v5(122.34,38.62) 122.17,38.62 U1.AA6 ; UH4.BH13 147.5,24.52 147.6,24.42 147.6,24.28 147.5,24.18 147.24,24.18 146.91,24.51 145.56,24.51 145.4,24.35 144.14,24.35 143.72,23.93 143.72,23.7 143.16,23.14 142.95,23.14 v3(142.69,22.88)
FDI_CTX_PRX_N4: length 39.6
  IN1 w0.084: v5(123.32,38.62) 123.32,38.82 123.41,38.91 123.65,38.91 123.74,38.81 123.74,38.33 124.67,37.4 124.67,35.23 124.34,34.91 124.34,34.19 ; 147.38,24.14 147.39,24.14 147.4,24.14 148.04,24.14 148.28,23.9 149.13,23.9 149.31,23.72 v3(149.31,23.56)
  IN1 w0.091: 147.38,24.14 144.69,24.14 144.05,24.78 142.85,24.78 141.72,25.91 139.39,25.91 137.81,27.49 137.81,28.74 135.88,30.66 129.73,30.66 129.27,30.2 125.07,30.2 124.34,30.93 124.34,34.19
  BOTTOM w0.102: v5(123.32,38.62) 123.16,38.62 U1.W6 ; v3(149.31,23.56) 149.31,23.55 149.75,23.99 UH4.BC12
FDI_CTX_PRX_N5: length 37.4
  IN1 w0.084: 123.87,34.19 123.87,34.19 123.87,34.97 123.78,35.06 123.78,35.55 124.16,35.92 124.16,37.32 123.87,37.61 123.59,37.61 123.46,37.72 v5(123.46,37.91)
  IN1 w0.091: v1(144.21,23.61) 143.93,23.34 143.85,23.34 143.02,24.17 142.7,24.17 141.88,24.99 138.92,24.99 137.31,26.59 137.31,28.57 135.69,30.19 129.92,30.19 129.46,29.72 124.86,29.72 123.87,30.72 123.87,34.19
  BOTTOM w0.102: v1(144.21,23.61) 144.21,23.61 144.21,23.43 144.27,23.36 144.46,23.36 144.67,23.15 144.79,23.15 145.39,23.76 146.36,23.76 146.44,23.84 146.44,24.22 146.52,24.3 146.82,24.3 146.9,24.23 UH4.BJ12 ; U1.V4 123.26,37.71 v5(123.46,37.91)
FDI_CTX_PRX_N6: length 39.2
  IN1 w0.091: v5(122.52,37.01) 122.17,36.67 122.17,36.53 122.48,36.22 122.48,34.67 122.58,34.57 122.58,29.61 123.03,29.16 123.03,28.55 123.76,27.81 128.7,27.81 129.44,27.08 129.44,24.88 131.39,22.93 134.85,22.93 135.51,23.59 139.94,23.59 140.52,23 141.47,23 142.05,22.41 144.33,22.41 144.83,22.92 145.51,22.92 v3(145.72,23.14)
  BOTTOM w0.102: v3(145.72,23.14) 146.05,23.14 146.25,23.34 147.05,23.34 147.28,23.11 147.71,23.11 UH4.BG10 ; v5(122.52,37.01) 122.6,36.93 U1.Y2
FDI_CTX_PRX_N7: length 43.3
  IN1 w0.091: v5(121.36,39.64) 121.36,39.47 121.51,39.31 121.74,39.31 121.95,39.11 121.95,37.5 121.23,36.78 121.23,34.89 121.94,34.19 121.94,29.34 122.38,28.89 122.38,28.28 123.5,27.17 126.24,27.17 131.12,22.28 135.94,22.28 136.61,22.95 139.67,22.95 140.26,22.36 141.2,22.36 141.79,21.76 142.8,21.76 143.25,21.32 144.45,21.32 144.61,21.48 144.96,21.48 v3(145.18,21.71)
  BOTTOM w0.102: U1.AC9 121.16,39.95 121.36,39.76 v5(121.36,39.64) ; UH4.BG9 147.96,22.72 147.68,22.72 147.55,22.84 147.22,22.84 146.93,22.55 146.63,22.55 145.95,21.87 145.81,21.87 145.47,21.53 145.35,21.53 v3(145.18,21.71)
FDI_CTX_PRX_P0: length 36.7
  IN1 w0.084: v5(124.34,38.66) 124.54,38.86 124.7,38.86 124.78,38.78 124.78,38.13 125.3,37.61 125.3,34.95 124.99,34.63 124.99,34.19
  IN1 w0.091: 124.99,34.19 124.99,31.19 125.33,30.86 129.01,30.86 129.84,31.69 135.77,31.69 138.45,29 138.45,27.76 139.66,26.56 142.24,26.56 142.86,25.94 143.81,25.94 144.96,24.78 145.9,24.78 146.16,25.04 146.16,25.26 v3(146.35,25.45)
  BOTTOM w0.102: v5(124.34,38.66) 124.03,38.34 U1.U6 ; v3(146.35,25.45) 146.39,25.41 147,25.41 147.23,25.18 147.62,25.18 UH4.BG14
FDI_CTX_PRX_P1: length 43.4
  IN1 w0.084: 127.57,34.96 127.55,34.97 127.55,34.97 127.52,35.01 127.52,35.01 127.27,35.26 127.27,39.49 126.86,39.9 124.24,39.9 123.8,40.33 123.8,40.64 123.57,40.87 123.44,40.87 123.32,40.75 v5(123.32,40.54)
  IN1 w0.091: 127.57,34.96 128.82,33.7 130.07,33.7 131.7,35.34 137.05,35.34 138.34,34.05 138.34,32.49 139.61,31.21 139.61,30.1 139.74,29.97 139.74,28.3 140.19,27.85 143.06,27.85 143.22,27.69 144.85,27.69 145.24,28.08 146.62,28.08 147.85,26.85 149.34,26.85 150.02,26.17 150.02,25.16 150.26,24.92 150.57,24.92 150.7,24.79 v3(150.7,24.46)
  BOTTOM w0.102: U1.W10 123.06,40.28 v5(123.32,40.54) ; v3(150.7,24.46) 150.38,24.78 UH4.BB14
FDI_CTX_PRX_P2: length 37.1
  IN1 w0.091: v3(125.64,31.47) 125.86,31.68 128.92,31.68 129.57,32.33 136.04,32.33 139.1,29.27 139.1,28.03 139.92,27.2 142.74,27.2 142.95,26.99 147.08,26.99 147.58,26.48 147.58,25.27 147.92,24.94 148.67,24.94 148.73,24.87 v1(148.73,24.47)
  BOTTOM w0.102: v1(148.73,24.47) 148.73,24.76 UH4.BF14 ; U1.W3 123.15,36.59 122.62,36.06 122.62,32.39 123.45,31.57 125.54,31.57 v3(125.64,31.47)
FDI_CTX_PRX_P3: length 41
  IN1 w0.084: v5(122.37,39.26) 122.63,39 122.72,39 122.92,38.8 122.92,37.52 123.11,37.33 123.11,34.85 123.23,34.73 123.23,34.19
  IN1 w0.091: 123.23,34.19 123.23,29.88 124.03,29.07 124.74,29.07 125.28,28.53 129.32,28.53 130.33,29.54 135.27,29.54 136.67,28.15 136.67,26.32 138.65,24.34 141.04,24.34 142.11,23.27 142.44,23.27 v3(142.69,23.52)
  BOTTOM w0.102: UH4.BG13 147.84,24.52 147.48,24.88 147.23,24.88 147.07,24.71 145.46,24.71 145.31,24.56 144.05,24.56 143.51,24.02 143.51,23.79 143.07,23.35 142.86,23.35 v3(142.69,23.52) ; U1.AA7 122.1,38.98 v5(122.37,39.26)
FDI_CTX_PRX_P4: length 39.5
  IN1 w0.084: v5(123.3,39.32) 123.3,39.18 123.4,39.08 123.71,39.08 123.91,38.88 123.91,38.39 124.83,37.47 124.83,35.16 124.52,34.85 124.52,34.19 ; v1(149.42,24.44) 149.04,24.07 148.35,24.07 148.1,24.31 147.4,24.31 147.39,24.31 147.38,24.31
  IN1 w0.091: 147.38,24.31 144.76,24.31 144.12,24.95 142.92,24.95 141.79,26.08 139.47,26.08 137.98,27.57 137.98,28.81 135.95,30.83 129.66,30.83 129.2,30.38 125.14,30.38 124.52,31 124.52,34.19
  BOTTOM w0.102: v1(149.42,24.44) 149.42,24.18 149.27,24.02 UH4.BE12 ; U1.W7 122.96,38.98 v5(123.3,39.32)
FDI_CTX_PRX_P5: length 37.4
  IN1 w0.084: 123.7,34.19 123.7,34.19 123.7,34.21 123.7,34.21 123.7,34.26 123.7,34.26 123.7,34.9 123.62,34.99 123.62,35.62 124,35.99 124,37.25 123.8,37.45 123.69,37.45 123.68,37.43 123.58,37.32 v5(123.58,37.06)
  IN1 w0.091: 123.7,34.19 123.7,30.64 124.79,29.55 129.53,29.55 129.99,30.02 135.62,30.02 137.14,28.49 137.14,26.52 138.84,24.81 141.81,24.81 142.63,23.99 142.95,23.99 143.78,23.17 143.97,23.17 v3(144.21,22.93)
  BOTTOM w0.102: v5(123.58,37.06) 123.91,37.39 U1.T4 ; v3(144.21,22.93) 144.88,22.93 145.48,23.54 146.88,23.54 147.3,23.96 147.72,23.96 UH4.BG12
FDI_CTX_PRX_P6: length 39.2
  IN1 w0.091: v5(121.62,36.4) 122.06,36.4 122.31,36.14 122.31,34.6 122.41,34.5 122.41,29.53 122.86,29.08 122.86,28.62 122.86,28.47 123.69,27.64 128.63,27.64 129.26,27.01 129.26,24.81 131.32,22.76 134.92,22.76 135.58,23.42 139.86,23.42 140.45,22.83 141.39,22.83 141.98,22.24 144.4,22.24 144.9,22.75 145.35,22.75 v1(145.72,22.37)
  BOTTOM w0.102: v5(121.62,36.4) 122.04,36.81 U1.AA3 ; UH4.BJ10 146.97,22.96 146.97,22.88 146.84,22.75 146.63,22.75 146.59,22.79 146.59,23.06 146.53,23.12 146.34,23.12 145.96,22.74 145.83,22.74 145.72,22.64 v1(145.72,22.37)
FDI_CTX_PRX_P7: length 43.3
  IN1 w0.091: v5(121.36,38.82) 121.36,39.03 121.45,39.13 121.68,39.13 121.77,39.03 121.77,37.57 121.06,36.85 121.06,34.82 121.76,34.12 121.76,29.27 122.21,28.82 122.21,28.21 123.42,26.99 126.17,26.99 131.05,22.11 136.01,22.11 136.68,22.77 139.6,22.77 140.19,22.18 141.13,22.18 141.72,21.59 142.73,21.59 143.17,21.15 144.52,21.15 144.68,21.31 144.94,21.31 v1(145.18,21.07)
  BOTTOM w0.102: U1.AC8 120.89,39.29 v5(121.36,38.82) ; UH4.BH9 147.56,22.54 147.56,22.54 147.68,22.42 147.68,22.36 147.4,22.08 147.33,22.08 147.06,22.35 146.74,22.35 146.04,21.66 145.9,21.66 145.56,21.32 145.43,21.32 v1(145.18,21.07)
FDI_FSYNC0: length 54.9
  IN1 w0.084: v5(122.36,41.15) 121.98,40.78 121.98,40.61 121.7,40.33 121.23,40.33 120.27,39.37 120.27,34.29 120.83,33.73 120.83,28.27 123.73,25.37 125.76,25.37 130.49,20.64 135.79,20.64 136.33,21.18 136.4,21.18 137.01,21.79 138.54,21.79 138.89,21.43 139.61,21.43 139.8,21.25 140.74,21.25 141.33,20.66 142.34,20.66 142.87,20.13 145.88,20.13 148.64,22.9 149.48,22.9 150,23.42 150,23.7 150.11,23.81 150.94,23.81 151.36,24.22 151.36,24.75 151.48,24.88 151.91,24.88 152.2,24.59 152.2,23.92 152.44,23.68 v1(152.7,23.68)
  BOTTOM w0.102: UH4.AV12 152.32,24.06 v1(152.7,23.68) ; U1.AA11 122.14,40.93 v5(122.36,41.15)
FDI_FSYNC1: length 55.3
  IN1 w0.084: v5(121.38,41.53) 120.73,40.88 119.99,40.88 118.32,39.22 118.32,37.36 118.28,37.31 118.28,36.32 118.48,36.12 118.48,34.93 118.81,34.6 118.81,33.19 119.44,32.56 119.44,27.05 122.51,23.98 124.44,23.98 124.82,23.6 124.82,23.08 129.38,18.52 135.64,18.52 136.58,19.45 140.56,19.45 140.75,19.26 141.77,19.26 142.82,18.21 145.69,18.21 149.25,21.76 149.25,21.84 149.83,22.43 v3(150.17,22.43)
  BOTTOM w0.102: v3(150.17,22.43) 149.75,22.85 UH4.BC10 ; U1.AC12 121.1,41.25 v5(121.38,41.53)
FDI_INT: length 61.6
  IN1 w0.084: v5(124.21,41.19) 123.84,41.56 123.84,41.97 123.39,42.42 122.36,42.42 122.01,42.07 122.01,41.48 121.79,41.26 121.79,40.68 121.63,40.51 119.88,40.51 118.51,39.14 118.51,37.87 119.07,37.31 119.07,34.65 119.27,34.45 119.27,33.38 119.9,32.75 119.9,27.88 123.34,24.44 124.8,24.44 130.26,18.98 135.45,18.98 136.38,19.92 140.76,19.92 140.95,19.73 141.96,19.73 142.49,19.2 146.42,19.2 149.06,21.84 149.06,21.92 149.97,22.83 150.8,22.83 151.28,23.31 151.28,23.89 151.75,24.36 v1(151.75,24.46)
  BOTTOM w0.102: v1(151.75,24.46) 151.33,24.88 151.33,25.69 UH4.AW16 ; v5(124.21,41.19) 123.99,41.19 U1.U11
FDI_LSYNC0: length 52.5
  IN1 w0.084: v3(152.65,24.52) 152.11,25.07 151.4,25.07 151.17,24.83 151.17,24.3 150.87,24 150.03,24 149.81,23.78 149.81,23.49 149.4,23.08 148.57,23.08 146.08,20.6 143.06,20.6 142.54,21.12 141.52,21.12 140.93,21.72 139.99,21.72 139.81,21.9 139.09,21.9 138.73,22.25 136.82,22.25 136.21,21.64 130.14,21.64 125.94,25.85 123.91,25.85 121.29,28.46 121.29,33.92 120.47,34.75 120.47,39.29 121.28,40.11 121.75,40.11 122.13,40.49 v5(122.37,40.49)
  BOTTOM w0.102: UH4.AV14 152.31,24.86 v3(152.65,24.52) ; U1.AA10 122.16,40.28 v5(122.37,40.49)
FDI_LSYNC1: length 49.7
  IN1 w0.084: v1(150.72,23.41) 150.3,23.41 148.96,22.08 148.17,22.08 145.76,19.67 142.68,19.67 142.15,20.19 141.14,20.19 140.95,20.38 136.19,20.38 135.25,19.45 130.45,19.45 124.99,24.91 123.53,24.91 120.36,28.08 120.36,32.95 119.74,33.57 119.74,34.78 119.26,35.26 119.26,37.47 119.3,37.52 119.3,39.38 v5(119.81,39.88)
  BOTTOM w0.102: U1.AG8 119.55,39.88 v5(119.81,39.88) ; v1(150.72,23.41) 150.38,23.08 UH4.BB10
FWP#: length 10
  TOP w0.102: R872.1 R879.2 v3(295.15,52.32) ; U51.B65 290.51,54.58 v1(291.03,55.1)
  IN1 w0.084: v1(291.03,55.1) 290.57,54.64 290.57,53.58 290.94,53.21 294.26,53.21 v3(295.15,52.32)
G: length 6.2
  BOTTOM w0.102: JCRT1.2 6.32,73.11 7.08,72.35 8.62,72.35 9.26,72.99 C1206.1 10.43,72.99 L100.2
GP1_SW: length 23.5
  IN1 w0.254: v1(135.92,93.05) 135.22,93.75 121.06,93.75 119.86,92.54 119.86,90.4 v1(119.97,90.28)
  BOTTOM w0.254: v1(135.92,93.05) 136.11,93.24 v2(136.43,93.24) PR758.2 ; v1(119.97,90.28) 119.97,90.33 119.53,90.78 PL704.3
GP1_VO: length 31.3
  IN1 w0.254: v1(119.31,90.26) 119.44,90.38 119.44,92.76 119.65,92.97 120.88,94.2 139.06,94.2 v1(140.2,93.06)
  BOTTOM w0.254: PR759.1 142.47,94.13 141.28,94.13 v2(141,93.85) 140.21,93.06 v1(140.2,93.06) ; v1(119.31,90.26) 119.31,89.8 119.53,89.58 PL704.2
GPU_SMBCLK: length 6.9
  TOP w0.102: U51.B49 283.96,55.35 v3(284.1,55.2) ; R822.2 283.67,50.59 283.67,50.74 v1(283.88,50.94)
  IN1 w0.084: v3(284.1,55.2) 283.58,55.2 283.24,54.85 283.24,52.94 283.55,52.63 283.55,51.27 v1(283.88,50.94)
GPU_SMBDAT: length 9.1
  TOP w0.102: v3(283.24,50.94) 283.44,50.74 283.44,50.54 R829.2 ; U51.B48 283.67,55.85 283.89,55.63 284.39,55.63 v1(284.83,56.06)
  IN1 w0.084: v3(283.24,50.94) 283.33,51.03 283.33,52.54 283.02,52.85 283.02,54.96 283.68,55.62 284.39,55.62 v1(284.83,56.06)
GREEN_CRT: length 220.7
  TOP w0.102: v1(11.36,70.57) 11.17,70.57 10.74,71 R1642.1 C1203.1 11.88,71.17 v1(12.38,71.17) ; v1(30.49,81.98) v2(29.93,81.98) 29.57,81.98 29,81.4 D77.2 29,77.99 v1(29.24,77.75)
  IN3 w0.122: v1(129.95,38.26) 128.94,39.28 128.94,42.03 129.2,42.3 129.2,43.89 127.2,45.9 127.2,54.45 126.66,54.99 126.08,54.99 124.47,56.6 123.55,56.6 122.52,57.63 122.52,59.56 121.54,60.54 121.54,64.79 121.1,65.24 110.32,65.24 96.93,78.63 94.78,78.63 90.39,83.02 90.39,85.48 89.57,86.31 68.57,86.31 67.77,87.11 49.87,87.11 45.09,82.33 34.88,82.33 34.17,81.62 30.84,81.62 v1(30.49,81.98) ; v1(29.24,77.75) 28.14,76.64 21.84,76.64 21.2,77.28 14.76,77.28 13.75,76.26 13.75,72.54 v1(12.38,71.17)
  IN4 w0.084: v1(165.43,51.3) 165.02,51.3 164.46,51.86 161.09,51.86 158.49,49.26 154.64,49.26 154.16,49.74 151.2,49.74 143.05,41.6 143.05,40.46 141.86,39.27 141.86,38.08 140.85,37.07 133.74,37.07 132.71,38.11 130.1,38.11 v1(129.95,38.26)
  BOTTOM w0.102: L100.1 11.36,70.57 v1(11.36,70.57) ; UH4.P49 164.16,43.5 165.52,44.87 165.52,48.47 RH132.2 165.03,49.69 165.17,49.83 165.17,51.04 v1(165.43,51.3)
H_CATERR#: length 24.5
  IN1 w0.084: v1(129.19,78.52) 129.19,77.68 128.55,77.05 128.55,73.33 130.59,71.3 130.59,64.56 131.84,63.31 131.84,61.16 131.44,60.75 v1(131.44,59.48)
  BOTTOM w0.102: v1(131.44,59.48) 131.06,59.86 U1.C49 ; RC128.2 129.69,81.09 v2(129.69,79.96) 129.19,79.46 v1(129.19,78.52)
H_CPU_SVIDALRT#: length 3.3
  TOP w0.102: RC61.1 130.27,57.18 130.48,57.39 v2(131.22,57.39) 131.84,57.39 v1(132.29,56.93)
  BOTTOM w0.102: v1(132.29,56.93) 131.91,56.93 U1.A44
H_CPUPWRGD: length 131.4
  TOP w0.102: v1(128.57,67.35) 128.43,67.49 CC141.1 129.13,68.04 RC25.1 ; RC5.1 94.5,89.41 v4(94.56,89.35) 95.22,88.69 95.22,85.18 v1(96.12,84.27)
  IN4 w0.084: v1(151.73,23.1) 150.84,23.99 148.01,23.99 147.68,24.32 136.24,24.32 134.85,22.93 131.36,22.93 128.99,25.3 128.99,26.88 127.95,27.92 125.62,27.92 124.95,28.58 124.95,29.94 123.23,31.66 123.23,35.87 124.19,36.83 124.19,37.86 123.75,38.29 123.75,42.17 122,43.93 122,56.65 122.66,57.31 125.38,57.31 126.24,58.18 126.24,58.38 126.78,58.91 126.78,59.29 125.86,60.21 125.86,63.31 126.26,63.7 126.71,63.7 128.4,65.39 128.4,67.18 v1(128.57,67.35) 128.57,69.92 128.1,70.39 128.1,75.19 124.46,78.83 116.75,78.83 115.64,77.72 113.82,77.72 112.68,78.87 106.7,78.87 105.37,80.2 100.2,80.2 v1(96.12,84.27)
  BOTTOM w0.102: UH4.AY11 151.42,23.4 v1(151.73,23.1)
H_CPUPWRGD_XDP: length 12.2
  TOP w0.102: 91.01,88.21 90.48,87.67 90.48,79.61 89.64,78.78 JXDP1.10 ; 91.01,88.21 RC5.2 ; 91.01,88.21 v4(91.01,88.21)
H_PM_SYNC: length 77.3
  TOP w0.102: v1(153.76,24.99) 154.29,24.46 T63.1
  IN3 w0.102: v1(153.76,24.99) 154.1,24.65 154.88,24.65 155.22,24.99 155.22,25.46 155.8,26.03 155.8,28.38
  IN3 w0.122: 155.8,28.38 154.95,29.23 154.95,31.86 154.45,32.36 154.45,32.79 153.08,34.16 153.08,34.71 152.82,34.96 150.79,34.96 149.79,35.96 144.52,35.96 144.4,35.84 144.4,34.96 144.28,34.83 143.91,34.83 143.79,34.96 143.79,36.1 143.66,36.23 143.31,36.23 143.18,36.1 143.18,34.96 143.06,34.83 142.69,34.83 142.57,34.96 142.57,36.1 142.45,36.23 142.07,36.23 141.94,36.1 141.94,34.91 141.81,34.78 141.37,34.78 141.24,34.91 141.24,36.98 140.83,37.39 138.47,37.39 138.35,37.26 138.35,36.61 138.22,36.48 137.84,36.48 137.72,36.61 137.72,37.27 137.6,37.39 137.23,37.39 137.11,37.27 137.11,36.61 136.99,36.48 136.62,36.48 136.5,36.61 136.5,37.27 136.38,37.39 136.01,37.39 135.89,37.27 135.89,36.61 135.77,36.48 135.4,36.48 135.28,36.61 135.28,37.79 135.16,37.92 134.8,37.92 134.67,37.79 134.67,36.61 134.55,36.48 134.17,36.48 134.04,36.61 134.04,38.94 133.91,39.06 133.52,39.06 133.39,38.94 133.39,38.15 133.27,38.02 132.94,38.02 132.81,38.15 132.81,55.42 132.53,55.7 132.06,55.7 131.37,56.39 131.37,58.29 v5(132.26,59.18)
  BOTTOM w0.102: U1.C48 131.33,59.03 131.64,58.72 132.09,58.72 132.26,58.89 v5(132.26,59.18) ; UH4.AP14 154.2,25.43 v1(153.76,24.99)
H_PROCHOT#: length 486
  TOP w0.102: RC44.2 RC57.1 v1(137.95,81.12) ; R1180.2 278.43,51.32 v1(276.34,51.32) 275.49,50.48 Q47.1 ; PR1339.2 v1(42.37,31.59) ; PR721.1 148.23,87.37 148.24,87.35 PC719.1 153.18,86.9 v1(154.17,87.9)
  IN1 w0.084: v1(178.53,47.84) 178.08,48.29 172.78,48.29 169.73,51.34 169.73,53.41 169.11,54.03 169.11,57.18 168.35,57.94 168.35,61.38 168.64,61.67 168.64,75.89 168.11,76.42 168.11,77.27 167.14,78.24 167.14,86.31 165.94,87.51 165.94,90 165.2,90.74 165.2,93.03 164.53,93.7 164.53,94.94 162.3,97.16 162.3,98.49 160.48,100.3 159.09,100.3 155.9,103.48 152.77,103.48 151.14,105.11 148.17,105.11 v1(147.68,105.6) ; v1(137.95,81.12) 135.68,81.12 134.41,79.85 116.96,79.85 115.83,80.99 115.83,88.31 113.72,90.42 v1(113.72,96.55) ; v1(42.37,31.59) 43.12,32.34 43.12,50.82 46.42,54.12 46.42,71.54 45,72.96 45,77.01 v1(45.24,77.25) ; v1(276.34,51.32) 275.56,50.55 270.27,50.55 266.07,46.35 v1(257.66,46.35)
  IN3 w0.122: v1(181.92,15.25) 181.23,15.94 181.23,17.76 182.09,18.62 182.09,21 183.03,21.93 183.03,24.01 182.29,24.75 182.29,25.88 182.85,26.44 182.85,29.45 182.3,29.99 182.3,31.66 183.32,32.67 183.32,36.57 182.61,37.28 182.61,42.35 178.53,46.43 v1(178.53,47.84) ; v3(135.29,95.07) 136.46,95.07 143.83,102.43 144.52,102.43 v1(147.68,105.6) ; v1(255.27,23.47) 256.14,24.34 256.14,30.41 256.32,30.59 256.32,37.3 257.27,38.24 257.27,40.48 257.72,40.93 257.72,44.05 257.66,44.1 v1(257.66,46.35)
  IN4 w0.084: v1(181.92,15.25) 182.8,14.37 196.53,14.37 201.96,19.8 219.68,19.8 220.28,20.39 233.23,20.39 235.89,23.05 254.85,23.05 v1(255.27,23.47) ; v1(154.17,87.9) 154.17,90.12 151.71,92.58 147.44,92.58 147,93.02 141.25,93.02 140.81,92.58 139.82,92.58 139.54,92.86 137.08,92.86 135.29,94.66 v3(135.29,95.07) 135.29,96.21 134.91,96.58 133.15,96.58 130.67,99.06 116.57,99.06 114.05,96.55 v1(113.72,96.55) 108.81,96.55 101.34,89.08 92.67,89.08 91.98,88.39 87.41,88.39 87.17,88.14 70.08,88.14 67.37,85.43 67.37,83.14 66.86,82.64 64.24,82.64 62.36,80.76 57.05,80.76 56.24,79.94 48.06,79.94 45.37,77.25 v1(45.24,77.25)
H_PROCHOT#_R: length 26.6
  TOP w0.102: v3(136.29,78.78) 136.29,79.21 RC57.2
  IN1 w0.084: v1(132.92,57.81) 133.24,58.13 133.24,71.59 135.95,74.29 135.95,78.43 v3(136.29,78.78)
  BOTTOM w0.102: U1.C45 131.32,57.92 131.7,58.3 132.71,58.3 132.92,58.09 v1(132.92,57.81)
H_SNB_IVB#: length 73.8
  TOP w0.102: v1(144.65,16.09) v2(145.79,17.23)
  IN2 w0.122: v1(144.65,16.09) 144.42,16.32 143.58,16.32 142.56,17.33 142.56,18.21 140.95,19.82 139.34,19.82 138.65,20.51 138.65,29.99 137.71,30.93 137.71,36.17 135.51,38.37 135.51,41.62 v1(134.5,42.63)
  IN4 w0.084: v5(129.28,60.43) 129.64,60.79 130.04,60.79 130.35,60.49 130.35,59.98 131.68,58.65 131.68,56.44 131.12,55.88 127.78,55.88 127.77,55.87 124.29,55.87 123.74,55.32 123.74,47.47 124.08,47.13 125.28,47.13 125.65,46.76 125.65,45.86 126.22,45.29 128.31,45.29 129.94,43.66 133.47,43.66 v1(134.5,42.63)
  BOTTOM w0.102: v1(144.65,16.09) 145.19,16.63 146.83,16.63 RH150.1 ; v5(129.28,60.43) 129.25,60.4 U1.F49
H_THERMTRIP#: length 44.3
  TOP w0.102: RC129.1 RC126.2 136,81.61 138.84,81.61 141.66,78.79 149.34,78.79 v4(149.94,79.38) 150.86,80.3 152.84,80.3 154.23,81.7 v1(154.79,81.7)
  BOTTOM w0.102: Q16.3 168.6,90.55 165.96,87.91 158.74,87.91 156.58,85.75 156.58,83.49 v1(154.79,81.7)
H_THERMTRIP#_R: length 31.2
  TOP w0.102: RC129.2 134.63,79.5 135.95,78.17 v3(136.96,78.17)
  IN4 w0.084: v3(136.96,78.17) 137.43,77.71 137.43,74.98 134.1,71.65 134.1,64.27 133.17,63.33 131.12,63.33 130.13,62.34 129.57,62.34 128.07,60.84 128.07,58.95 128.45,58.57 129.34,58.57 v1(129.9,58.01)
  BOTTOM w0.102: U1.D45 130.09,57.81 v1(129.9,58.01)
HDD_DET#: length 134.4
  TOP w0.102: v1(160.62,22.46) 161.08,22.46 161.45,22.83 RH30.2 161.22,23.33 161.22,23.82 160.9,24.14 160.88,24.14 RH290.2 ; v1(270.29,19.77) v2(270.29,20.53)
  IN2 w0.102: 161.75,17.59 161.83,17.59 162.12,17.88 162.12,18.73 161.16,19.69 161.16,21.93 v1(160.62,22.46)
  IN2 w0.122: v1(270.29,19.77) 269.77,20.29 244.08,20.29 241.22,17.43 224.99,17.43 216.98,9.42 208.03,9.42 206.98,10.47 203.94,10.47 203.36,11.06 198.34,11.06 198.07,10.79 193.38,10.79 190.11,7.53 179.51,7.53 178.07,8.97 172.97,8.97 168.55,13.4 168.55,14.18 168.04,14.69 162.14,14.69 161.21,15.63 161.21,17.32 161.46,17.57 161.74,17.57 161.75,17.59
  BOTTOM w0.102: JMINI3.51 269.94,18.5 270.29,18.84 v1(270.29,19.77)
HDD_DET#_R: length 3.3
  TOP w0.102: v1(161.67,25.14) 161.45,24.91 RH290.1 161.77,24.48 162.12,24.13 162.12,23.61 v2(162.5,23.23)
  BOTTOM w0.102: UH4.V14 161.88,25.14 v1(161.67,25.14)
HDMI_CEC: length 12.2
  TOP w0.102: v3(75.66,100.43) 79.74,100.43 81.25,101.94 81.25,102.96 80.84,103.36 78.11,103.36 JHDMI1.13
  BOTTOM w0.102: v3(75.66,100.43) 75.66,100.02 R1165.2
HDMI_HPD_SINK: length 15.4
  IN1 w0.084: JHDMI1.19 80.89,103.58 80.89,101.94 78.56,99.6 v1(78.56,99.31)
  BOTTOM w0.102: v2(79.66,91.67) 79.27,92.06 R1128.1 ; R1128.1 Q121.1 ; R1128.1 78.69,93.42 78.69,99.17 v1(78.56,99.31)
HDMI_OB: length 33.3
  IN4 w0.084: v1(77.95,94.05) 77.75,94.24 75.48,94.24 v1(75.28,94.04) v1(74.26,94.04) v1(71.37,94.04) 70.94,94.46 67.94,94.46 v1(67.21,93.74) 67.21,92.92 65.94,91.65 v3(65.94,90.78)
  BOTTOM w0.102: R455.2 74.06,94.24 v1(74.26,94.04) ; R454.2 v1(75.28,94.04) ; v3(65.94,90.78) 70.02,90.78 70.31,91.07 70.31,91.93 R449.2 ; v3(65.94,90.78) 64.55,92.17 R452.2 ; v3(65.94,90.78) 65.94,88.43 65.68,88.16 Q26.1 ; R448.2 66.95,92.62 66.95,93.47 v1(67.21,93.74) R450.2 ; R456.2 71.39,94.07 v1(71.37,94.04) ; R453.2 v1(77.95,94.05)
HDMIB_PCH_HPD: length 153.8
  TOP w0.102: v1(168.57,56.82) 167.49,56.82 165.98,55.31 162.45,55.31 159.78,52.64 159.78,47.1 157.27,44.59 157.27,41.22 155.33,39.28 155.33,38.61 155.11,38.39 v1(153.78,38.39)
  IN4 w0.084: v1(168.57,56.82) 168.99,57.24 168.99,70.55 168.18,71.37 168.18,75.5 169.46,76.78 169.46,79.92 160.76,88.63 159.87,88.63 153.45,95.06 139.17,95.06 135.74,98.49 133.94,98.49 130.35,102.08 116.68,102.08 114.22,99.62 105.71,99.62 97.98,91.89 90.65,91.89 v1(89.92,91.16)
  BOTTOM w0.102: v1(89.92,91.16) 88.75,92.33 v2(85.41,92.33) R1168.1 83.55,92.33 83.42,92.2 Q121.3 ; v1(153.78,38.39) 153.55,38.16 UH4.AT40
HOST_DEB_RX: length 4.9
  TOP w0.102: JDEG2.9 264.45,59.29 264.71,59.55 265.46,59.55 265.61,59.4 v2(267.33,59.4) 267.84,59.9 R855.1
HOST_DEB_TX: length 3
  TOP w0.102: JDEG2.8 263.95,59.26 v2(264.98,60.28) 265.26,60.56 R853.1
HOST_DEBUG_RX: length 40.7
  TOP w0.102: v1(284.84,57) 284.38,56.55 283.96,56.55 283.66,56.85 U51.B46 ; R855.2 R849.2 269.77,61.48 v1(269.84,61.4)
  IN1 w0.084: v3(256.04,57.29) 256.04,59.71 258.14,61.81 263.91,61.81 265.03,60.69 268.52,60.69 269.39,61.55 269.69,61.55 v1(269.84,61.4) 270.01,61.57 271,61.57 273.3,59.27 282.15,59.27 283.06,58.35 284.35,58.35 284.59,58.11 284.59,57.25 v1(284.84,57)
  BOTTOM w0.102: JMINI2.17 256.2,57.45 v3(256.04,57.29)
HOST_DEBUG_TX: length 43.4
  TOP w0.102: v1(269.83,62.04) 269.43,62.44 v2(268.12,62.44) 267.85,62.44 R848.2 R853.2 ; v1(257.16,65.05) 257.33,64.87 C595.1 ; U51.B44 283.62,57.85 283.98,57.49 284.58,57.49 v1(285.02,57.93)
  IN1 w0.084: v1(257.16,65.05) 260.18,62.02 264.04,62.02 265.11,60.95 268.45,60.95 269.29,61.8 269.59,61.8 v1(269.83,62.04) 270.09,61.78 271.08,61.78 273.38,59.48 282.24,59.48 282.24,59.48 282.34,59.48 283.25,58.57 284.47,58.57 285.02,58.02 v1(285.02,57.93)
  BOTTOM w0.102: JMINI2.16 259.8,65.66 259.4,65.26 257.37,65.26 v1(257.16,65.05)
HSYNC: length 7.8
  BOTTOM w0.102: UH4.M47 165.15,41.82 164.83,42.15 164.83,42.62 166.88,44.68 v2(166.88,46.14) 166.76,46.26 166.76,47.81 RH123.2
HSYNC_BUF: length 215.1
  TOP w0.102: U73.2 20.17,78 20.35,77.82 21.77,77.82 22.09,77.51 22.74,77.51 R1668.1 23.73,77.04 24.17,77.48 v1(24.17,78.09)
  IN3 w0.122: v3(159.79,98.34) 159.61,98.15 159.61,94.65 161.37,92.88 161.37,90.53 160.71,89.87 160.71,73.48 161.85,72.34 161.85,56.16 166.12,51.89 166.12,51.31 166.59,50.83 166.59,50.07 v1(167.03,49.63)
  IN4 w0.084: v1(24.17,78.09) 24.17,78.09 26.54,80.46 26.54,82.49 29.47,85.42 39.13,85.42 41.95,88.23 62.69,88.23 64.67,90.21 64.67,93.83 65.89,95.06 87.21,95.06 94.12,101.97 95.37,101.97 99.73,106.33 107.72,106.33 109.96,108.56 117.25,108.56 117.68,108.14 133.18,108.14 137.39,103.93 149.09,103.93 151,102.02 155.72,102.02 159.4,98.34 v3(159.79,98.34)
  BOTTOM w0.102: RH123.1 167,49.6 v1(167.03,49.63)
HSYNC_CRT: length 11.4
  TOP w0.102: L102.1 13.29,74.93 13.59,75.23 13.59,75.71 14.52,76.64 16.66,76.64 v2(17.35,75.95) 17.35,75.94 17.98,75.94 18.33,76.3 19.17,76.3 20.22,77.35 U73.4 21.64,77.35 21.95,77.04 R1668.2
HW_GPS_DISABLE2#: length 56.1
  TOP w0.102: U46.B34 268.99,79.31 269.76,80.08 271.79,80.08 R798.2 272.31,80.6 275.57,80.6 v1(276.29,79.88)
  IN3 w0.122: v1(276.29,79.88) 276.1,79.69 276.1,78.81 275.32,78.02 275.32,50.04 274.71,49.43 274.71,45.72 274.04,45.05 274.04,42.49 v3(275.55,40.98)
  BOTTOM w0.102: v3(275.55,40.98) 277.01,39.52 277.01,36.28 276.6,35.88 JMINI1.51
ICOUT: length 8.6
  TOP w0.102: PR1319.2 v2(40.14,14.5)
  TOP w0.254: PU1300.26 34.19,16.92 PC1309.1 v1(35.59,14.82) ; v1(38.26,15.2) 38.64,14.82 PR1319.2
  IN1 w0.254: v1(35.59,14.82) 37.88,14.82 v1(38.26,15.2)
IMVP_PWRGD: length 169.2
  TOP w0.102: v1(256.85,72.36) 257.05,72.56 U46.A62
  IN1 w0.084: v1(169,76.93) 169.54,76.4 169.54,73.77 170.58,72.72 170.58,64.16 169.96,63.54 169.96,61.19 169.75,60.98 169.75,60.45 171.41,58.8 171.41,51.75 173.39,49.77 181.61,49.77 183.99,47.39 185.96,47.39 186.43,47.85 187.63,47.85 190.66,44.82 194.23,44.82 195.65,43.39 195.65,42.44 196.28,41.82 196.28,40.06 199.28,37.05 217.61,37.05 234.69,54.13 234.69,56.26 237.11,58.68 237.11,70.5 238.24,71.63 241.1,71.63 241.31,71.85 251.65,71.85 251.86,72.07 255.62,72.07 255.91,72.36 v1(256.85,72.36)
  BOTTOM w0.254: PR726.2 PR708.2 PR728.2 151.99,79.83 152.51,79.83 153.82,81.14 155.16,81.14 156.19,82.17 v4(157.28,82.17) 157.3,82.15 160.66,82.15 162.01,80.81 162.01,78.32 163.73,76.59 168.66,76.59 v1(169,76.93)
IMVP_VR_ON: length 199.8
  TOP w0.102: v1(253.41,71.4) 253.84,70.96 254.89,70.96 R765.2
  TOP w0.254: v1(150.36,97.47) v4(150.36,99.63) 149.74,100.25 v1(149.74,105.6)
  IN1 w0.084: v1(149.74,105.6) 151.26,105.6 152.95,103.91 156.1,103.91 159.25,100.76 160.69,100.76 162.77,98.68 162.77,97.39 164.98,95.18 164.98,93.99 165.63,93.34 165.63,90.92 166.39,90.16 166.39,87.67 167.57,86.49 167.57,78.42 168.54,77.45 168.54,76.6 169.33,75.81 169.33,73.68 170.37,72.64 170.37,64.25 169.75,63.63 169.75,61.28 169.53,61.05 169.53,60.38 171.2,58.71 171.2,51.66 173.3,49.56 181.52,49.56 183.9,47.18 186.05,47.18 186.52,47.64 187.54,47.64 190.61,44.57 192.92,44.57 195.84,41.65 195.84,39.89 199.11,36.63 217.78,36.63 238.91,57.75 238.91,66.69 237.61,67.99 237.61,70.35 238.47,71.21 241.27,71.21 241.49,71.43 253.38,71.43 v1(253.41,71.4)
  BOTTOM w0.254: PR722.1 146.55,92.94 150.36,96.75 v1(150.36,97.47)
INT_SPK_L+: length 278.3
  TOP w0.254: v1(30.26,31.96) 30.14,32.08 U72.40
  TOP w0.508: C976.1 30.38,31.84 v1(30.26,31.96) ; v3(245.36,47.3) 245.36,48.58 243.36,50.57 243.36,56.74 L94.1
  IN3 w0.508: v3(245.36,47.3) 246.39,46.27 246.39,25.52 243.83,22.97 238.25,22.97 236.94,21.66 v1(236.94,20.63)
  IN4 w0.508: v1(236.94,20.63) 236.94,19.7 235.7,18.47 221.1,18.47 220.51,17.87 206.89,17.87 205.5,16.48 203.63,16.48 198.51,11.36 192.74,11.36 191.53,10.16 182.91,10.16 182.29,10.78 180.05,10.78 178.89,9.62 160.88,9.62 155.38,15.12 153.01,15.12 152.34,15.79 146.53,15.79 145.97,15.22 138.07,15.22 137.22,16.08 135.51,16.08 134.81,16.78 132.19,16.78 129.65,19.32 124.48,19.32 123.91,19.89 120.66,19.89 120.09,19.32 118.22,19.32 117.67,19.87 112.63,19.87 111.16,18.4 65.73,18.4 63.49,16.16 54.87,16.16 49.66,21.37 49.66,23.19 38.92,33.93 30.97,33.93 30.26,33.22 v1(30.26,31.96)
INT_SPK_L-: length 276.9
  TOP w0.254: v1(31.17,31.94) 30.64,32.47 U72.41
  TOP w0.508: v3(246.49,47.28) 246.49,49.03 244.35,51.17 244.35,56.39 L93.1 ; v1(31.17,31.94) 31.17,30.6 31.34,30.44 C975.1
  IN3 w0.508: v1(237.7,20.66) 237.7,21.34 238.56,22.21 244.15,22.21 247.17,25.23 247.17,46.59 v3(246.49,47.28)
  IN4 w0.508: v1(31.17,31.94) 31.17,32.61 31.73,33.17 38.6,33.17 48.8,22.98 48.8,20.99 54.39,15.4 63.81,15.4 66.05,17.64 111.48,17.64 112.39,18.55 129.34,18.55 132.58,15.31 136.9,15.31 137.76,14.46 146.28,14.46 146.85,15.03 152.03,15.03 152.7,14.36 155.06,14.36 160.64,8.79 179.13,8.79 179.72,9.38 191.83,9.38 193.06,10.6 198.86,10.6 203.97,15.72 205.81,15.72 206.64,16.55 210.79,16.55 211.35,17.11 220.87,17.11 221.46,17.71 236.02,17.71 237.7,19.39 v1(237.7,20.66)
INT_SPK_R+: length 278.3
  TOP w0.254: v1(32.64,32) 32.64,32.15 32.14,32.66 U72.44
  TOP w0.508: C974.1 33.24,29.55 32.9,29.89 32.9,31.75 v1(32.64,32) ; v3(247.77,47.29) 247.3,47.76 247.3,55.84 L92.1
  IN3 w0.508: v1(238.46,20.69) 238.46,21.03 238.88,21.45 244.56,21.45 247.93,24.83 247.93,47.13 v3(247.77,47.29)
  IN4 w0.508: v1(238.46,20.69) 238.46,19.07 235.74,16.35 211.76,16.35 211.19,15.78 206.96,15.78 204.41,13.24 204.41,12.69 201.56,9.84 193.37,9.84 191.86,8.33 190.4,8.33 189.37,7.29 178.63,7.29 177.89,8.02 160.32,8.02 154.75,13.6 152.38,13.6 151.71,14.27 147.17,14.27 145.94,13.05 135.61,13.05 134.1,14.55 132.26,14.55 129.02,17.79 112.78,17.79 111.87,16.88 79.37,16.88 76.19,13.7 53.55,13.7 47.86,19.39 47.86,22.84 39.04,31.66 33.77,31.66 33.43,32 v1(32.64,32)
INT_SPK_R-: length 282.2
  TOP w0.254: U72.43 31.64,32.3 v1(31.97,31.96)
  TOP w0.508: v1(31.97,31.96) 31.97,30.95 32.14,30.78 32.14,29.46 C973.1 ; v3(248.91,47.28) 248.91,52.56 250.63,54.28 L91.1
  IN3 w0.508: v3(248.91,47.28) 248.7,47.06 248.7,24.51 244.87,20.69 v1(239.22,20.69)
  IN4 w0.508: v1(31.97,31.96) 31.97,29.75 34.66,27.06 42.56,27.06 47.1,22.52 47.1,19.07 53.23,12.94 76.51,12.94 79.69,16.12 112.3,16.12 113.22,17.03 128.71,17.03 131.95,13.79 133.79,13.79 135.29,12.28 146.43,12.28 146.98,12.84 154.43,12.84 161.82,5.45 177.96,5.45 179.04,6.53 189.68,6.53 190.68,7.53 192.21,7.53 193.2,8.52 201.32,8.52 205.17,12.37 205.17,12.92 207.27,15.02 211.59,15.02 212.15,15.59 236.05,15.59 239.22,18.76 v1(239.22,20.69)
INT_SPKL_L+: length 11.4
  TOP w0.508: JSPK1.4 246.2,66.8 245.79,66.39 244.71,66.39 v2(244.05,65.73) DE1.2 244.05,61.27 243.57,60.79 243.57,59.78 C1318.1 243.72,58.47 L94.2
INT_SPKR_L-: length 11.2
  TOP w0.508: L93.2 245.35,58.1 246.4,59.15 C1319.1 246.4,60.6 245.98,61.02 DE1.3 245.98,62.57 246.75,63.34 v2(246.75,64.69) 246.75,65.95 247.4,66.59 JSPK1.3
INT_SPKR_R+: length 10.5
  TOP w0.508: L92.2 247.67,58.65 C1320.1 247.67,60.36 248.11,60.8 DE2.2 248.11,62.66 247.52,63.26 247.52,65.15 v2(248.29,65.92) 248.6,66.23 JSPK1.2
INT_SPKR_R-: length 10.1
  TOP w0.508: L91.2 250.34,58.45 C1321.1 250.34,60.33 250.04,60.63 DE2.3 250.04,64.87 250.46,65.29 250.46,65.92 250.14,66.24 v2(250.04,66.24) 249.8,66.48 JSPK1.1
INTRUDER#: length 42.9
  IN4 w0.084: v1(166.72,28.54) 166.72,28.9 166.25,29.37 166.25,29.79 166.39,29.93 171.11,29.93 171.24,29.8 174.79,29.8 175.49,30.5 179.37,30.5 180.04,29.83 180.04,27.24 180.31,26.97 182.65,26.97 183.36,27.68 186.83,27.68 187.42,28.26 191.24,28.26 v1(191.45,28.06)
  BOTTOM w0.102: v1(191.45,28.06) 193.34,29.95 193.34,34.71 v2(192.68,35.37) 192.68,36 RH11.2 ; v1(166.72,28.54) 166.72,28.68 166.42,28.98 UH4.K22
IRQ_SERIRQ: length 258.5
  TOP w0.102: U51.A28 286.26,64.31 v1(286,64.58) ; v1(161.69,21.03) 162.16,20.57 162.16,18.21 161.24,17.29 161.24,16.63 162.22,15.66 164.72,15.66 165.3,15.08 168.7,15.08 169.07,14.71 171.73,14.71 173.47,12.97 176.23,12.97 176.56,13.3 v2(179.79,13.3) 181.42,13.3 182.57,14.45 183.79,14.45 184.35,15 184.35,17.29 185.2,18.15 185.72,18.15 186.39,18.82 RH28.2 ; U46.B21 267.86,72.81 v1(267.36,73.31)
  IN1 w0.084: v1(267.36,73.31) 266.94,73.73 266.94,74.96 267.37,75.39 268.39,75.39 269.49,76.49 272.7,76.49 280.6,68.59 282.63,68.59 283.05,68.17 283.05,66.67 284.73,65 285.58,65 v1(286,64.58)
  IN2 w0.102: 167.86,17.59 166.73,18.72 164,18.72 v1(161.69,21.03)
  IN2 w0.122: v1(270.22,30.25) 268.63,30.25 266.7,28.32 252.93,28.32 252.04,27.44 247.11,27.44 239.83,20.16 221.23,20.16 218.68,17.61 212.43,17.61 211.46,16.65 202.35,16.65 202.18,16.48 198.16,16.48 196.6,14.92 186.76,14.92 185.34,13.5 176.45,13.5 175.74,14.2 175.41,14.2 174.46,15.16 171.81,15.16 169.61,17.36 168.09,17.36 167.86,17.59
  IN3 w0.122: v1(270.22,30.25) 271.43,31.45 271.43,41.53 273.24,43.33 273.24,45.82 270.15,48.9 270.15,55.21 271.24,56.29 271.24,58.38 272.29,59.43 272.29,63.54 271.65,64.18 271.65,67.14 271.47,67.32 271.47,69.48 268.08,72.86 267.81,72.86 v1(267.36,73.31)
  BOTTOM w0.102: UH4.V5 161.86,20.86 v1(161.69,21.03) ; v1(270.22,30.25) 271.81,31.84 271.81,41.3 270.6,42.5 266.6,42.5 265.26,43.85 265.26,47.1 265.79,47.63 U39.27 U37.27
ISEN2: length 5.2
  BOTTOM w0.203: PU700.12 147.44,85.84 147.69,86.09 147.69,87.08 147.92,87.31 v2(147.92,88.39) 147.92,89 PR732.2
ISEN2G: length 6.2
  BOTTOM w0.203: 143.05,87.74 143.39,87.4 PU700.3
  BOTTOM w0.254: 143.05,87.74 143.05,91.27 v2(143.31,91.54) 143.93,92.16 PR713.2
JETWAY_14M: length 7.9
  BOTTOM w0.102: UH4.K49 166.41,42.28 166.63,42.49 166.63,43.37 168.37,45.11 168.37,47.22 168.88,47.72 v2(168.88,47.88) 168.7,48.05 RH315.2
JETWAY_CLK14M: length 117.8
  TOP w0.102: v1(168.57,56.18) 167.8,55.41 v2(167.8,53.25) 167.8,51.31 168.9,50.2 168.9,49.65 v1(168.61,49.36)
  IN4 w0.084: v1(256.24,53.81) 253.59,51.15 244.54,51.15 237.76,44.37 235.87,44.37 229.6,38.1 219.06,38.1 217.08,36.11 198.62,36.11 194.38,40.36 193.19,40.36 189.63,43.91 187.99,43.91 184.23,47.66 184.23,48.5 182.13,50.61 173.5,50.61 168.57,55.53 v1(168.57,56.18)
  BOTTOM w0.102: v1(168.61,49.36) 168.35,49.36 RH315.1 ; U39.13 U37.13 258.36,54.78 RE6.1 257.66,54.09 256.52,54.09 v1(256.24,53.81)
JTAG_CLK: length 36.7
  TOP w0.102: JDEG2.4 261.95,60.1 v2(261.96,60.11) 261.96,60.42 v1(262.15,60.61) 262.31,60.78 R860.2 ; U51.B56 286.01,53.98 286.27,54.24 286.27,54.67 v1(285.84,55.1)
  IN1 w0.084: v1(262.15,60.61) 262.69,60.61 264.7,58.6 270.64,58.6 278.98,50.27 285.08,50.27 285.44,50.63 285.44,53.34 285.4,53.39 285.4,54.66 v1(285.84,55.1)
JTAG_RST#: length 16.5
  TOP w0.102: U51.B57 286.51,54.07 286.5,54.08 286.5,54.67 v1(286.93,55.1) ; R836.1 C735.1 ; C735.1 v1(286.16,47.04) 286.16,46.31 v2(286.47,46.01) ; C735.1 R824.2 JTAG1.1
  IN1 w0.084: v1(286.16,47.04) 285.48,47.72 285.48,48.87 286.98,50.37 286.98,52.66 286.47,53.17 286.47,54.63 v1(286.93,55.1)
JTAG_TDI: length 33.7
  TOP w0.102: v1(285.02,52.19) 285.26,52.43 U51.A51 ; JDEG2.2 260.95,59.71 v2(260.65,60.02) 260.52,60.14 v1(260.52,60.55) 260.53,60.56 R858.2
  IN1 w0.084: v1(285.02,52.19) 284.86,52.19 284.53,51.86 284.53,51 284.01,50.48 279.07,50.48 270.73,58.81 264.79,58.81 262.57,61.04 261.01,61.04 v1(260.52,60.55)
JTAG_TDO: length 35.1
  TOP w0.102: U51.B55 285.51,54.13 v3(285.84,54.46) ; JDEG2.5 262.45,60 v1(262.58,60.13) 263.2,60.75 R861.1
  IN1 w0.084: v1(262.58,60.13) 264.32,58.39 270.55,58.39 278.89,50.05 285.19,50.05 285.65,50.51 285.65,54.27 v3(285.84,54.46)
JTAG_TMS: length 35
  TOP w0.102: R859.2 261.42,60.58 261.41,60.56 v1(261.41,59.99) 261.45,59.95 JDEG2.3 ; U51.A53 286.26,52.14 v3(286.15,52.03)
  IN1 w0.084: v3(286.15,52.03) 286.77,51.41 286.77,50.49 286.12,49.84 278.81,49.84 270.47,58.18 263.22,58.18 v1(261.41,59.99)
JVGA_HS: length 6.4
  TOP w0.102: v3(12.05,76.69) 12.93,75.8 L102.2
  BOTTOM w0.102: v3(12.05,76.69) R1647.2 C1210.1 8.79,76.69 JCRT1.13
JVGA_VS: length 6.6
  TOP w0.102: L103.2 11.88,78.96 v3(12.07,79.14)
  BOTTOM w0.102: v3(12.07,79.14) 11.83,79.38 R1646.2 C1209.1 9.19,79.38 JCRT1.14
KB_DET#: length 70.3
  TOP w0.102: v1(218.2,21.33) 223.13,21.33 224.05,22.25 JTP1.16 ; v1(168.72,20.6) 169.24,21.11 170.38,21.11 v2(170.86,20.63) 171.68,20.63 173.11,19.21 174.83,19.21 175.11,19.49 RH170.1
  IN2 w0.102: 174.55,21.09 174.53,21.12 169.24,21.12 v1(168.72,20.6)
  IN2 w0.122: 174.55,21.09 174.69,21.09 175.71,20.07 177.8,20.07 178.68,19.19 181.47,19.19 183.2,20.91 185.17,20.91 185.31,21.06 186.27,21.06 186.86,20.46 189.64,20.46 190.23,21.06 199.53,21.06 199.67,21.19 201.49,21.19 202.08,20.6 217.47,20.6 v1(218.2,21.33)
  BOTTOM w0.102: UH4.D6 168.95,20.82 v1(168.72,20.6)
LAN_ACTLED_YEL#: length 2.8
  TOP w0.102: U31.26 288.71,85.1 289.12,85.51 289.26,85.51 v2(289.43,85.67) 289.43,86.18 R1089.1
LAN_ACTLED_YEL#_R: length 34.5
  TOP w0.102: v2(291.14,87.6) C1323.1 289.91,87.83 289.15,87.83 R1089.2 289.38,87.14 v1(289.53,87.14)
  IN3 w0.122: v1(289.53,87.14) 291.1,88.72 297.99,88.72 298.42,88.29 316.99,88.29 JLOM1.10
LAN_DISABLE#_R: length 37.4
  TOP w0.102: U31.3 285.51,77.9 285.44,77.83 285.44,77.35 285.35,77.26 R549.2 285.35,76.41 283.44,74.51 v2(283.44,74.5) 283.44,73.53 v1(283.39,73.48) 282.86,72.94 282.86,69.89 R555.2 R557.1 ; v1(262.37,78.58) 261.94,79.01 261.94,79.51 262.09,79.66 U46.B47
  IN4 w0.084: v1(283.39,73.48) 282.23,73.48 279.06,76.65 273.64,76.65 270.14,80.15 263.15,80.15 262.82,79.82 262.82,79.02 v1(262.37,78.58)
LAN_SMBCLK: length 212.6
  TOP w0.102: v3(295.8,70.53) 295.64,70.37 295.64,69.78 RH305.2 295.65,68.86 295.65,67.35 v1(295.84,67.15) ; R551.1 v1(287.98,88.24)
  IN3 w0.122: v3(295.8,70.53) 295.61,70.73 295.61,71.18 294.26,72.53 293.38,72.53 291.88,74.03 290.25,74.03 288.5,75.78 288.5,77.78 289.98,79.26 289.98,83.64 288.52,85.1 288.52,85.65 287.2,86.97 287.2,87.46 v1(287.98,88.24) ; v1(289.32,28.08) 289.12,27.87 288.72,27.87 288.46,28.13 288.46,35.13 289.29,35.96 289.29,42.11 293.7,46.53 293.7,48.97 292.81,49.86 290.33,49.86 289.51,50.67 289.51,55.9 289.27,56.14 289.27,63.23 289.46,63.42 289.46,65.06 290.28,65.87 295.2,65.87 295.65,66.32 295.65,66.96 v1(295.84,67.15)
  IN4 w0.084: v1(289.32,28.08) 289.07,27.82 288.78,27.82 287.91,28.69 282.38,28.69 282.07,28.38 275.32,28.38 273.28,30.42 271.04,30.42 269.07,28.45 269.07,27 266.96,24.89 262.79,24.89 262.04,25.64 233.31,25.64 230.41,22.74 193.92,22.74 191.27,20.09 187.62,20.09 186.91,19.39 185.84,19.39 v1(185.58,19.65) 185.38,19.45 184.78,19.45 183.83,18.5 180.92,18.5 180.61,18.2 177.47,18.2 177.03,18.64 174.74,18.64 173.71,19.67 168.93,19.67 168.31,20.28 168.31,20.92 168.5,21.1 168.84,21.1 v1(169.26,21.52)
  BOTTOM w0.102: v1(169.26,21.52) 169.63,21.9 UH4.C8
