# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
EMC4021-1-EZK-TR_QFN32_5X5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 17(3.5,4.95) 18(3,4.95) 19(2.5,4.95) 20(2,4.95) 21(1.5,4.95) 22(1,4.95) 23(0.5,4.95) 24(0,4.95)
  oval 1.041x0.254 smd: 9(4.225,0.725) 10(4.225,1.225) 11(4.225,1.725) 12(4.225,2.225) 13(4.225,2.725) 14(4.225,3.225) 15(4.225,3.725) 16(4.225,4.225) 25(-0.725,4.225) 26(-0.725,3.725) 27(-0.725,3.225) 28(-0.725,2.725) 29(-0.725,2.225) 30(-0.725,1.725) 31(-0.725,1.225) 32(-0.725,0.725)
  rect 3.302x3.302 smd: 33(1.75,2.475)
FDC654P-G_SSOT-6
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0.95,2.6) 6(0,2.6)
FDS6679AZ_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.16) 6(2.54,5.16) 7(1.27,5.16) 8(0,5.16)
FDV301N_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G547I2P81U_MSOP8
  oval 0.381x1.549 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.37) 6(1.3,4.37) 7(0.65,4.37) 8(0,4.37)
H_2P0
  round 2.515 hole 2.007: 1(0,0)
H_2P3
  round 2.819 hole 2.311: 1(0,0)
H_2P5X2P0
  oval 2.997x2.515 hole 2.489x2.007: 1(0,0)
H_2P8
  round 3.302 hole 2.794: 1(0,0)
H_2P8X2P3
  oval 3.302x2.819 hole 2.794x2.311: 1(0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P8
  round 4.318 hole 3.81: 1(0,0)
H_5P4N
  round 5.41 hole 5.41 unplated: (0,0)
HB_5620821-SICR11_9P
  round 0.889 hole 0.889 unplated: (-1.65,-24.45)
  round 1.194 hole 1.194 unplated: (11.45,-0.05)
  oval 0.787x2.108 smd: 1(0,0) 2(2.54,0) 3(5.08,0) 4(7.62,0) 5(1.27,0) 6(3.81,0) 7(6.35,0) 8(8.89,0) 9(10.16,0)
  rect 1.6x2.591 smd: 10(-4.65,-6.95) 11(15.25,-6.95) 12(-4.65,-19.15) 13(15.25,-19.15)
HB_A080415-SAHR21_4P-T
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 2.159x2.21 smd: 5(-2.825,-3.05) 6(5.825,-3.05)
HB_A081015-SAHR21_10P-T
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0)
  rect 2.159x2.21 smd: 11(-2.825,-3.05) 12(11.825,-3.05)
HB_A531015-SCHR21_10P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.991x2.007 smd: 11(6.6,-3.05) 12(-2.1,-3.05)
HONGL_13-13201904CP_19P
  round 0.762 hole 0.508: 1(0,0) 2(0.5,1.2) 3(1,0) 4(1.5,1.2) 5(2,0) 6(2.5,1.2) 7(3,0) 8(3.5,1.2) 9(4,0) 10(4.5,1.2) 11(5,0) 12(5.5,1.2) 13(6,0) 14(6.5,1.2) 15(7,0) 16(7.5,1.2) 17(8,0) 18(8.5,1.2) 19(9,0)
  oval 1.397x2.946 hole 0.787x2.362: 20(-2.75,0.77) 21(11.75,0.77)
  rect 1.549x2.388 smd: 22(-4.125,-6.08) 23(13.125,-6.08)
IP4292CZ10-TB_XSON10U10
  oval 0.229x0.889 smd: 1(0,0)
  oval 0.229x0.787 smd: 2(0.5,-0.051) 3(1,-0.051) 4(1.5,-0.051) 5(2,-0.051) 6(2,1.149) 7(1.5,1.149) 8(1,1.149) 9(0.5,1.149) 10(0,1.149)
ISL95835HRTZ-T_TQFN40_5X5
  oval 0.203x0.991 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,5.001) 22(3.2,5.001) 23(2.8,5.001) 24(2.4,5.001) 25(2,5.001) 26(1.6,5.001) 27(1.2,5.001) 28(0.8,5.001) 29(0.4,5.001) 30(0,5.001)
  oval 0.991x0.203 smd: 11(4.3,0.7) 12(4.3,1.1) 13(4.3,1.5) 14(4.3,1.9) 15(4.3,2.3) 16(4.3,2.7) 17(4.3,3.1) 18(4.3,3.5) 19(4.3,3.9) 20(4.3,4.3) 31(-0.7,4.3) 32(-0.7,3.9) 33(-0.7,3.5) 34(-0.7,3.1) 35(-0.7,2.7) 36(-0.7,2.3) 37(-0.7,1.9) 38(-0.7,1.5) 39(-0.7,1.1) 40(-0.7,0.7)
  rect 3.607x3.607 smd: 41(1.8,2.5)
IVY-BRIDGE_BGA_1023P
  round 0.381 smd: A4(1.154,-0.101) A5(1.804,-0.101) A57(27.577,-0.101) A58(28.228,-0.101) A59(28.878,-0.101) A61(29.528,-0.101) BC1(0.177,-20.581) BC61(29.528,-20.577) BD1(0.101,-21.227) BD3(0.751,-21.227) BD59(28.878,-21.227) BD61(29.528,-21.227) BE1(0.101,-21.878) BE3(0.751,-21.878) BE4(1.401,-21.878) BE58(28.228,-21.878) BE59(28.878,-21.878) BE61(29.528,-21.878) BG1(0.101,-22.528) BG3(0.751,-22.528) BG4(1.401,-22.528) BG5(2.051,-22.392) BG57(27.577,-22.528) BG58(28.228,-22.528) BG59(28.878,-22.528) BG61(29.528,-22.528) C3(0.504,-0.504) C4(1.194,-0.751) C58(28.228,-0.751) C59(28.878,-0.751) C61(29.528,-0.751) D1(0.101,-1.144) D3(0.751,-1.227) D59(28.878,-1.401) D61(29.528,-1.401) E1(0.101,-1.794) E61(29.528,-2.051)
  round 0.305 smd: A8(3.181,0) A9(4.045,0) A11(5.157,0) A13(6.021,0) A15(7.133,0) A17(7.997,0) A19(9.109,0) A21(9.973,0) A23(11.086,0) A25(12.041,0) A26(12.691,0) A28(13.341,0) A29(13.991,0) A31(14.642,0) A33(15.292,0) A34(15.942,0) A35(16.592,0) A37(17.243,0) A38(17.893,0) A39(18.543,0) A40(19.193,0) A42(19.854,0) A44(20.966,0) A45(21.83,0) A48(22.942,0) A49(23.806,0) A51(24.918,0) A53(25.782,0) A55(26.895,0) AA1(0,-9.748) AA3(0.729,-9.748) AA4(1.374,-9.85) AA6(2.246,-9.912) AA7(2.897,-9.912) AA8(3.547,-9.912) AA10(4.197,-9.912) AA11(4.847,-9.912) AA13(5.498,-9.912) AA14(6.148,-9.912) AA50(24.08,-9.812) AA51(24.73,-9.812) AA52(25.381,-9.812) AA53(26.031,-9.812) AA55(26.681,-9.812) AA56(27.331,-9.812) AB50(24.08,-10.462) AB51(24.73,-10.462) AB52(25.381,-10.462) AB53(26.031,-10.462) AB55(26.681,-10.462) AB56(27.331,-10.462) AB58(28.204,-10.137) AB59(28.9,-10.239) AB61(29.629,-10.066) AC1(0,-10.612) AC3(0.729,-10.612) AC4(1.374,-10.51) AC6(2.566,-10.902) AC8(3.217,-10.902) AC9(3.867,-10.902) AC10(4.517,-10.902) AC12(5.167,-10.902) AC61(29.629,-10.716) AD2(0.381,-11.168) AD4(1.425,-11.168) AD50(24.08,-11.248) AD51(24.73,-11.248) AD52(25.381,-11.248) AD53(26.031,-11.248) AD55(26.681,-11.248) AD56(27.331,-11.248) AD58(28.204,-11.013) AD59(28.9,-11.115) AD61(29.629,-11.367) AE6(2.241,-11.468) AE7(2.892,-11.468) AE8(3.542,-11.468) AE10(4.192,-11.468) AE11(4.842,-11.468) AF1(0,-11.724) AF3(0.729,-11.724) AF4(1.374,-11.826) AF50(24.08,-12.066) AF51(24.73,-12.066) AF52(25.381,-12.066) AF53(26.031,-12.066) AF55(26.681,-12.066) AF56(27.331,-12.066) AF58(28.204,-11.902) AF59(28.9,-12.004) AF61(29.629,-12.017) AG1(0,-12.588) AG3(0.729,-12.588) AG4(1.374,-12.486) AG6(2.272,-12.459) AG7(2.922,-12.459) AG8(3.572,-12.459) AG10(4.222,-12.459) AG11(4.873,-12.459) AG55(26.681,-12.717) AG56(27.331,-12.717) AG58(28.254,-12.664) AG59(28.9,-12.766) AG61(29.629,-12.766) AH2(0.381,-13.144) AH4(1.425,-13.144) AH58(28.204,-13.322) AH60(29.248,-13.322) AJ6(2.272,-13.449) AJ7(2.922,-13.449) AJ8(3.572,-13.449) AJ10(4.222,-13.449) AJ11(4.873,-13.449) AK1(0,-13.7) AK3(0.729,-13.7) AK4(1.374,-13.802) AK55(26.77,-13.707) AK56(27.42,-13.707) AK58(28.254,-13.98) AK59(28.9,-13.879) AK61(29.629,-13.879) AL1(0,-14.564) AL3(0.729,-14.564) AL4(1.374,-14.462) AL6(2.221,-14.44) AL7(2.871,-14.44) AL8(3.521,-14.44) AL10(4.172,-14.44) AL11(4.822,-14.44) AL13(5.472,-14.44) AL14(6.122,-14.44) AL15(6.773,-14.44) AL58(28.254,-14.641) AL59(28.9,-14.742) AL61(29.629,-14.742) AM2(0.381,-15.12) AM4(1.425,-15.12) AM13(5.472,-15.287) AM14(6.122,-15.287) AM15(6.773,-15.287) AM58(28.204,-15.298) AM60(29.248,-15.298) AN1(0,-15.676) AN3(0.729,-15.676) AN4(1.374,-15.778) AN54(26.3,-15.545) AN55(26.95,-15.545) AN57(27.601,-15.545) AN58(28.254,-15.956) AN59(28.9,-15.855) AN61(29.629,-15.855) AP6(2.302,-15.852) AP7(2.952,-15.852) AP8(3.603,-15.852) AP10(4.253,-15.852) AP11(4.903,-15.852) AP50(24.024,-16.11) AP51(24.675,-16.11) AP52(25.325,-16.11) AP53(25.975,-16.11) AP55(26.625,-16.11) AP56(27.276,-16.11) AR1(0,-16.54) AR3(0.729,-16.54) AR4(1.374,-16.438) AR6(2.292,-16.843) AR7(2.942,-16.843) AR8(3.593,-16.843) AR10(4.243,-16.843) AR11(4.893,-16.741) AR13(5.776,-16.696) AR14(6.342,-16.371) AR17(8.18,-16.447) AR19(9.17,-16.447) AR21(10.161,-16.43) AR22(10.726,-16.755) AR26(12.564,-16.498) AR28(13.554,-16.396) AR30(14.545,-16.704) AR32(15.111,-16.378) AR34(16.101,-16.427) AR36(17.092,-16.427) AR40(18.929,-16.371) AR41(19.495,-16.696) AR43(20.486,-16.62) AR45(21.476,-16.696) AR48(23.314,-16.696) AR58(28.254,-16.617) AR59(28.9,-16.718) AR61(29.629,-16.718) AT2(0.381,-17.096) AT4(1.425,-17.096) AT13(5.776,-17.346) AT14(6.342,-17.021) AT17(8.18,-17.097) AT19(9.17,-17.097) AT21(10.161,-17.08) AT22(10.726,-17.405) AT26(12.564,-17.148) AT28(13.554,-17.046) AT30(14.545,-17.354) AT32(15.111,-17.029) AT34(16.101,-17.077) AT36(17.092,-17.077) AT40(18.929,-17.021) AT41(19.495,-17.346) AT43(20.486,-17.27) AT45(21.476,-17.346) AT48(23.314,-17.346) AT49(23.879,-17.021) AT52(25.381,-17.101) AT54(26.031,-17.101) AT55(26.681,-17.101) AT56(27.331,-17.101) AT58(28.204,-17.275) AT60(29.248,-17.275) AU1(0,-17.652) AU3(0.729,-17.652) AU4(1.374,-17.754) AU6(2.241,-17.834) AU7(2.892,-17.834) AU11(4.633,-17.747) AU13(5.776,-17.996) AU14(6.342,-17.671) AU17(8.18,-17.747) AU19(9.17,-17.747) AU21(10.161,-17.73) AU22(10.726,-18.055) AU26(12.564,-17.798) AU28(13.554,-17.697) AU30(14.545,-18.004) AU32(15.111,-17.679) AU34(16.101,-17.727) AU36(17.092,-17.727) AU40(18.929,-17.671) AU49(23.879,-17.671) AU51(24.87,-17.747) AU58(28.254,-17.932) AU59(28.9,-17.831) AU61(29.629,-17.831) AV1(0,-18.516) AV3(0.729,-18.516) AV4(1.374,-18.414) AV9(3.617,-18.388) AV11(4.633,-18.398) AV14(6.342,-18.322) AV17(8.18,-18.398) AV19(9.17,-18.398) AV21(10.161,-18.38) AV22(10.726,-18.706) AV28(13.554,-18.347) AV30(14.545,-18.654) AV32(15.111,-18.329) AV34(16.101,-18.377) AV36(17.092,-18.377) AV40(18.929,-18.322) AV41(19.495,-17.996) AV43(20.486,-17.92) AV45(21.476,-17.996) AV48(23.314,-17.996) AV49(23.879,-18.322) AV51(24.87,-18.398) AV54(26.031,-18.091) AV55(26.681,-18.091) AV56(27.331,-18.091) AW7(2.627,-18.728) AW13(5.776,-18.647) AW26(12.564,-18.449) AW41(19.495,-18.647) AW43(20.486,-18.57) AW45(21.476,-18.647) AW48(23.314,-18.647) AW58(28.254,-18.593) AW59(28.9,-18.694) AW61(29.629,-18.694) AY2(0.381,-19.072) AY4(1.425,-19.072) AY9(3.617,-19.038) AY11(4.633,-19.048) AY13(5.776,-19.297) AY14(6.342,-18.972) AY17(8.18,-19.048) AY19(9.17,-19.048) AY21(10.161,-19.031) AY22(10.726,-19.356) AY26(12.564,-19.099) AY28(13.554,-18.997) AY30(14.545,-19.305) AY32(15.111,-18.979) AY34(16.101,-19.028) AY36(17.092,-19.028) AY40(18.929,-18.972) AY41(19.495,-19.297) AY43(20.486,-19.221) AY45(21.476,-19.297) AY48(23.314,-19.297) AY49(23.879,-18.972) AY51(24.87,-19.048) AY53(25.861,-19.048) AY55(26.851,-19.048) AY58(28.204,-19.251) AY60(29.248,-19.251) B6(2.625,-0.381) B10(4.601,-0.381) B14(6.577,-0.381) B18(8.553,-0.381) B22(10.529,-0.381) B43(20.41,-0.381) B46(22.386,-0.381) B50(24.362,-0.381) B54(26.338,-0.381) BA1(0,-19.629) BA3(0.729,-19.629) BA4(1.364,-19.883) BA7(2.627,-19.378) BA9(3.617,-19.688) BA11(4.633,-19.698) BA13(5.776,-19.947) BA14(6.342,-19.622) BA17(8.18,-19.698) BA19(9.17,-19.698) BA21(10.161,-19.681) BA22(10.726,-20.006) BA26(12.564,-19.749) BA28(13.554,-19.647) BA30(14.545,-19.955) BA32(15.111,-19.63) BA34(16.101,-19.678) BA36(17.092,-19.678) BA40(18.929,-19.622) BA41(19.495,-19.947) BA43(20.486,-19.871) BA45(21.476,-19.947) BA48(23.314,-19.947) BA49(23.879,-19.622) BA51(24.87,-19.698) BA53(25.861,-19.698) BA55(26.851,-19.698) BA58(28.254,-19.909) BA59(28.9,-19.807) BA61(29.629,-19.807) BB3(0.778,-20.314) BB7(2.627,-20.028) BB9(3.617,-20.338) BB11(4.633,-20.348) BB14(6.342,-20.272) BB17(8.18,-20.348) BB19(9.17,-20.348) BB21(10.161,-20.331) BB26(12.564,-20.399) BB28(13.554,-20.298) BB32(15.111,-20.28) BB34(16.101,-20.328) BB36(17.092,-20.328) BB40(18.929,-20.272) BB49(23.879,-20.272) BB51(24.87,-20.348) BB53(25.861,-20.348) BB55(26.851,-20.348) BC4(1.301,-20.881) BC5(1.962,-20.674) BC7(2.627,-20.679) BC13(5.776,-20.597) BC22(10.726,-20.656) BC30(14.545,-20.605) BC41(19.495,-20.597) BC43(20.486,-20.521) BC45(21.476,-20.597) BC48(23.314,-20.597) BC57(27.829,-20.873) BC59(28.845,-20.578) BD8(3.214,-21.203) BD9(3.872,-21.254) BD10(4.532,-21.254) BD12(5.19,-21.203) BD13(5.848,-21.254) BD14(6.508,-21.254) BD16(7.166,-21.203) BD17(7.824,-21.254) BD18(8.485,-21.254) BD19(9.142,-21.203) BD21(9.8,-21.254) BD22(10.461,-21.254) BD23(11.119,-21.203) BD25(11.776,-21.254) BD26(12.437,-21.254) BD27(13.095,-21.203) BD29(13.753,-21.254) BD30(14.413,-21.254) BD32(15.071,-21.203) BD33(15.729,-21.254) BD35(16.389,-21.254) BD36(17.047,-21.203) BD37(17.705,-21.254) BD39(18.365,-21.254) BD40(19.023,-21.203) BD42(19.681,-21.254) BD43(20.341,-21.254) BD44(20.999,-21.203) BD45(21.657,-21.254) BD46(22.317,-21.254) BD48(22.975,-21.203) BD49(23.633,-21.254) BD50(24.294,-21.254) BD52(24.951,-21.203) BD53(25.604,-21.203) BD54(26.255,-21.208) BD56(27.004,-21.138) BE5(2.048,-21.661) BE7(2.658,-21.899) BE9(3.77,-21.899) BE11(4.634,-21.899) BE13(5.746,-21.899) BE14(6.61,-21.899) BE17(7.723,-21.899) BE18(8.586,-21.899) BE21(9.699,-21.899) BE22(10.562,-21.899) BE24(11.675,-21.899) BE26(12.538,-21.899) BE28(13.651,-21.899) BE30(14.515,-21.899) BE33(15.627,-21.899) BE35(16.491,-21.899) BE37(17.603,-21.899) BE39(18.467,-21.899) BE41(19.579,-21.899) BE43(20.443,-21.899) BE45(21.555,-21.899) BE47(22.419,-21.899) BE49(23.532,-21.899) BE51(24.395,-21.899) BE53(25.458,-21.839) BE54(26.321,-21.855) BE57(27.474,-21.773) BF8(3.214,-22.247) BF12(5.19,-22.247) BF16(7.166,-22.247) BF19(9.142,-22.247) BF23(11.119,-22.247) BF27(13.095,-22.247) BF32(15.071,-22.247) BF36(17.047,-22.247) BF40(19.023,-22.247) BF44(20.999,-22.247) BF48(22.975,-22.247) BF52(24.951,-22.247) BF56(26.879,-22.19) BG7(2.658,-22.628) BG9(3.77,-22.628) BG11(4.634,-22.628) BG13(5.746,-22.628) BG14(6.61,-22.628) BG17(7.723,-22.628) BG18(8.586,-22.628) BG21(9.699,-22.628) BG22(10.562,-22.628) BG24(11.675,-22.628) BG26(12.538,-22.628) BG28(13.651,-22.628) BG30(14.515,-22.628) BG33(15.627,-22.628) BG35(16.491,-22.628) BG37(17.603,-22.628) BG39(18.467,-22.628) BG41(19.579,-22.628) BG43(20.443,-22.628) BG45(21.555,-22.628) BG47(22.419,-22.628) BG49(23.532,-22.628) BG51(24.395,-22.628) BG53(25.508,-22.628) BG54(26.371,-22.628) C5(2.056,-0.706) C8(3.181,-0.729) C9(4.045,-0.729) C11(5.157,-0.729) C13(6.021,-0.729) C15(7.133,-0.729) C17(7.997,-0.729) C19(9.109,-0.729) C21(9.973,-0.729) C23(11.086,-0.729) C26(12.302,-0.65) C27(13.143,-0.65) C29(14.017,-0.65) C32(14.89,-0.65) C34(15.731,-0.65) C35(16.605,-0.65) C37(17.479,-0.65) C39(18.319,-0.65) C40(19.193,-0.65) C42(19.854,-0.729) C44(20.966,-0.729) C45(21.83,-0.729) C48(22.942,-0.729) C49(23.806,-0.729) C51(24.918,-0.729) C53(25.782,-0.729) C55(26.895,-0.729) C57(27.678,-1.213) D4(1.51,-1.323) D6(2.625,-1.425) D8(3.283,-1.374) D9(3.943,-1.374) D10(4.601,-1.425) D12(5.259,-1.374) D13(5.919,-1.374) D14(6.577,-1.425) D16(7.235,-1.374) D17(7.895,-1.374) D18(8.553,-1.425) D19(9.211,-1.374) D21(9.871,-1.374) D22(10.529,-1.425) D23(11.187,-1.374) D24(11.726,-0.995) D26(12.302,-1.3) D27(13.092,-1.3) D29(13.966,-1.3) D32(14.84,-1.3) D34(15.68,-1.3) D35(16.554,-1.3) D37(17.428,-1.3) D39(18.269,-1.3) D40(19.117,-1.326) D42(19.747,-1.501) D43(20.41,-1.425) D44(21.068,-1.374) D45(21.728,-1.374) D46(22.386,-1.425) D48(23.044,-1.374) D49(23.704,-1.374) D50(24.362,-1.425) D52(25.02,-1.374) D53(25.68,-1.374) D54(26.338,-1.425) D58(28.236,-1.569) E3(0.702,-2.042) E5(1.611,-1.984) E14(6.112,-2.031) E21(9.981,-2.031) E25(11.771,-1.679) E26(12.716,-1.962) E28(13.504,-1.962) E29(14.322,-1.962) E32(14.972,-1.962) E34(15.759,-1.962) E35(16.409,-1.962) E37(17.227,-1.962) E38(18.015,-1.962) E40(18.833,-1.962) E55(26.824,-1.884) E59(28.878,-2.051) F6(2.574,-2.28) F8(3.565,-2.28) F10(4.555,-2.28) F13(5.546,-2.356) F14(6.112,-2.681) F15(7.022,-2.695) F17(7.949,-2.147) F19(8.94,-2.275) F21(9.981,-2.681) F22(10.636,-2.128) F25(11.644,-2.612) F26(12.716,-2.612) F28(13.504,-2.612) F29(14.322,-2.612) F32(14.972,-2.612) F34(15.759,-2.612) F35(16.409,-2.612) F37(17.227,-2.612) F38(18.015,-2.612) F40(18.833,-2.612) F42(19.808,-2.216) F43(20.458,-2.216) F45(21.449,-2.216) F48(23.286,-2.211) F49(23.852,-2.536) F51(24.843,-2.204) F53(25.833,-2.28) F55(26.824,-2.534) G1(0,-2.707) G3(0.729,-2.707) G4(1.374,-2.606) G6(2.574,-2.93) G8(3.565,-2.93) G10(4.555,-2.93) G13(5.546,-3.006) G17(7.949,-2.798) G19(8.94,-2.925) G22(10.636,-2.778) G42(19.808,-2.867) G43(20.458,-2.867) G45(21.449,-2.867) G48(23.286,-2.861) G51(24.843,-2.854) G53(25.833,-2.93) G55(26.824,-3.184) G58(28.055,-2.695) G59(28.8,-2.797) G61(29.629,-2.822) H2(0.381,-3.263) H4(1.425,-3.263) H6(2.574,-3.58) H8(3.565,-3.58) H10(4.555,-3.58) H13(5.546,-3.657) H14(6.112,-3.331) H17(7.949,-3.448) H19(8.94,-3.575) H21(9.981,-3.331) H22(10.636,-3.428) H25(11.644,-3.262) H26(12.716,-3.262) H28(13.504,-3.262) H29(14.322,-3.262) H32(14.972,-3.262) H34(15.759,-3.262) H35(16.409,-3.262) H37(17.227,-3.262) H38(18.015,-3.262) H40(18.833,-3.262) H43(20.458,-3.517) H45(21.449,-3.517) H48(23.286,-3.511) H49(23.852,-3.186) H51(24.843,-3.504) H53(25.833,-3.58) H58(28.004,-3.353) H60(29.128,-3.359) J1(0,-3.82) J3(0.729,-3.82) J4(1.374,-3.921) J14(6.112,-3.982) J21(9.981,-3.982) J25(11.644,-3.913) J26(12.716,-3.913) J28(13.504,-3.913) J29(14.322,-3.913) J32(14.972,-3.913) J34(15.759,-3.913) J35(16.409,-3.913) J37(17.227,-3.913) J38(18.015,-3.913) J40(18.833,-3.913) J42(19.808,-3.517) J49(23.852,-3.836) J55(26.824,-3.834) J58(28.114,-4.011) J59(28.761,-3.909) J61(29.629,-3.909) K1(0,-4.683) K3(0.729,-4.683) K4(1.374,-4.582) K6(2.297,-4.537) K7(2.947,-4.537) K8(3.598,-4.537) K10(4.248,-4.537) K11(4.898,-4.537) K13(5.546,-4.307) K15(6.895,-4.117) K17(7.949,-4.098) K19(8.94,-4.226) K22(10.636,-4.078) K42(19.808,-4.167) K43(20.458,-4.167) K45(21.449,-4.167) K48(23.286,-4.162) K49(23.852,-4.487) K51(24.843,-4.154) K53(25.833,-4.231) K58(28.254,-4.671) L51(24.843,-4.805) L53(25.833,-4.881) L55(26.737,-4.795) L56(27.387,-4.795) L59(28.9,-4.773) L61(29.629,-4.773) M2(0.381,-5.24) M4(1.425,-5.24) M6(2.246,-5.528) M7(2.897,-5.528) M8(3.547,-5.528) M10(4.197,-5.528) M11(4.847,-5.528) M58(28.204,-5.326) M60(29.248,-5.329) N1(0,-5.796) N3(0.729,-5.796) N4(1.374,-5.897) N50(24.08,-5.921) N51(24.73,-5.921) N52(25.381,-5.921) N53(26.031,-5.921) N55(26.681,-5.921) N56(27.331,-5.921) N58(27.983,-5.939) N59(28.712,-5.946) N61(29.629,-6.165) P1(0,-6.659) P3(0.729,-6.659) P4(1.374,-6.558) P6(2.302,-6.518) P7(2.952,-6.518) P9(3.603,-6.518) P10(4.253,-6.518) P11(4.903,-6.518) P50(24.08,-6.739) P51(24.73,-6.739) P52(25.381,-6.739) P53(26.031,-6.739) P55(26.681,-6.739) P56(27.331,-6.739) P58(28.204,-6.553) P59(28.9,-6.649) P61(29.629,-6.815) R2(0.381,-7.216) R4(1.425,-7.227) T1(0,-7.772) T3(0.729,-7.772) T4(1.372,-7.879) T50(24.08,-7.557) T51(24.73,-7.557) T52(25.381,-7.557) T53(26.031,-7.557) T55(26.681,-7.557) T56(27.331,-7.557) T58(28.204,-7.453) T59(28.9,-7.555) T61(29.629,-7.465) U6(2.257,-8.045) U7(2.907,-8.045) U8(3.557,-8.045) U10(4.207,-8.045) U11(4.857,-8.045) U13(5.508,-8.045) U14(6.158,-8.045) U15(6.808,-8.045) V4(1.374,-8.534) V50(24.08,-8.207) V51(24.73,-8.207) V52(25.381,-8.207) V53(26.031,-8.207) V55(26.681,-8.207) V56(27.331,-8.207) V58(28.204,-8.33) V59(28.9,-8.431) V61(29.629,-8.115) W1(0,-8.635) W3(0.729,-8.635) W6(2.246,-8.921) W7(2.897,-8.921) W8(3.547,-8.921) W10(4.197,-8.921) W11(4.847,-8.921) W13(5.498,-8.921) W14(6.148,-8.921) W15(6.798,-8.921) W50(24.08,-8.994) W51(24.73,-8.994) W52(25.381,-8.994) W53(26.031,-8.994) W55(26.681,-8.994) W56(27.331,-8.994) W61(29.629,-8.766) Y2(0.381,-9.192) Y4(1.425,-9.192) Y58(28.204,-9.231) Y59(28.9,-9.333) Y61(29.629,-9.416)
  round 0.356 smd: AA15(6.798,-9.912) AA46(22.262,-9.756) AB16(7.428,-10.201) AB17(8.114,-10.201) AB18(8.8,-10.201) AB20(9.485,-10.201) AB21(10.171,-10.201) AB47(22.739,-10.201) AB48(23.425,-10.201) AC13(5.818,-10.902) AC14(6.468,-10.902) AC46(22.262,-10.645) AD16(7.428,-11.09) AD17(8.114,-11.09) AD18(8.8,-11.09) AD20(9.485,-11.09) AD21(10.171,-11.09) AD47(22.739,-11.09) AD48(23.425,-11.09) AE13(5.492,-11.468) AE14(6.143,-11.468) AE15(6.793,-11.468) AE46(22.262,-11.534) AF16(7.428,-11.979) AF17(8.114,-11.979) AF18(8.8,-11.979) AF20(9.485,-11.979) AF21(10.171,-11.979) AF46(22.262,-12.423) AF47(22.739,-11.979) AF48(23.425,-11.979) AG13(5.523,-12.459) AG14(6.173,-12.459) AG15(6.823,-12.459) AG16(7.428,-12.868) AG17(8.114,-12.868) AG18(8.8,-12.868) AG20(9.485,-12.868) AG21(10.171,-12.868) AG47(22.739,-12.868) AG48(23.425,-12.868) AG50(24.08,-12.717) AG51(24.73,-12.717) AG52(25.381,-12.717) AG53(26.031,-12.717) AJ13(5.523,-13.449) AJ14(6.173,-13.449) AJ15(6.823,-13.373) AJ16(7.423,-13.655) AJ17(8.312,-13.655) AJ20(9.201,-13.655) AJ21(10.09,-13.655) AJ22(10.979,-13.655) AJ25(11.868,-13.655) AJ26(12.757,-13.655) AJ28(13.646,-13.655) AJ30(14.535,-13.655) AJ33(15.424,-13.655) AJ34(16.313,-13.655) AJ36(17.202,-13.655) AJ38(18.091,-13.655) AJ40(18.98,-13.655) AJ42(19.869,-13.655) AJ43(20.758,-13.655) AJ45(21.647,-13.655) AJ47(22.536,-13.655) AJ48(23.425,-13.655) AK50(24.169,-13.707) AK51(24.819,-13.707) AK52(25.47,-13.707) AK54(26.12,-13.707) AL16(7.423,-14.341) AL17(8.312,-14.341) AL20(9.201,-14.341) AL21(10.09,-14.341) AL22(10.979,-14.341) AL25(11.868,-14.341) AL26(12.757,-14.341) AL28(13.646,-14.341) AL30(14.535,-14.341) AL33(15.424,-14.341) AL34(16.313,-14.341) AL36(17.202,-14.341) AL38(18.091,-14.341) AL40(18.98,-14.341) AL42(19.869,-14.341) AL43(20.758,-14.341) AL45(21.647,-14.341) AL47(22.536,-14.341) AL48(23.425,-14.341) AM16(7.423,-15.027) AM17(8.312,-15.027) AM20(9.201,-15.027) AM21(10.09,-15.027) AM22(10.979,-15.027) AM25(11.868,-15.027) AM26(12.757,-15.027) AM28(13.646,-15.027) AM30(14.535,-15.027) AM33(15.424,-15.027) AM34(16.313,-15.027) AM36(17.202,-15.027) AM38(18.091,-15.027) AM40(18.98,-15.027) AM42(19.869,-15.027) AM43(20.758,-15.027) AM45(21.647,-15.027) AM47(22.536,-15.027) AM48(23.425,-15.027) AN16(7.423,-15.712) AN17(8.312,-15.712) AN20(9.201,-15.712) AN21(10.09,-15.712) AN22(10.979,-15.712) AN25(11.868,-15.712) AN26(12.757,-15.712) AN28(13.646,-15.712) AN30(14.535,-15.712) AN33(15.424,-15.712) AN34(16.313,-15.712) AN36(17.202,-15.712) AN38(18.091,-15.712) AN40(18.98,-15.712) AN42(19.869,-15.712) AN43(20.758,-15.712) AN45(21.647,-15.712) AN47(22.536,-15.712) AN48(23.425,-15.712) AN50(24.349,-15.545) AN52(25,-15.545) AN53(25.65,-15.545) K21(9.638,-4.545) K24(11.442,-4.548) K26(12.319,-4.563) K27(13.195,-4.563) K29(14.097,-4.563) K32(14.973,-4.563) K34(15.862,-4.563) K35(16.751,-4.537) K37(17.627,-4.537) K39(18.504,-4.537) L16(7.423,-5.044) L17(8.312,-5.044) L20(9.201,-5.044) L21(10.09,-5.044) L22(10.979,-5.044) L25(11.868,-5.044) L26(12.757,-5.044) L28(13.646,-5.044) L30(14.535,-5.044) L33(15.424,-5.044) L34(16.313,-5.044) L36(17.202,-5.044) L38(18.091,-5.044) L40(18.98,-5.044) L42(19.869,-5.044) L43(20.758,-5.044) L45(21.647,-5.044) L47(22.536,-5.044) L48(23.425,-5.044) M13(5.498,-5.528) M14(6.148,-5.528) M15(6.793,-5.311) N16(7.423,-5.73) N17(8.312,-5.73) N20(9.201,-5.73) N21(10.09,-5.73) N22(10.979,-5.73) N25(11.868,-5.73) N26(12.757,-5.73) N28(13.646,-5.73) N30(14.535,-5.73) N33(15.424,-5.73) N34(16.313,-5.73) N36(17.202,-5.73) N38(18.091,-5.73) N40(18.98,-5.73) N42(19.869,-5.73) N43(20.758,-5.73) N45(21.647,-5.73) N47(22.536,-5.73) N48(23.425,-5.73) P13(5.553,-6.518) P14(6.204,-6.518) P16(7.428,-6.645) P17(8.114,-6.645) P18(8.8,-6.645) P20(9.485,-6.645) P21(10.171,-6.645) P47(22.739,-6.645) P48(23.425,-6.645) R16(7.428,-7.534) R17(8.114,-7.534) R18(8.8,-7.534) R20(9.485,-7.534) R21(10.171,-7.534) R46(22.262,-7.089) T47(22.739,-7.534) T48(23.425,-7.534) U46(22.262,-7.978) V16(7.428,-8.423) V17(8.114,-8.423) V18(8.8,-8.423) V20(9.485,-8.423) V21(10.171,-8.423) V47(22.739,-8.423) V48(23.425,-8.423) W16(7.428,-9.312) W17(8.114,-9.312) W18(8.8,-9.312) W20(9.485,-9.312) W21(10.171,-9.312) W46(22.262,-8.867) Y47(22.739,-9.312) Y48(23.425,-9.312)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
L2N7002WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
LCN_DAN08-52406-0500_52P
  round 1.6 hole 1.6 unplated: (-0.7,4.1)
  round 1.092 hole 1.092 unplated: (24.3,4.1)
  oval 0.61x2.007 smd: 1(0,0) 2(0.4,8.2) 3(0.8,0) 4(1.2,8.2) 5(1.6,0) 6(2,8.2) 7(2.4,0) 8(2.8,8.2) 9(3.2,0) 10(3.6,8.2) 11(4,0) 12(4.4,8.2) 13(4.8,0) 14(5.2,8.2) 15(5.6,0) 16(6,8.2) 17(9.6,0) 18(10,8.2) 19(10.4,0) 20(10.8,8.2) 21(11.2,0) 22(11.6,8.2) 23(12,0) 24(12.4,8.2) 25(12.8,0) 26(13.2,8.2) 27(13.6,0) 28(14,8.2) 29(14.4,0) 30(14.8,8.2) 31(15.2,0) 32(15.6,8.2) 33(16,0) 34(16.4,8.2) 35(16.8,0) 36(17.2,8.2) 37(17.6,0) 38(18,8.2) 39(18.4,0) 40(18.8,8.2) 41(19.2,0) 42(19.6,8.2) 43(20,0) 44(20.4,8.2) 45(20.8,0) 46(21.2,8.2) 47(21.6,0) 48(22,8.2) 49(22.4,0) 50(22.8,8.2) 51(23.2,0) 52(23.6,8.2)
  rect 2.311x3.2 smd: 53(-2.85,0.6) 54(26.45,0.6)
LL34
  oval 1.397x1.905 smd: 1(0,0) 2(2.978,0)
LM393DR_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
MDU1516URH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MEC5055-LZY_DQFN132_11X11
  oval 0.279x0.737 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.737x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.318x0.61 smd: B1(-0.25,0.855) B2(0.25,0.855) B3(0.75,0.855) B4(1.25,0.855) B5(1.75,0.855) B6(2.25,0.855) B7(2.75,0.855) B8(3.25,0.855) B9(3.75,0.855) B10(4.25,0.855) B11(4.75,0.855) B12(5.25,0.855) B13(5.75,0.855) B14(6.25,0.855) B15(6.75,0.855) B16(7.25,0.855) B17(7.75,0.855) B35(7.75,10.045) B36(7.25,10.045) B37(6.75,10.045) B38(6.25,10.045) B39(5.75,10.045) B40(5.25,10.045) B41(4.75,10.045) B42(4.25,10.045) B43(3.75,10.045) B44(3.25,10.045) B45(2.75,10.045) B46(2.25,10.045) B47(1.75,10.045) B48(1.25,10.045) B49(0.75,10.045) B50(0.25,10.045) B51(-0.25,10.045)
  oval 0.61x0.318 smd: B18(8.345,1.45) B19(8.345,1.95) B20(8.345,2.45) B21(8.345,2.95) B22(8.345,3.45) B23(8.345,3.95) B24(8.345,4.45) B25(8.345,4.95) B26(8.345,5.45) B27(8.345,5.95) B28(8.345,6.45) B29(8.345,6.95) B30(8.345,7.45) B31(8.345,7.95) B32(8.345,8.45) B33(8.345,8.95) B34(8.345,9.45) B52(-0.845,9.45) B53(-0.845,8.95) B54(-0.845,8.45) B55(-0.845,7.95) B56(-0.845,7.45) B57(-0.845,6.95) B58(-0.845,6.45) B59(-0.845,5.95) B60(-0.845,5.45) B61(-0.845,4.95) B62(-0.845,4.45) B63(-0.845,3.95) B64(-0.845,3.45) B65(-0.845,2.95) B66(-0.845,2.45) B67(-0.845,1.95) B68(-0.845,1.45)
  rect 5.105x5.105 smd: C1(3.75,5.45)
MMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MOLEX_52435-2671_26P-T
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0)
  custom 0.597x0.597 smd: 27(-2.45,-1.925) 28(14.95,-1.925)
MURAT_BLM15AG121SN1D_2P
  oval 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15AG601SN1D_2P
  oval 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BB221SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM18BD102SN1D_L0603_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18BD601SN1D_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
MURAT_BLM18PG121SN1D_2P
  rect 0.66x0.711 smd: 1(0,0) 2(1.35,0)
MURAT_BLM18PG471SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM21PG600SN1D_L0805_2P
  rect 0.991x1.753 smd: 1(0,0) 2(1.5,0)
MURAT_DLW21SN121SQ2L_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,0.8) 4(0,0.8)
MURAT_DLW21SN900HQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN900HQ2L_0805_4P-S
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN900SQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN900SQ2L_0805_4P-S
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
NTR4503NT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
OZ600FJ0LN_QFN32_5X5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 17(3.5,4.95) 18(3,4.95) 19(2.5,4.95) 20(2,4.95) 21(1.5,4.95) 22(1,4.95) 23(0.5,4.95) 24(0,4.95)
  oval 1.041x0.254 smd: 9(4.225,0.725) 10(4.225,1.225) 11(4.225,1.725) 12(4.225,2.225) 13(4.225,2.725) 14(4.225,3.225) 15(4.225,3.725) 16(4.225,4.225) 25(-0.725,4.225) 26(-0.725,3.725) 27(-0.725,3.225) 28(-0.725,2.725) 29(-0.725,2.225) 30(-0.725,1.725) 31(-0.725,1.225) 32(-0.725,0.725)
  rect 3.2x3.2 smd: 33(1.75,2.475)
PDTA114EU_SC70-3
  rect 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
PDTC124EU_SC70-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PMST3904_SOT323-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PMV65XP_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PS8513BTQFN20GTR-A0_TQFN20_4X4
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.8) 12(1.5,3.8) 13(1,3.8) 14(0.5,3.8) 15(0,3.8)
  oval 1.194x0.254 smd: 6(2.9,0.9) 7(2.9,1.4) 8(2.9,1.9) 9(2.9,2.4) 10(2.9,2.9) 16(-0.9,2.9) 17(-0.9,2.4) 18(-0.9,1.9) 19(-0.9,1.4) 20(-0.9,0.9)
  rect 2.108x2.108 smd: 21(1,1.9)
R0402_0OHM-NEW
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM-NEW
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM-NEW
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0402NEW
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0402NEW-S
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603NEW
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805NEW
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
R_1206NEW
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
RB751S40T1_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RB751V40_SC76-2
  rect 0.61x0.61 smd: 1(0,0) 2(2.2,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RT8205EGQW_WQFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.515x2.515 smd: 25(1.25,1.975)
RT8207MZQW_WQFN20_3X3
  oval 0.203x0.991 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.001) 12(1.2,3.001) 13(0.8,3.001) 14(0.4,3.001) 15(0,3.001)
  oval 0.991x0.203 smd: 6(2.3,0.7) 7(2.3,1.1) 8(2.3,1.5) 9(2.3,1.9) 10(2.3,2.3) 16(-0.7,2.3) 17(-0.7,1.9) 18(-0.7,1.5) 19(-0.7,1.1) 20(-0.7,0.7)
  rect 1.702x1.702 smd: 21(0.8,1.5)
RT9818A-44GU3_SC70-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
SANTA_130456-241_13P-T
  round 1.295 hole 0.889: 1(0,0) 2(1.02,1.1) 3(2.04,0) 4(3.06,1.1) 5(4.08,0) 6(5.1,1.1) 7(6.12,0) 8(7.14,1.1)
  round 1.295 hole 0.991: 9(-3.705,1.65) 10(-3.705,-1.35) 11(10.845,1.65) 12(10.845,0.15) 13(10.845,-1.35)
  rect 1.956x2.896 hole 0.61x1.905: 14(13.07,-8.7) 15(-5.93,-8.7)
SANTA_373070-1_9P-T
  round 1.016 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(3.25,-0.47) 11(-10.25,-0.47)
  oval 1.397x2.388 hole 0.787x1.803: 12(4.35,-9.47) 13(-11.35,-9.47)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI3456DDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI4164DY-T1-GE3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI7121DN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SI7170DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SI7326DN-T1-E3_PAK1212-8
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SI7716ADN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SINGA_2SJ3053-100111F_6P-T
  oval 1.194x2.108 hole 0.61x1.499: 1(0,0) 2(-11.8,0) 3(0,9.9) 4(0,5.95) 5(-11.8,2.5) 6(-11.8,9.65) 7(-11.8,5.62)
SLG55584AVTR_TDFN8_2X2
  oval 0.254x0.914 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.075) 6(1,2.075) 7(0.5,2.075) 8(0,2.075)
  rect 1.6x0.889 smd: 9(0.75,1.038)
SN74LVC1G07DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SRV05-4PTCT_SOT23-6
  oval 0.61x1.092 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.5) 5(0.95,2.5) 6(0,2.5)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SSX44-B-D-T1_TSSOP28
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(6.5,0) 12(7.15,0) 13(7.8,0) 14(8.45,0) 15(8.45,7.5) 16(7.8,7.5) 17(7.15,7.5) 18(6.5,7.5) 19(5.85,7.5) 20(5.2,7.5) 21(4.55,7.5) 22(3.9,7.5) 23(3.25,7.5) 24(2.6,7.5) 25(1.95,7.5) 26(1.3,7.5) 27(0.65,7.5) 28(0,7.5)
STARC_107K40-000001-G2_40P
  round 1.092 hole 1.092 unplated: (-2.3,-1.95) (21.8,-1.95)
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.549x3.404 smd: 41(-4.125,-5.85) 42(23.625,-5.85)
  rect 2.007x6.198 smd: 43(0.5,-7.65) 44(6,-7.65) 45(13.5,-7.65) 46(19,-7.65)
SUYIN_200277MR009F515ZR_7P
  round 1.397 hole 0.991: 1(0,0) 2(4,0) 3(6,0) 4(8,0) 5(10,0) 6(12,0) 7(16,0)
  oval 1.549x3.556 hole 0.787x2.794: 8(-3.125,0) 9(19.125,0)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SY8033BDBC_DFN10_3X3
  oval 0.305x0.559 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.7) 7(1.5,2.7) 8(1,2.7) 9(0.5,2.7) 10(0,2.7)
  rect 2.591x1.753 smd: 11(1,1.35)
T-SOL_156-4000000606_15P-T
  round 1.499 hole 1.499 unplated: (-23.05,-2.875) (-3.05,-2.875)
  oval 0.889x1.549 smd: 1(0,0) 2(-1.3,0)
  oval 0.787x2.362 smd: 3(-2.6,-0.4) 4(-4.3,-0.4) 5(-5.47,-0.4) 6(-6.72,-0.4) 7(-7.97,-0.4) 8(-9.22,-0.4) 9(-11.73,-0.4) 10(-14.23,-0.4) 11(-15.48,-0.4) 12(-16.73,-0.4) 13(-17.98,-0.4) 14(-19.23,-0.4) 15(-21.73,-0.4)
  oval 0.991x2.692 hole 0.61x1.397: 16(1.25,-26.025) 17(-27.35,-26.025)
TAI-T_HCB2012KF-121T50_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
TAI-T_VMPI0703AR-1R0M-Z01_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
TAIMA_IH-115-F_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
TAIWI_EU147-167CRL-TWD_16P
  round 1.295 hole 0.889: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 12(-8,2.03) 13(-5.75,2.03) 14(-3.5,2.03) 15(-1.25,2.03) 16(1,2.03)
  round 1.067 hole 0.762: 5(-7.31,-1.6) 6(-6.04,-1.6) 7(-4.77,-1.6) 8(-3.5,-1.6) 9(-2.23,-1.6) 10(-0.96,-1.6) 11(0.31,-1.6)
  oval 1.372x3.251 hole 0.61x2.489: 17(-12.7,-0.7) 18(5.7,-0.7)
  rect 2.007x3.505 smd: 19(7.35,-9.45) 20(-14.35,-9.45)
TAIYO_CBC2012T4R7M_2P
  rect 0.711x1.448 smd: 1(0,0) 2(1.5,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TAIYO_LBR2012T100M_2P
  rect 0.711x1.448 smd: 1(0,0) 2(1.5,0)
TAIYO_NRS4018T1R0NDGJ_2P
  rect 1.194x3.708 smd: 1(0,0) 2(2.8,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TDK_GLFR1608T1R0M-LR_2P
  rect 0.711x0.711 smd: 1(0,0) 2(1.4,0)
TDK_MLG1608BR10JT_2P
  oval 0.559x1.041 smd: 1(0,0) 2(1.3,0)
TOKO_FDSD0630-H-4R7M-P3_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
TP0610K-T1-E3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
TPC12
  round 0.305 smd: 1(0,0)
TPS2560DRCR-PG1P1_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51218DSCR_SON10_3X3
  oval 0.279x0.813 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.925) 7(1.5,2.925) 8(1,2.925) 9(0.5,2.925) 10(0,2.925)
  custom 0.412x0.412 smd: 11(1,1.463)
TPS51461RGER_QFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.54x2.54 smd: 25(1.25,1.975)
TYCO_2-2013022-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 3.505x4.597 smd: 205(1.15,-16.1) 206(-64.45,-16.1)
TYCO_2-2013287-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 3.505x4.597 smd: 205(1.15,7.9) 206(-64.45,7.9)
TYCO_2041127-1_15P
  oval 0.965x1.321 hole 0.711: 1(0,0) 2(2.29,0) 3(4.58,0) 4(6.87,0) 5(9.16,0) 6(-1.145,0) 7(1.145,0) 8(3.435,0) 9(5.725,0) 10(8.015,0)
  round 1.016 hole 0.711: 11(0,1.4) 12(2.29,1.4) 13(4.58,1.4) 14(6.87,1.4) 15(9.16,1.4)
  oval 1.372x3.251 hole 0.61x2.489: 16(14.63,-0.1) 17(-5.47,-0.1)
W25Q32BVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q64CVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
Y_Q13FC1350000_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_Q22FA2380049900_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_X3G025000DI1H-H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.75V_DDR_VTT_ON: PR236.1 R790.2 U46.A60
1.05V_0.8V_PWROK: PR723.1 R883.2 RH283.1 U50.4
1.05V_0.8V_PWROK_R: JXDP2.10 RH283.2 RH284.2
1.05V_A_PWRGD: PR400.2 PU400.1 U51.A14
1.5V_B+: PC274.1 PC276.1 PC279.1 PC281.1 PJP200.1 PQ200.5 PR205.1
1.5V_FB: PC215.2 PR237.2 PR238.2 PU200.6
1.05V_RUN_ENABLE: C773.1 Q63.4 Q64.1 R930.2 R1611.1
1.5V_RUN_ENABLE: C771.1 Q52.3 Q59.4 R920.2 R1610.1
1.5V_SUS_PWRGD: PR204.2 PU200.10 U51.B9
1.05V_VTTPWRGD: PR83.2 PR500.1 PU500.1 U50.1
1.8V_RUN_PWRGD: PR300.2 PU300.4 U46.B10
1.8VSP_FB: PC301.2 PR302.2 PR305.1 PU300.6
1.8VSP_LX: PL301.1 PR301.1 PU300.2 PU300.3
1.8VSP_VIN: PC300.1 PC307.1 PJP301.1 PU300.8 PU300.9 PU300.10
2VREF_6182: PC101.1 PU100.3 PU100.4 PU100.14
3.3V_RUN_ENABLE: C766.1 Q56.1 Q61.4 R940.2 R1618.1
3V_PWROK#: R391.2 U9.12
5V_ALW_PCH_ENABLE: CH107.1 QH4.2 QH8.1 RH279.2
5V_RUN_ENABLE: C767.1 Q55.4 Q62.1 R933.2 R1621.1
+0.75V_DDR_VTT: CD19.1 CD20.1 CD21.1 CD22.1 CD39.1 CD40.1 CD41.1 CD42.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 PJP203.1 R927.1
+0.75V_P: PC263.1 PC280.1 PJP203.2 PU200.2 PU200.20
+1.0V_LAN: C462.1 C463.1 C466.1 C467.1 C468.1 C469.1 C1177.1 L29.2 R548.1 U31.8 U31.11 U31.16 U31.22 U31.37 U31.40 U31.43 U31.46 U31.47
+1.05V_+1.5V_1.8V_RUN: CH53.1 RH197.1 UH4.AF11 UH4.AP16 UH4.AT16 UH4.Y49
+1.5V_CPU_VDDQ: CC135.1 CC149.2 CC150.2 CC161.1 CC162.1 CC163.1 CC164.1 CC165.1 CC166.1 CC167.1 CC178.2 CC179.2 CC180.1 CC181.1 CC250.1 CC251.1 CC252.1 CC253.1 CC254.1 CC255.1 CC256.1 CC257.1 CC258.1 CC259.1 CC574.1 QC3.1 QC3.2 QC3.3 R926.1 RC12.1 RC73.1 RC84.1 U1.AJ28 U1.AJ33 U1.AJ36 U1.AJ40 U1.AL30 U1.AL34 U1.AL38 U1.AL42 U1.AM28 U1.AM33 U1.AM36 U1.AM40 U1.AN26 U1.AN30 U1.AN34 U1.AN38 U1.AR26 U1.AR28 U1.AR30 U1.AR32 U1.AR34 U1.AR36 U1.AR40 U1.AV41 U1.AW26 U1.BA40 U1.BB28 U1.BG33
+1.5V_CPU_VDDQ_CHG: Q71.1 R926.2
+1.05V_M: CH64.1 CH65.1 CH67.1 CH68.1 CH69.1 PJP401.1 Q63.5 Q63.6 Q63.7 Q63.8 R548.2 UH4.AA19 UH4.AA21 UH4.AA24 UH4.AA26 UH4.AA27 UH4.AA29 UH4.AA31 UH4.AC26 UH4.AC27 UH4.AC29 UH4.AC31 UH4.AD29 UH4.AD31 UH4.T19 UH4.T21 UH4.V21 UH4.W21 UH4.W23 UH4.W24 UH4.W26 UH4.W29 UH4.W31 UH4.W33
+1.5V_MEM: CC149.1 CC150.1 CC178.1 CC179.1 CD3.1 CD4.1 CD5.1 CD6.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD16.1 CD25.1 CD26.1 CD27.1 CD28.1 CD31.1 CD32.1 CD33.1 CD34.1 CD35.1 CD36.1 CD37.1 CD38.1 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 PJP201.1 Q59.5 Q59.6 Q59.7 Q59.8 QC3.5 QC3.6 QC3.7 QC3.8 RC80.1 RD3.1
+1.5V_MEN_P: PC215.1 PC265.1 PC282.1 PJP201.2 PJP204.1 PL200.1 PR237.1 PU200.5
+1.05V_MP: PC406.1 PJP401.2 PL400.2 PR406.1
+1.05V_RUN: C772.1 CH6.1 CH30.1 CH31.1 CH32.1 CH33.1 CH44.1 CH45.1 CH46.1 CH47.1 CH48.1 CH50.1 CH56.1 CH77.1 CH79.1 CH82.1 CH106.1 JXDP2.14 LH6.1 LH7.1 Q63.1 Q63.2 Q63.3 R925.1 R931.1 RH40.2 RH42.2 RH111.1 RH359.1 RH360.1 UH4.AA23 UH4.AB36 UH4.AC16 UH4.AC17 UH4.AC23 UH4.AD17 UH4.AD21 UH4.AD23 UH4.AF13 UH4.AF14 UH4.AF17 UH4.AF21 UH4.AF23 UH4.AG21 UH4.AG23 UH4.AG24 UH4.AG26 UH4.AG27 UH4.AG29 UH4.AH13 UH4.AH14 UH4.AJ23 UH4.AJ26 UH4.AJ27 UH4.AJ29 UH4.AJ31 UH4.AL29 UH4.AN16 UH4.AN17 UH4.AN19 UH4.AN21 UH4.AN26 UH4.AN27 UH4.AN33 UH4.AN34 UH4.AP17 UH4.AP21 UH4.AP23 UH4.AP24 UH4.AP26 UH4.AT24 UH4.N26 UH4.P26 UH4.P28 UH4.T26 UH4.T27 UH4.T29
+1.5V_RUN: C593.1 C594.1 C601.1 C602.1 C619.1 C620.1 C769.1 JMINI1.6 JMINI1.28 JMINI1.48 JMINI2.6 JMINI2.28 JMINI2.48 JMINI3.6 JMINI3.28 JMINI3.48 L47.1 Q59.1 Q59.2 Q59.3 R921.1 R924.1 RH197.2
+1.5V_RUN_CHG: Q68.1 R924.2
+1.05V_RUN_CHG: Q70.1 R925.2
+1.05V_RUN_VCCA_A_DPL: CH92.1 CH94.1 LH6.2 UH4.BD47
+1.05V_RUN_VCCA_B_DPL: CH93.1 CH95.1 LH7.2 UH4.BF47
+1.05V_RUN_VTT: CC65.1 CC573.1 CH49.1 CH85.1 CH86.1 CH87.1 JXDP1.16 PC1124.1 PC1125.1 PC1154.1 PC1155.1 PC1156.1 PC1159.1 PC1160.1 PC1161.1 PC1162.1 PC1165.1 PC1166.1 PC1167.1 PC1172.1 PC1175.1 PC1176.1 PC1177.1 PC1178.1 PC1179.1 PC1180.1 PC1181.1 PC1182.1 PC1183.1 PC1184.1 PC1185.1 PC1186.1 PC1188.1 PC1189.1 PC1190.1 PC1191.1 PC1192.1 PC1193.1 PC1194.1 PC1195.1 PC1196.1 PC1197.1 PC1198.1 PC1199.1 PC1200.1 PC1201.1 PJP501.1 PJP502.1 PR730.2 PR735.2 PR737.2 R399.1 R862.2 R1179.1 RC1.1 RC2.1 RC4.1 RC17.2 RC27.1 RC29.1 RC32.1 RC35.1 RC44.1 RC60.1 RC63.1 RC98.1 RC126.1 RC128.1 RH262.1 U1.AA14 U1.AA15 U1.AB17 U1.AB20 U1.AC13 U1.AD16 U1.AD18 U1.AD21 U1.AE14 U1.AE15 U1.AF16 U1.AF18 U1.AF20 U1.AF46 U1.AG15 U1.AG16 U1.AG17 U1.AG20 U1.AG21 U1.AG48 U1.AG50 U1.AG51 U1.AJ14 U1.AJ15 U1.AJ17 U1.AJ21 U1.AJ25 U1.AJ43 U1.AJ47 U1.AK50 U1.AK51 U1.AL14 U1.AL15 U1.AL16 U1.AL20 U1.AL22 U1.AL26 U1.AL45 U1.AL48 U1.AM16 U1.AM17 U1.AM21 U1.AM25 U1.AM43 U1.AM47 U1.AN20 U1.AN22 U1.AN42 U1.AN45 U1.AN48 U1.W16 U1.W17 UH4.AT20 UH4.AU20 UH4.BJ8
+1.05VTTP: PC510.1 PC511.1 PJP501.2 PJP502.2 PL500.2
+1.8V_RUN: CC174.1 CC175.1 CC176.1 CH52.1 LH8.1 PJP300.1 RH149.1 U1.BB3 U1.BC1 U1.BC4 UH4.AG16 UH4.AG17 UH4.AJ16 UH4.AJ17
+1.8V_RUN_LVDS: CH103.1 CH104.1 CH105.1 LH8.2 UH4.AM37 UH4.AM38 UH4.AP36 UH4.AP37
+1.8V_RUNP: PC301.1 PC302.1 PC303.1 PC306.1 PJP300.2 PL301.2 PR302.1
