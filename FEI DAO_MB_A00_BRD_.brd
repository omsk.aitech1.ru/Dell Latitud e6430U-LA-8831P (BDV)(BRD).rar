# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SPI_CLK_TAA: length 4.3
  TOP w0.102: v1(196.32,21.92) 197.07,21.17 v2(197.07,21.1) R906.1
  BOTTOM w0.102: JTAA1.8 196.9,22.5 v1(196.32,21.92)
SPI_DIN32: length 12.9
  BOTTOM w0.102: R895.2 212.91,24.75 213.38,24.28 213.38,23.87 213.28,23.77 212.55,23.77 212.45,23.67 212.45,23.46 212.55,23.36 213.28,23.36 213.38,23.26 213.38,21.13 212.92,20.67 209.66,20.67 209.27,21.07 U53.2
SPI_DIN64: length 12.8
  BOTTOM w0.102: U52.2 210.51,29.78 210.38,29.91 208.93,29.91 208.81,30.02 208.81,30.19 208.93,30.31 213.28,30.31 213.4,30.19 213.4,30.02 213.28,29.89 211.26,29.89 211.13,29.77 211.13,27.31 R894.2
SPI_DIN_TAA: length 3.2
  TOP w0.102: v2(205.91,20.93) 205.07,20.93 R896.2 204.77,21.88 v1(204.72,21.93)
  BOTTOM w0.102: JTAA1.9 204.65,22 v1(204.72,21.93)
SPI_DO32: length 13.3
  BOTTOM w0.102: U53.5 211.81,16.86 211.74,16.93 211.41,16.93 211.31,17.03 211.31,17.28 211.44,17.41 213.42,17.41 213.52,17.31 213.52,17.1 213.42,17 212.6,17 212.55,16.95 212.55,16.65 212.6,16.6 213.42,16.6 213.52,16.49 213.52,16.29 213.42,16.19 212.6,16.19 212.55,16.14 212.55,15.81 212.6,15.76 213.47,15.76 213.57,15.66 213.57,15.45 213.47,15.35 212.6,15.35 212.55,15.3 212.55,15.02 212.63,14.95 213.34,14.95 213.44,14.84 213.44,14.49 213.34,14.39 R900.1
SPI_DO64: length 14.1
  BOTTOM w0.102: U52.5 207.97,35 207.5,34.53 206.1,34.53 206,34.63 206,35.12 206.1,35.22 206.84,35.22 206.94,35.32 206.94,35.53 206.84,35.63 206.1,35.63 206,35.73 206,35.93 206.1,36.03 206.84,36.03 206.94,36.14 206.94,36.34 206.84,36.44 206.1,36.44 206,36.54 206,36.75 206.1,36.85 206.84,36.85 206.94,36.95 206.94,37.15 206.84,37.25 206.1,37.25 206,37.36 206,37.75 206.15,37.91 R901.1 v2(208.73,37.91)
SPI_DO_TAA: length 4.3
  TOP w0.102: v1(197.12,24.53) v2(197.12,23.76) 197.12,23.21 197.41,22.92 R912.1
  BOTTOM w0.102: JTAA1.4 197.42,23.5 197.12,23.8 v1(197.12,24.53)
SPI_HOLD#: length 26
  IN3 w0.122: v1(210.61,38.53) 210.04,37.96 v3(210.04,17.18)
  BOTTOM w0.102: v1(210.61,38.53) R891.2 210.61,37.41 210.51,37.31 U52.7 ; v3(210.04,17.18) 209.61,17.18 209.27,16.84 U53.7
SPI_WP#_SEL: length 118.1
  TOP w0.102: v1(201.62,25.85) 201.62,22.98 202.04,22.57 211.28,22.57 212.13,23.42 212.13,26.57 v4(213.09,27.52) 214.03,28.46 v1(214.03,32.9) ; U46.A12 265.84,69.52 266.31,69.04 v1(266.31,68.74)
  IN1 w0.084: v1(214.03,32.9) 215.54,34.41 220.34,34.41 225.65,39.72 231.63,39.72 235.73,43.82 265.94,43.82 v1(268.94,46.82)
  IN3 w0.122: v1(268.94,46.82) 268.27,47.5 268.27,64.92 267.54,65.64 267.54,67.51 v1(266.31,68.74)
  BOTTOM w0.102: R898.1 209.3,25.77 207.13,25.77 206.53,25.17 202.3,25.17 v1(201.62,25.85)
SPI_WP#_SEL_R: length 7.3
  BOTTOM w0.102: U53.3 210.54,26.46 R898.2 R890.2 209.24,27.69 U52.3
SPKR: length 180.8
  TOP w0.102: v1(163.72,22.4) 163.15,21.84 163.15,21.68 162.93,21.46 162.93,19.25 164.97,17.22 164.97,16.18 165.5,15.64 v2(167.87,15.64) 169,15.64 169.32,15.33 173.26,15.33 174.49,14.1 181.46,14.1 182.94,15.57 182.94,17.71 183.39,18.17 183.39,20.37 183.71,20.69 184.8,20.69 RH35.2 ; R1119.2 40.96,42.79 v1(41.31,42.45)
  IN4 w0.084: v1(41.31,42.45) 49.24,34.51 49.24,28.66 50.23,27.68 63.2,27.68 71.89,18.98 94.1,18.98 94.84,19.73 101.1,19.73 104.09,22.72 109.65,22.72 113.75,26.83 126.24,26.83 130.99,22.09 135.8,22.09 136.55,22.83 141.83,22.83 142.41,22.25 142.79,22.25 144.57,20.46 147.95,20.46 148.65,21.17 153.54,21.17 154.71,22.34 156.49,22.34 157.08,22.92 158.09,22.92 159.68,24.51 161.77,24.51 162.18,24.09 162.18,23.48 162.59,23.07 163.04,23.07 v1(163.72,22.4)
  BOTTOM w0.102: UH4.T10 163.35,22.77 v1(163.72,22.4)
SRTCRST#: length 48.8
  TOP w0.102: v1(192.14,26.92) 192.14,26.93 v4(192.14,27.75)
  IN4 w0.084: v1(192.14,26.92) 191.67,26.92 191.04,27.55 190.06,27.55 189.56,27.05 183.62,27.05 182.19,25.62 178.2,25.62 174.77,29.04 173.28,29.04 173.08,28.84 171.44,28.84 171.28,29 167.61,29 167.38,28.77 v1(167.38,28.54)
  BOTTOM w0.102: v1(192.14,26.92) 194.63,29.42 194.63,37.39 193.93,38.08 ME1.2 193.45,38.68 190.84,41.29 RH23.2 189.17,41.29 188.99,41.47 CH5.2 ; UH4.G22 167.68,28.85 167.38,28.55 v1(167.38,28.54)
SUS_ON: length 12.7
  TOP w0.102: R878.2 253.95,75.5 253.38,74.93 v1(253.38,74.68) 252.57,74.68 v4(252.53,74.71) ; U46.B60 259.92,75.31 259.99,75.37 260.47,75.37 v1(260.91,75.81)
  IN1 w0.084: v1(253.38,74.68) 254.02,74.04 254.69,74.04 254.86,73.87 258.65,73.87 260.15,75.37 260.47,75.37 v1(260.91,75.81)
SUS_STAT#/LPCPD#: length 1.2
  TOP w0.102: T56.1 167.11,22.3 v1(167.39,22.58)
  BOTTOM w0.102: UH4.G8 167.39,22.33 v1(167.39,22.58)
SUSACK#: length 130.6
  TOP w0.102: U46.A58 258.03,74.56 v1(257.77,74.29) ; v1(257.23,34.51) v2(257.23,33.87)
  IN2 w0.122: v1(179.04,20.62) 179.46,20.62 180.56,21.73 184.92,21.73 186.33,23.14 216.74,23.14 218.12,24.53 229.8,24.53 239.94,34.67 250.15,34.67 251.67,33.15 255.87,33.15 v1(257.23,34.51)
  IN3 w0.122: v1(257.23,34.51) 257.04,34.71 257.04,37 257.98,37.94 257.98,40.18 259.24,41.44 259.24,43.28 258.43,44.09 258.43,46.84 258.35,46.92 258.35,61.86 256.71,63.5 256.71,66.93 257.65,67.88 257.65,69.82 258.18,70.35 258.18,73.88 v1(257.77,74.29)
  BOTTOM w0.102: RH114.1 178.32,21.5 179.04,20.77 v1(179.04,20.62)
SUSACK#_R: length 10
  BOTTOM w0.102: RH323.2 RH114.2 176.85,21.5 176.4,21.95 v2(174.02,21.95) 173.87,21.95 173.26,22.57 173.26,23.01 172.9,23.37 171.58,23.37 171.37,23.58 170.47,23.58 170.17,23.88 169.77,23.88 UH4.C12
SUSCLK: length 1.3
  TOP w0.102: v1(164.06,25.51) 164.44,25.12 T57.1
  BOTTOM w0.102: v1(164.06,25.51) 164.43,25.14 UH4.N14
SW_1.5V: length 9.9
  TOP w1.016: 35.08,67.71 32.56,70.24 27.18,70.24 26.52,69.58
  vias: v1(21.68,62.89) v1(21.68,62.25) v1(22.32,62.89) v1(22.32,62.25) v1(22.95,62.89) v1(22.95,62.25) v1(23.59,62.89) v1(23.59,62.25) v1(25.75,63.97) v1(26.45,63.97) v1(26.57,66.32) v1(26.57,65.68) v1(26.57,65.05) v1(27.08,63.97) v1(27.27,66.32) v1(27.27,65.68) v1(27.27,65.05) v1(27.78,63.97) v2(21.93,64.65)
SW_+V1.05S_VCCPP: length 3.6
  TOP w0.254: PU500.8 122.66,11.14 122.25,11.55 121.03,11.55 120.81,11.33
  TOP w0.508: 120.81,11.33 120.63,11.15 PC504.2
  vias: v1(116.77,8.33) v1(116.77,7.69) v1(117.2,6.09) v1(117.2,5.39) v1(117.4,8.33) v1(117.4,7.69) v1(117.93,6.09) v1(117.93,5.39) v1(118.04,8.33) v1(118.04,7.69) v1(118.7,8.33) v1(118.71,7.69) v2(123.28,8.65)
SW_+V1.05SP: length 0.6
  TOP w0.102: v4(158.77,57.08) 158.12,57.08
  vias: v1(155.76,57.11) v1(155.81,56.42) v1(155.81,55.79) v1(155.81,55.15) v1(156.42,57.11) v1(156.44,56.42) v1(156.47,55.79) v1(157.16,57.24)
SYS_LED_MASK#: length 165.1
  TOP w0.102: U58.1 258.68,87.74 v1(258.41,87.48) ; U46.B48 261.59,79.44 v1(261.36,79.21) ; v1(261.54,82.29) 261.52,82.3 R775.2
  IN1 w0.084: v1(261.54,82.29) 259.5,84.32 259.5,86.47 258.5,87.48 v1(258.41,87.48) 258.22,87.28 258.22,86.57 258.01,86.36 258.01,83.54 256.53,82.06 252.58,82.06 245.75,75.23 242.82,75.23 240.43,72.85 237.84,72.85 236.89,71.89 236.89,71.13 236.4,70.65 236.4,67.82 236.15,67.56 236.15,61.72 232.81,58.37 232.81,52.85 217.43,37.47 199.46,37.47 196.7,40.23 196.7,41.99 196.07,42.62 196.07,43.62 194.46,45.24 190.84,45.24 187.61,48.47 183.5,48.47 181.78,50.19 173.57,50.19 171.83,51.93 171.83,59.01 170.62,60.22 170.62,61.33 170.44,61.51 170.44,63.35 170.94,63.85 170.94,72.96 v1(170.46,73.45)
  BOTTOM w0.102: v1(261.36,79.21) 261.36,82.11 v1(261.54,82.29) ; Q80.2 166.85,72.94 v2(167.2,73.29) 167.36,73.45 v1(170.46,73.45)
SYS_PWROK: length 313.9
  TOP w0.102: v1(98.66,84.27) v4(97.78,83.38) 97.55,83.16 95.52,83.16 94.38,84.3 94.38,85.44 RC9.1 ; v1(260.28,76.83) 260.25,76.81 U46.B57 ; v1(164.6,24.52) 165,24.93 168.8,24.93 169,24.72 170.36,24.72 171.19,23.9 172.92,23.9 173.62,24.61 173.62,26 174.1,26.48 175.8,26.48 RH321.2
  IN2 w0.102: 174.55,23.11 173.4,23.11 172.99,23.52 170.07,23.52 169.54,24.05 165.07,24.05 v1(164.6,24.52)
  IN2 w0.122: v1(264.68,32.67) 263.74,32.67 260.51,35.91 255.4,35.91 254.91,35.42 239.63,35.42 229.61,25.4 217.51,25.4 216.31,24.2 202.62,24.2 202.31,23.89 186.02,23.89 184.62,22.49 180.25,22.49 179.33,21.56 176.27,21.56 174.72,23.11 174.55,23.11
  IN3 w0.122: v1(137.92,79.64) 137.92,73.43 138.46,72.89 138.46,68.95 136.46,66.95 136.46,66.95 135.66,66.14 135.66,63.96 136.58,63.04 136.58,61.89 139.34,59.13 139.34,49.02 140.96,47.41 147.09,47.41 149.52,49.84 150.34,49.84 150.96,50.47 156.26,50.47 157.74,48.99 157.74,45.03 158.23,44.54 158.23,42.69 159.04,41.89 159.04,37.45 159.39,37.1 159.86,37.1 161.05,35.91 161.05,35.61 161.5,35.16 161.5,34.32 163.5,32.32 166.3,32.32 167.05,31.56 167.05,30.77 167.66,30.16 168.92,30.16 169.74,29.34 169.74,25.38 169.3,24.94 165.01,24.94 v1(164.6,24.52) ; v1(264.68,32.67) 264.09,33.26 264.09,37.36 263.22,38.23 263.22,44.73 262.66,45.29 262.66,54.04 262.49,54.21 262.49,57.8 260.97,59.32 260.97,62.38 260.38,62.97 260.38,67.76 260.95,68.34 260.95,70.08 261.64,70.76 261.64,73.19 261.5,73.33 261.5,76.03 261.19,76.34 260.77,76.34 v1(260.28,76.83)
  IN4 w0.084: v1(137.92,79.64) 137.42,80.14 137.42,80.49 135.18,82.73 132.81,82.73 131.28,81.2 107.7,81.2 103.75,85.14 99.55,85.14 98.68,84.27 v1(98.66,84.27)
  BOTTOM w0.102: UH4.P12 164.16,24.09 v1(164.6,24.52)
SYS_PWROK_XDP: length 11.4
  TOP w0.102: RC9.2 RC124.2 91.67,85.25 v2(91.67,80.64) 91.67,78.57 90.38,77.28 JXDP1.13
SYSTEM_ID: length 5.4
  TOP w0.102: U51.A10 v2(294.82,59.1) 296.25,59.1 C742.1 R871.1
TCM_BA0: length 3.8
  BOTTOM w0.102: U39.9 U37.9 258.86,52.18 258.44,52.6 R660.1 R658.2
TCM_BA1: length 4.9
  BOTTOM w0.102: v2(258.16,45.97) R659.1 R657.2 258.47,48.28 U37.3 U39.3
TEMP_ALERT#: length 196.3
  TOP w0.102: RH266.1 185.91,17.8 185.24,17.8 184.63,17.19 184.63,14.77 183.94,14.08 182.62,14.08 181.5,12.96 176.55,12.96 176.32,12.74 173.3,12.74 171.66,14.37 v2(170.54,14.37) 169.09,14.37 168.61,14.86 165.2,14.86 164.63,15.43 161.91,15.43 160.93,16.41 160.93,17.55 161.18,17.8 161.18,19.22 v1(161.71,19.75) ; v1(266.98,64.59) 265.17,66.41 R738.2
  IN2 w0.102: v1(161.71,19.75) 162.17,19.75 163.62,18.3 165.12,18.3 165.72,17.7 166.01,17.7 166.12,17.59
  IN2 w0.122: v1(267.03,25.66) 266.55,26.15 260.74,26.15 259.5,24.91 246.09,24.91 240.38,19.2 222.01,19.2 217.79,14.98 213.28,14.98 211.71,13.42 205.2,13.42 204.11,14.51 203.17,14.51 202.82,14.16 197.79,14.16 197.18,13.54 190.26,13.54 187.15,10.43 182.72,10.43 181.54,11.62 174.65,11.62 169.42,16.84 167.9,16.84 167.41,17.33 166.38,17.33 166.12,17.59
  IN3 w0.122: v1(266.98,64.59) 267.86,63.71 267.86,58.47 267.38,57.99 267.38,44.65 268.02,44.01 268.02,26.65 v1(267.03,25.66)
  BOTTOM w0.102: v1(161.71,19.75) 161.92,19.54 UH4.V3
TEMP_ALERT#_R: length 5.2
  TOP w0.102: v1(265.4,69) 265.17,68.77 R738.1 ; v1(265.1,71.4) 265.09,71.38 U46.B11
  IN1 w0.084: v1(265.4,69) 265.4,71.11 v1(265.1,71.4)
  BOTTOM w0.102: v1(265.4,69) 265.4,69.39 v2(265.61,69.61)
TEST1: length 0.8
  BOTTOM w0.102: U37.12 U39.12
TEST2: length 0.8
  BOTTOM w0.102: U37.6 U39.6
THERM_STP#: length 179.1
  TOP w0.102: v1(244.23,15.94) 244.61,15.94 v2(245.08,16.41) 245.57,16.9 247.35,16.9 247.74,17.29 PR116.1 ; v1(169.92,98.3) 168.99,97.37 168.99,81.65 170.71,79.93 170.71,77.82 172.19,76.34 172.19,71.57 173.31,70.46 173.31,66.51 171.16,64.36 171.16,62.68 169.23,60.75 169.23,58.6 170.46,57.37 170.46,52.14 173.5,49.1 187.55,49.1 191.51,45.13 194.47,45.13 195.69,43.91 195.69,28.52 192.35,25.18 192.35,23.53 191.94,23.12 191.94,16.85 v1(191.56,16.47) ; v1(160.62,99.29) 160.63,99.28 v1(163.39,99.28)
  IN1 w0.084: v1(244.23,15.94) 243.74,15.45 242.6,15.45 242.29,15.76 213.83,15.76 213.52,15.45 197.39,15.45 197.2,15.26 193.22,15.26 192.02,16.47 v1(191.56,16.47)
  BOTTOM w0.102: U9.19 160.19,99.72 v1(160.62,99.29) ; v1(169.92,98.3) 169.37,97.75 166.32,97.75 166.06,98.02 166.06,98.83 R390.1 165.24,98.52 164.14,98.52 v1(163.39,99.28)
THERMATRIP2#: length 11.8
  BOTTOM w0.102: Q16.1 169.25,95.74 C278.1 R395.2 168.56,97.32 v2(165.12,97.32) 164.69,97.32 163.23,98.78 161.89,98.78 161.19,99.48 U9.17
TMDSB_CON_CLK: length 8.2
  BOTTOM w0.102: JHDMI1.10 76.36,102.41 76.36,102.05 76.01,101.7 74.07,101.7 73.08,100.71 73.08,100.35 72.99,100.26 72.99,100.26 72.6,99.87 72.6,99.64 72.32,99.36 L19.2 72.32,98.71 L117.2 71.22,98.6 C1217.1
TMDSB_CON_CLK#: length 8.2
  BOTTOM w0.102: JHDMI1.12 76.62,102.39 76.62,101.94 76.12,101.43 74.18,101.43 73.35,100.6 73.35,100.24 v1(73.18,100.07) 72.86,99.75 72.86,99.64 73.17,99.34 L19.3 73.17,98.7 L116.2 74.25,98.6 C1216.1
TMDSB_CON_N0: length 15.6
  BOTTOM w0.102: 78.44,100.62 78.44,100.62 ; 78.44,100.62 78.21,100.39 77.23,100.39 76.76,99.92 76.76,99.67 77.05,99.38 L20.3 77.05,98.7 L118.2 77.18,98.57 C1219.1 ; 78.44,100.62 79.57,101.75 80.6,101.75 81.06,102.21 81.06,102.86 80.61,103.3 80.02,103.6 79.46,103.37 78.99,103.61 78.57,103.38 78.01,103.56 77.44,103.37 77.08,103.6 76.55,103.38 76.13,103.51 75.89,103.58 75.5,103.35 75.28,103.46 75.18,103.56 75.18,103.77 75.38,103.97 JHDMI1.9 ; 78.44,100.62 78.44,100.62 ; 78.44,100.62 v1(78.44,100.62)
TMDSB_CON_N1: length 9.9
  BOTTOM w0.102: L120.2 67.89,98.37 L21.3 67.89,98.88 67.59,99.17 67.59,99.4 67.7,99.51 68,99.51 68.14,99.36 68.48,99.36 C1221.1 69.41,99.35 71.02,99.35 v1(71.25,99.57) 73.65,101.98 73.65,102.42 JHDMI1.6
TMDSB_CON_N2: length 12.8
  BOTTOM w0.102: JHDMI1.3 72.38,103.97 72,103.59 72,103.57 70.87,102.44 70.87,101.95 69.45,100.53 v1(67.84,100.53) 67.59,100.53 66.76,101.36 65.67,101.36 65.44,101.12 65.44,100.36 C1223.1 65.79,99.55 65.59,99.55 65.45,99.41 65.45,99.21 65.74,98.92 L22.3 65.74,98.38 L122.2
TMDSB_CON_P0: length 15.6
  BOTTOM w0.102: JHDMI1.7 74.94,103.53 74.94,103.42 74.98,103.38 75,103.38 75.04,103.36 75.5,103.13 75.92,103.36 76.56,103.17 76.63,103.19 77.06,103.37 77.41,103.14 78.01,103.34 78.6,103.16 78.99,103.38 79.44,103.14 79.71,103.25 80.01,103.38 80.49,103.14 80.79,102.84 80.79,102.32 80.49,102.02 79.46,102.02 78.36,100.91 78.1,100.66 77.12,100.66 v1(76.82,100.36) 76.5,100.03 76.5,99.67 76.21,99.37 L20.2 76.21,98.69 L119.2 75.13,98.58 C1218.1
TMDSB_CON_P1: length 9.9
  BOTTOM w0.102: L121.2 67.04,98.38 L21.2 67.04,98.89 67.33,99.18 67.33,99.51 67.59,99.77 68.11,99.77 68.26,99.63 68.51,99.63 C1220.1 69.41,99.62 70.91,99.62 v1(72.07,100.77) 73.39,102.09 73.39,102.38 JHDMI1.4
TMDSB_CON_P2: length 12.9
  BOTTOM w0.102: L123.2 64.89,98.37 L22.2 64.89,98.92 65.18,99.21 65.18,99.41 65.04,99.55 64.8,99.55 C1222.1 64.87,100.03 65.04,100.03 65.18,100.16 65.18,101.24 65.56,101.62 v1(65.91,101.62) 66.87,101.62 67.7,100.8 69.34,100.8 70.6,102.06 70.6,102.55 71.74,103.68 71.74,103.86 71.62,103.97 JHDMI1.1
TMDSB_PCH_CLK: length 120.2
  IN3 w0.122: v1(149.78,42.83) 150.08,43.13 150.08,43.45 149.96,43.58 149.17,43.58 146.48,40.89 143.23,40.89 142.24,39.9 137.62,39.9 136.16,41.36 136.16,45.82 135.51,46.46 135.51,59.05 132.69,61.87 132.69,64.03 127.01,69.72 126.1,69.72 125.22,70.6 125.22,71.09 124.45,71.86 119.02,71.86 111.96,78.92 107.71,78.92 106.82,79.8 100.82,79.8 98.95,81.67 97.36,81.67 95.2,83.83 95.2,85.96 90.8,90.37 82.94,90.37 80.87,92.44 73.3,92.44 72.94,92.8 72.94,93.17 v3(72.74,93.37)
  BOTTOM w0.102: C352.2 72.59,94.48 72.59,94.03 72.88,93.74 72.88,93.51 v3(72.74,93.37) ; v1(149.78,42.83) 150.02,42.83 150.14,42.95 150.14,43.29 150.41,43.56 151.26,43.56 152.21,42.61 152.21,42.34 UH4.AV49
TMDSB_PCH_CLK#: length 120.2
  IN3 w0.122: v3(73.37,93.37) 73.18,93.18 73.18,92.9 73.4,92.68 80.97,92.68 83.04,90.61 90.9,90.61 95.45,86.07 95.45,83.93 97.46,81.92 99.05,81.92 100.93,80.05 106.93,80.05 107.81,79.16 112.07,79.16 119.12,72.11 124.55,72.11 125.47,71.19 125.47,70.7 126.21,69.96 127.11,69.96 132.93,64.13 132.93,61.97 135.76,59.15 135.76,46.57 136.4,45.92 136.4,41.46 137.72,40.14 142.14,40.14 143.13,41.13 146.37,41.13 149.07,43.82 150.06,43.82 150.33,43.55 150.33,43.17 v1(150.67,42.83)
  BOTTOM w0.102: C353.2 72.85,94.43 72.85,94.14 73.14,93.85 73.14,93.6 v3(73.37,93.37) ; v1(150.67,42.83) 150.41,43.09 150.41,43.18 150.52,43.29 151.15,43.29 151.94,42.5 151.94,42.18 152.08,42.04 152.08,41.58 UH4.AV47
TMDSB_PCH_CLK#_C: length 3.1
  BOTTOM w0.102: R455.1 74.05,95.68 C353.1 72.88,95.99 72.88,96.39 73.17,96.68 L19.4 73.17,97.53 L116.1
TMDSB_PCH_CLK_C: length 3.2
  BOTTOM w0.102: R456.1 71.4,95.68 C352.1 72.61,95.99 72.61,96.39 72.32,96.68 L19.1 72.32,97.52 L117.1
TMDSB_PCH_N0: length 117.9
  IN3 w0.122: v1(151.65,43.88) 151.65,44.15 151.27,44.52 148.66,44.52 146.06,41.92 142.04,41.92 140.91,40.79 138.04,40.79 137.1,41.73 137.1,58.66 133.57,62.2 133.57,64.67 125.5,72.73 121.96,72.73 117.42,77.27 115.41,77.27 112.96,79.72 107.99,79.72 107.15,80.56 102.2,80.56 99.29,83.47 99.29,84.37 91.64,92.02 83.37,92.02 80.8,94.58 77.03,94.58 76.73,94.28 76.73,93.99 v3(76.92,93.79)
  BOTTOM w0.102: v3(76.92,93.79) 76.75,93.97 76.75,94.44 C351.2 ; v1(151.65,43.88) 151.65,44.25 151.75,44.35 151.84,44.35 151.99,44.5 152.42,44.5 152.69,44.23 152.69,42.26 152.69,42.19 152.6,42.1 152.53,42.1 152.31,41.88 152.31,41.78 152.49,41.6 152.67,41.6 152.77,41.7 UH4.AU48
TMDSB_PCH_N0_C: length 3.1
  BOTTOM w0.102: L118.1 77.05,97.51 L20.4 77.05,96.76 76.75,96.45 76.75,96 C351.1 77.08,95.67 R453.1
TMDSB_PCH_N1: length 126.4
  IN3 w0.122: v1(152.7,40.38) 152.4,40.68 152.4,45.08 151.96,45.52 147.75,45.52 145.69,43.46 141.69,43.46 138.15,47 138.15,59.03 135.83,61.35 135.83,62.66 134.9,63.58 134.9,66.3 132.64,68.56 131.62,68.56 129.65,70.54 129.65,70.54 126.34,73.85 123.65,73.85 116.57,80.94 108.68,80.94 103.85,85.77 99.95,85.77 90.14,95.58 72.42,95.58 71.84,95.01 71.84,91.55 71.21,90.92 68.97,90.92 68.86,91.03 68.86,91.19 v3(69.04,91.37)
  BOTTOM w0.102: C347.2 68.88,91.84 68.88,91.53 v3(69.04,91.37) ; UH4.AV45 152.27,40.14 152.51,40.38 v1(152.7,40.38)
TMDSB_PCH_N1_C: length 6.1
  BOTTOM w0.102: L120.1 67.89,97.2 L21.4 67.89,96.58 67.61,96.3 67.61,96.17 67.74,96.03 67.98,96.03 v1(68.31,95.7) 68.86,95.15 68.86,93.41 C347.1 R449.1
TMDSB_PCH_N2: length 125.5
  IN3 w0.122: v3(66.19,93.68) 65.8,93.29 65.8,92.65 68.6,89.85 89.32,89.85 93.27,85.9 93.27,84.34 96.85,80.76 98.36,80.76 106.77,72.35 117.24,72.35 119.28,70.32 124.34,70.32 126.12,68.54 126.12,67.8 128.25,65.67 129.82,65.67 131.54,63.95 131.54,62.24 134.51,59.27 134.51,46.29 135.34,45.46 135.34,40.71 136.85,39.2 141.46,39.2 142.28,38.38 147.81,38.38 148.61,39.18 152.13,39.18 152.41,38.9 152.41,38.74 v1(152.71,38.44)
  BOTTOM w0.102: v1(152.71,38.44) 152.35,38.79 UH4.AV42 ; v3(66.19,93.68) 66.01,93.87 66.01,94.04 C349.2
TMDSB_PCH_N2_C: length 3.6
  BOTTOM w0.102: R450.1 66.35,95.29 C349.1 66.03,95.61 66.03,95.87 65.77,96.14 65.55,96.14 65.45,96.24 65.45,96.34 65.74,96.63 L22.4 65.74,97.19 L122.1
TMDSB_PCH_P0: length 117.9
  IN3 w0.122: v3(151.65,44.77) 148.56,44.77 145.95,42.17 141.94,42.17 140.81,41.03 138.14,41.03 137.35,41.83 137.35,58.76 133.81,62.3 133.81,64.77 125.6,72.98 122.07,72.98 117.52,77.52 115.51,77.52 113.07,79.96 108.1,79.96 107.25,80.81 102.3,80.81 99.54,83.58 99.54,84.47 91.74,92.26 83.47,92.26 80.9,94.83 76.93,94.83 76.48,94.38 76.48,93.99 v1(76.29,93.79)
  BOTTOM w0.102: UH4.AU47 152.77,41.32 153.08,41.63 153.08,42.03 152.96,42.15 152.96,44.34 152.53,44.77 v3(151.65,44.77) ; v1(76.29,93.79) 76.48,93.99 76.48,94.46 C350.2
TMDSB_PCH_P0_C: length 3.1
  BOTTOM w0.102: L119.1 76.21,97.52 L20.1 76.21,96.8 76.48,96.52 76.48,95.98 C350.1 76.18,95.67 R454.1
TMDSB_PCH_P1: length 126.4
  IN3 w0.122: v3(151.8,40.38) 152.15,40.73 152.15,44.98 151.86,45.27 147.85,45.27 145.79,43.21 141.59,43.21 137.9,46.9 137.9,58.93 135.58,61.24 135.58,62.56 134.66,63.48 134.66,66.2 132.54,68.32 131.52,68.32 129.4,70.43 129.4,70.44 126.23,73.61 123.55,73.61 116.46,80.69 108.58,80.69 103.75,85.52 99.85,85.52 90.04,95.33 72.52,95.33 72.09,94.9 72.09,91.45 71.31,90.67 68.86,90.67 68.61,90.92 68.61,91.16 v1(68.4,91.37)
  BOTTOM w0.102: UH4.AV46 152.12,40.7 v3(151.8,40.38) ; v1(68.4,91.37) 68.61,91.58 68.61,91.86 C346.2
TMDSB_PCH_P1_C: length 6.1
  BOTTOM w0.102: L121.1 67.04,97.19 L21.1 67.04,96.62 67.34,96.31 67.34,96.06 67.63,95.77 67.87,95.77 68.6,95.04 v1(68.6,94.24) 68.6,93.36 C346.1 R448.1
TMDSB_PCH_P2: length 125.5
  IN3 w0.122: v1(65.56,93.68) 65.56,92.54 68.49,89.61 89.22,89.61 93.03,85.8 93.03,84.24 96.75,80.52 98.26,80.52 106.67,72.11 117.14,72.11 119.17,70.07 124.24,70.07 125.87,68.44 125.87,67.7 128.15,65.42 129.72,65.42 131.29,63.85 131.29,62.14 134.26,59.17 134.26,46.19 135.1,45.36 135.1,40.61 136.75,38.96 141.35,38.96 142.18,38.13 147.91,38.13 148.71,38.93 152.02,38.93 152.16,38.8 152.16,38.6 152.04,38.48 v3(151.8,38.48)
  BOTTOM w0.102: C348.2 65.74,94.1 65.74,93.87 v1(65.56,93.68) ; UH4.AV40 152.12,38.16 v3(151.8,38.48)
TMDSB_PCH_P2_C: length 3.6
  BOTTOM w0.102: R452.1 65.44,95.29 C348.1 65.46,95.3 65.77,95.6 65.77,95.76 65.66,95.87 65.44,95.87 65.18,96.13 65.18,96.3 64.89,96.59 L22.1 64.89,97.21 L123.1
TP_CLK: length 9.9
  TOP w0.102: L55.1 221.15,29.6 C749.1 220.17,29.31 219.79,29.31 219.53,29.58 218.26,29.58 217.67,28.98 217.67,28.43 217.57,28.33 D37.2 216.82,26.82 v2(217.37,26.27) 217.55,26.09 JTP1.3
TP_DATA: length 14
  TOP w0.102: JTP1.4 218.05,26.06 218.75,26.76 D37.3 218,28.33 217.9,28.43 217.9,28.89 218.36,29.35 219.43,29.35 219.7,29.08 220.15,29.08 C750.1 220.68,28.98 223.39,28.98 v2(223.47,28.89) 223.56,28.98 224.54,28.98 L54.1
TP_DC_TEST_A4: length 8
  BOTTOM w0.102: T121.1 131.3,32.37 131.3,35.51 132.36,36.58 132.36,37.04 132.17,37.24 U1.A4
TP_DC_TEST_A58: length 5.7
  BOTTOM w0.102: T119.1 134.64,68.2 132.15,65.71 132.15,64.77 U1.A58
TP_DC_TEST_BD1: length 7.9
  BOTTOM w0.102: T124.1 103.84,35.18 105.9,35.18 106.36,35.63 110.01,35.63 U1.BD1
TP_DC_TEST_BD61: length 3.8
  BOTTOM w0.102: U1.BD61 109.85,66.33 T122.1
TP_DC_TEST_BG4: length 7.7
  BOTTOM w0.102: T123.1 103.28,36 103.69,35.6 105.57,35.6 106.1,36.13 107.91,36.13 109.26,37.48 U1.BG4
TP_DC_TEST_BG58: length 4.7
  BOTTOM w0.102: U1.BG58 107.07,66.51 T132.1
TP_DC_TEST_D1: length 3.8
  BOTTOM w0.102: U1.D1 130.97,35.86 T118.1
TP_DC_TEST_D61: length 4.8
  BOTTOM w0.102: U1.D61 131.23,66.46 131.87,66.46 133.28,67.87 T120.1
TP_LAN_JTAG_TCK: length 3.7
  TOP w0.102: U31.35 285.11,85.05 284.78,85.38 284.78,85.75 R546.2 283.24,86.66 v2(282.95,86.37)
TP_LAN_JTAG_TDI: length 4.4
  TOP w0.102: T142.1 285.73,88.55 285.73,85.81 286.31,85.23 U31.32
TP_LAN_JTAG_TDO: length 5.7
  TOP w0.102: T143.1 283.3,88.68 284.23,88.68 284.54,88.38 284.54,86.41 285.01,85.94 285.01,85.53 285.51,85.03 U31.34
TP_LAN_JTAG_TMS: length 2.4
  TOP w0.102: R545.2 285.25,85.8 v2(285.34,85.71) 285.34,85.67 285.91,85.1 U31.33
TP_VCC_DIESENSE: length 1.3
  TOP w0.102: T128.1 129.7,59.45 v5(129.22,58.97)
  BOTTOM w0.102: U1.F48 129.58,59.33 v5(129.22,58.97)
TPM_ID0: length 29.3
  IN1 w0.084: v1(151.83,16.69) 152.66,15.86 155.62,15.86 160.18,11.3 v1(161.55,11.3)
  BOTTOM w0.102: RH267.1 148.87,13.83 RH270.2 149.62,13.08 151.62,13.08 152.06,13.52 152.06,16.46 v1(151.83,16.69) ; UH4.N2 164.48,18.92 164.48,18.54 164.28,18.34 164.28,17.65 163.89,17.26 163.89,16.87 164.23,16.53 164.23,16.32 163.96,16.05 163.96,13.1 v2(163.67,12.81) 162.84,11.99 162.24,11.99 v1(161.55,11.3)
TPM_ID1: length 5.2
  BOTTOM w0.102: RH271.1 RH268.2 v2(166.3,16.69) 166.3,17.07 165.48,17.88 165.48,18.83 165.32,19 165.32,19.38 UH4.M3
TRIP_+V1.05S_VCCPP: length 1.8
  TOP w0.254: PU500.2 126.69,10.64 127.27,10.06 PR501.2
TRIP_+V1.05SP: length 1.3
  BOTTOM w0.254: PU400.2 156.44,67.76 PR402.2
UG_3V: length 4.1
  IN1 w1.016: 257.78,8.53 255.39,8.53 254.21,9.71
  vias: v1(252.55,9.7) v1(253.18,9.69) v1(258.72,8.85) v1(259.35,8.84) v2(260.84,8.65)
UG_5V: length 7.3
  TOP w0.102: v1(238.47,10.32) v4(238.47,9.46)
  IN1 w1.016: 238.17,9.46 239.31,8.32 244.09,8.32
  vias: v1(237.83,10.32) v1(244.89,8.8) v1(245.52,8.8)
UG_+V1.05S_VCCPP: length 5.2
  TOP w0.102: v4(120.5,3.25) 120.5,3.67
  IN1 w1.016: 121.7,9.23 121.7,5.61 120.85,4.76
  vias: v1(120.19,3.87) v1(120.82,3.87) v1(121.32,10.56) v1(121.95,10.56)
UG_+V1.05SP: length 1.2
  TOP w0.102: v4(158.72,58.95) 157.87,58.95 v1(157.61,58.7)
  vias: v1(156.27,62.93) v1(156.27,62.29) v1(157.61,58.04)
UGATE1: length 5.5
  IN4 w1.016: 149.46,76.62 149.46,79.99 147.99,81.47
  vias: v1(146.72,81.95) v1(147.07,81.39) v1(149.32,75.33) v1(149.32,74.7) v2(148.75,75.23)
UGATE1G: length 15.8
  TOP w0.102: v2(126.33,84.1) 125.98,84.45 v1(125.27,84.45)
  IN4 w1.016: 138.26,82.38 137.7,82.38 135.22,84.86 133.63,84.86 132.86,85.63 125.05,85.63
  vias: v1(124.62,84.45) v1(139.79,82.7) v1(140.43,82.7)
UIM_CLK: length 43.9
  IN3 w0.122: v1(291.86,24.77) 292.09,24.54 292.29,24.54 292.79,25.04 292.79,29.28 291.54,30.53 291.54,32.04 291.78,32.28 292.08,32.28 v1(292.27,32.47) 292.47,32.28 292.69,32.28 292.83,32.42 292.83,35.37 295.74,38.28 295.74,40.63 v3(295.55,40.83)
  BOTTOM w0.102: JSIM1.3 282.7,25.26 282.19,24.75 282.19,23.7 283.21,22.68 289.28,22.68 291.17,24.57 291.66,24.57 v1(291.86,24.77) ; v1(292.27,32.47) 291.81,32.01 287.14,32.01 286.71,31.58 C628.1 286.71,31.17 U40.3 ; JMINI1.12 295.4,41.88 295.76,41.52 295.76,41.05 v3(295.55,40.83)
UIM_DATA: length 38.9
  IN3 w0.122: v3(291.86,24.13) 292.01,24.29 292.39,24.29 293.03,24.93 293.03,29.39 291.79,30.63 291.79,31.93 291.88,32.03 292.08,32.03 v1(292.27,31.84) 292.46,32.03 292.79,32.03 293.08,32.32 293.08,35.27 295.99,38.17 295.99,40.64 v1(296.18,40.83)
  BOTTOM w0.102: U40.4 292.27,31.17 C631.1 v1(292.27,31.84) ; JMINI1.10 296.2,41.78 295.99,41.57 295.99,41.02 v1(296.18,40.83) ; JSIM1.7 281.43,25.28 281.96,24.75 281.96,23.6 283.11,22.45 289.38,22.45 291.26,24.34 291.66,24.34 v3(291.86,24.13)
UIM_RESET: length 26.4
  TOP w0.102: v1(291.62,28.29) 291.64,28.3 v2(291.64,28.97)
  IN3 w0.122: v1(291.62,28.29) 291.64,28.29 290.64,29.28 290.64,34.68 293.85,37.89 v1(293.85,40.68)
  BOTTOM w0.102: JSIM1.2 285.24,28.35 286.15,29.26 C629.1 287.18,29.26 287.19,29.27 U40.1 289.3,29.27 290.28,28.29 v1(291.62,28.29) ; JMINI1.14 294.6,41.44 v1(293.85,40.68)
UIM_VPP: length 33.4
  TOP w0.102: v2(293.15,42.06) 293.85,41.36 v1(293.85,41.32)
  IN3 w0.122: v1(293.85,41.32) 294.29,40.88 294.29,37.98 290.92,34.61 290.92,29.64 v1(292.27,28.29)
  BOTTOM w0.102: U40.6 291.57,29.27 291.64,29.21 C630.1 v1(292.27,28.29) 292.27,27.06 288.4,23.19 285.73,23.19 283.97,24.95 JSIM1.6 ; v1(293.85,41.32) 293.8,41.37 JMINI1.16
USB3RN1: length 208.1
  IN1 w0.084: v3(148.81,31.54) 149.03,31.76 149.03,32.48 149.42,32.88 150.33,32.88 150.45,32.99 154.54,32.99 155.13,32.4 157.31,32.4 158.32,33.41 162.18,33.41 162.72,32.88 163.05,32.88 164.19,31.74 164.19,31.3 164.39,31.09 165.68,31.09 166.68,30.09 169.09,30.09 169.97,29.21 169.97,28.74 171.34,27.37 173.17,27.37 173.87,26.67 174.55,26.67
  IN1 w0.091: v1(307.87,59.02) 307.71,58.86 307.12,58.86 304.4,56.15 304.4,54.01 306.22,52.2 306.22,45.91 309.17,42.97 309.17,29.12 305.89,25.84 279.22,25.84 278.2,24.82 264.73,24.82 264.07,25.48 235.19,25.48 232.26,22.55 193.63,22.55 193.14,22.06 191.31,22.06 188.99,24.39 186.44,24.39 184.89,25.94 181.21,25.94 179.58,24.31 178.55,24.31 178.02,24.83 176.59,24.83 174.76,26.67 174.55,26.67
  BOTTOM w0.102: R1605.1 309.47,59.14 L95.1 308.61,59.14 308.28,58.81 308.08,58.81 v1(307.87,59.02) ; UH4.BE28 149.11,31.85 v3(148.81,31.54)
USB3RN1_D-: length 9.9
  BOTTOM w0.102: JUSB1.5 318.19,61.16 318.06,61.03 317.36,61.03 314.96,58.63 v1(314.56,58.63) 314.07,58.63 313.92,58.78 D78.1 D78.10 312.02,58.78 311.88,58.64 311.79,58.64 311.65,58.79 311.51,58.79 311.16,59.14 L95.2 310.42,59.14 R1605.2
USB3RN2: length 159.1
  IN3 w0.122: v1(150.05,33.44) 149.86,33.25 149.86,32.99 149.54,32.67 146.97,32.67 146.77,32.88 139.64,32.88 138.73,31.96 130.51,31.96 130.02,31.47 127.81,31.47 127.15,30.81 121.25,30.81 119.57,29.13 113.8,29.13 112.7,30.23 106.53,30.23 98.97,22.67 86.44,22.67 84.94,21.17 75.12,21.17 72.27,18.32 60.85,18.32 60.52,18.65 58.05,18.65 57.32,19.38 57.32,37.77 56.37,38.72 55.62,38.72 53.03,41.31 49,41.31 47.42,42.9 39.94,50.38 27.06,50.38 26,49.32 25.67,49.32 v3(25.44,49.1)
  BOTTOM w0.102: v3(25.44,49.1) 25.23,49.31 25.06,49.31 24.74,48.99 L114.1 23.93,48.99 R1704.1 ; UH4.BC30 149.75,33.14 v1(150.05,33.44)
USB3RN2_D-: length 11.6
  BOTTOM w0.102: JUSB3.5 13.81,46.34 13.89,46.42 14.34,46.42 14.98,47.05 15.74,47.05 17.41,48.71 17.42,48.71 17.8,49.09 17.8,49.11 18.15,49.46 v1(18.71,49.46) 19.37,49.46 19.49,49.35 D89.6 D89.5 21.49,49.35 21.56,49.42 21.7,49.42 22.13,48.99 L114.2 22.97,48.99 R1704.2
USB3RN3: length 184.3
  IN1 w0.084: v3(148.6,33.44) 148.51,33.44 148.38,33.57 148.38,33.78 148.47,33.87 150.41,33.87 150.48,33.94 153.21,33.94 153.34,33.8 154.98,33.8 155.54,33.25 156.57,33.25 157.27,33.95 157.27,34.49 157.75,34.97 162.12,34.97 163.43,33.66 163.43,33.37 164.77,32.03 166.59,32.03 167.8,30.82 169.15,30.82 170.54,29.43 170.54,28.93 171.6,27.86 173.45,27.86 173.93,27.38 174.55,27.38
  IN1 w0.091: v1(254.96,26.2) 254.72,26.45 254.4,26.45 254.07,26.78 235.63,26.78 232.01,23.15 191.13,23.15 189.29,24.99 186.69,24.99 185.12,26.55 180.89,26.55 180.13,25.79 176.9,25.79 175.32,27.37 174.6,27.37 174.6,27.38 174.55,27.38
  IN3 w0.122: v1(254.69,89.76) 254.9,89.55 254.9,88.52 255.36,88.06 255.36,79.53 255.98,78.91 255.98,75.27 255.46,74.76 255.46,68.01 255.15,67.7 255.15,55.22 255.49,54.87 255.49,47.86 255.25,47.62 255.25,37.67 254.92,37.33 254.92,29.5 254.11,28.69 254.11,26.78 254.46,26.43 254.74,26.43 v1(254.96,26.2)
  BOTTOM w0.102: v1(254.69,89.76) 254.92,89.98 254.92,90.13 254.58,90.47 L112.1 254.58,91.21 R1682.1 ; v3(148.6,33.44) 149.09,33.93 UH4.BE32
USB3RN3_D-: length 8.1
  BOTTOM w0.102: JESA1.12 252.4,97.24 252.52,97.12 252.52,96.58 253.28,95.82 254.77,95.82 254.86,95.73 254.86,95.6 254.72,95.47 D88.6 D88.5 254.72,93.51 254.88,93.35 254.88,93.14 254.58,92.83 L112.2 254.58,92.17 R1682.2
USB3RP1: length 208.1
  IN1 w0.084: 174.55,26.49 174.54,26.49 174.53,26.5 174.48,26.5 174.48,26.5 173.8,26.5 173.1,27.2 171.27,27.2 169.8,28.67 169.8,29.14 169.02,29.93 166.61,29.93 165.61,30.93 164.32,30.93 164.03,31.23 164.03,31.67 162.98,32.71 162.65,32.71 162.12,33.25 158.39,33.25 157.38,32.24 155.06,32.24 154.47,32.83 150.52,32.83 150.4,32.71 149.49,32.71 149.19,32.41 149.19,31.64 149.29,31.54 v1(149.44,31.54)
  IN1 w0.091: 174.55,26.49 174.69,26.49 176.52,24.66 177.95,24.66 178.47,24.13 179.65,24.13 181.29,25.77 184.82,25.77 186.37,24.21 188.91,24.21 191.24,21.89 193.21,21.89 193.7,22.38 232.33,22.38 235.26,25.31 264,25.31 264.66,24.65 278.27,24.65 279.3,25.67 305.96,25.67 309.34,29.05 309.34,43.04 306.4,45.98 306.4,52.27 304.58,54.09 304.58,56.08 307.19,58.69 307.6,58.69 307.69,58.59 307.82,58.59 307.87,58.54 v3(307.87,58.38)
  BOTTOM w0.102: v1(149.44,31.54) 149.44,31.64 149.75,31.95 UH4.BC28 ; R1604.1 309.47,58.29 L95.4 308.61,58.29 308.31,58.59 308.08,58.59 v3(307.87,58.38)
USB3RP1_D+: length 9.9
  BOTTOM w0.102: JUSB1.6 318.19,60.13 318.19,60.69 318.07,60.81 317.45,60.81 315.05,58.42 314.85,58.42 314.84,58.41 314.29,58.41 314.28,58.42 314.05,58.42 313.91,58.28 D78.2 D78.9 311.97,58.28 311.83,58.42 311.7,58.42 311.56,58.57 311.49,58.57 311.2,58.29 L95.3 310.42,58.29 R1604.2
USB3RP2: length 159
  IN3 w0.122: v1(149.23,33.43) 149.29,33.5 149.51,33.5 149.64,33.37 149.64,33.08 149.45,32.89 147.06,32.89 146.86,33.09 139.55,33.09 138.64,32.18 130.42,32.18 129.93,31.68 127.72,31.68 127.06,31.02 121.16,31.02 119.48,29.34 113.89,29.34 112.79,30.45 106.44,30.45 98.88,22.89 86.35,22.89 84.85,21.39 75.03,21.39 72.18,18.54 60.94,18.54 60.61,18.87 58.14,18.87 57.54,19.47 57.54,37.86 56.46,38.94 55.71,38.94 53.12,41.53 49.09,41.53 47.57,43.05 40.03,50.59 26.97,50.59 25.91,49.54 25.64,49.54 v3(25.44,49.74)
  BOTTOM w0.102: UH4.BE30 149.02,33.03 149.02,33.22 v1(149.23,33.43) ; v3(25.44,49.74) 25.23,49.53 25.08,49.53 24.76,49.84 L114.4 23.93,49.84 R1702.1
USB3RP2_D+: length 11.5
  BOTTOM w0.102: JUSB3.6 13.81,46.7 13.88,46.63 14.25,46.63 14.89,47.27 15.65,47.27 v1(17.45,49.06) 18.06,49.68 18.43,49.68 18.44,49.69 19.05,49.69 19.07,49.68 19.35,49.68 19.52,49.85 D89.7 D89.4 21.41,49.85 21.63,49.64 21.81,49.64 22.02,49.84 L114.3 22.97,49.84 R1702.2
USB3RP3: length 184.3
  IN1 w0.084: v1(147.92,33.43) 148.08,33.43 148.21,33.56 148.21,33.84 148.41,34.04 150.34,34.04 150.41,34.1 153.27,34.1 153.41,33.97 155.05,33.97 155.61,33.41 156.5,33.41 157.1,34.02 157.1,34.56 157.69,35.14 162.18,35.14 163.59,33.73 163.59,33.44 164.84,32.19 166.66,32.19 167.87,30.98 169.22,30.98 170.7,29.5 170.7,29 171.67,28.03 173.52,28.03 174,27.54 174.48,27.54 174.48,27.55 174.53,27.55 174.54,27.55 174.55,27.55
  IN1 w0.091: v3(254.96,26.84) 254.75,26.62 254.47,26.62 254.14,26.95 235.56,26.95 231.94,23.33 191.2,23.33 189.37,25.16 186.76,25.16 185.19,26.73 180.82,26.73 180.06,25.96 176.98,25.96 175.39,27.55 174.67,27.55 174.67,27.55 174.55,27.55
  IN3 w0.122: v1(255.33,89.76) 255.12,89.55 255.12,88.61 255.58,88.15 255.58,79.61 256.19,79 256.19,75.18 255.67,74.67 255.67,67.92 255.36,67.61 255.36,55.31 255.7,54.96 255.7,47.77 255.47,47.53 255.47,37.58 255.14,37.24 255.14,29.41 254.32,28.6 254.32,26.87 254.55,26.64 254.77,26.64 v3(254.96,26.84)
  BOTTOM w0.102: UH4.BF32 148.42,33.93 147.92,33.43 v1(147.92,33.43) ; v1(255.33,89.76) 255.13,89.96 255.13,90.1 255.43,90.4 L112.4 255.43,91.21 R1683.1
USB3RP3_D+: length 8.1
  BOTTOM w0.102: JESA1.13 252.85,97.24 252.73,97.12 252.73,96.67 253.37,96.03 254.86,96.03 255.07,95.82 255.07,95.6 255.22,95.45 D88.7 D88.4 255.22,93.51 255.1,93.38 255.1,93.13 255.43,92.8 L112.3 255.43,92.17 R1683.2
USB3T_N2: length 2
  BOTTOM w0.102: R1703.1 23.93,50.83 L115.1 24.73,50.83 25,51.1 25.32,51.1 C1243.1
USB3T_N3: length 3.4
  BOTTOM w0.102: C1234.1 261.36,91.6 261.43,91.67 261.43,92.15 261.13,92.45 261.07,92.45 261.05,92.44 260.52,92.44 260.51,92.45 260.29,92.45 259.92,92.08 L110.1 259.29,92.08 R1678.1
USB3T_P2: length 2.1
  BOTTOM w0.102: R1706.1 23.93,51.68 L115.4 24.68,51.68 25.05,51.32 25.36,51.32 C1242.1
USB3T_P3: length 3.4
  BOTTOM w0.102: R1681.1 259.29,92.93 L110.4 259.93,92.93 260.19,92.67 v1(260.79,92.67) 261.22,92.67 261.64,92.24 261.64,91.84 C1235.1
USB3TN1: length 200.1
  IN1 w0.084: 174.55,24.23 174.54,24.23 174.53,24.23 174.48,24.23 174.48,24.23 172.61,24.23 171.23,25.61 170.93,25.61 169.13,27.42 169.13,27.64 168.86,27.91 165.14,27.91 164.83,28.22 164.83,28.55 162.74,30.64 158.32,30.64 158.13,30.83 156.72,30.83 156.65,30.76 155.2,30.76 154.32,29.88 152.16,29.88 152.01,30.03 152.01,30.5 v3(151.98,30.54)
  IN1 w0.091: 174.55,24.23 174.71,24.23 176.21,22.73 177.4,22.73 178.43,21.69 185.68,21.69 186.94,20.44 189.37,20.44 190.26,19.54 198.43,19.54 199.69,18.28 202.67,18.28 203.29,18.9 240.86,18.9 242.76,20.8 256.97,20.8 257.86,21.69 262.06,21.69 262.54,22.17 267.72,22.17 268.05,22.5 287.23,22.5 287.98,23.25 304.63,23.25 310.12,28.74 310.12,43.36 307.17,46.31 307.17,52.63 306.13,53.67 306.13,55.64 305.93,55.83 305.19,55.83 v1(305.18,55.83)
  BOTTOM w0.102: v3(151.98,30.54) 152.31,30.87 UH4.AV26 ; v1(305.18,55.83) 305.35,55.66 305.68,55.66 C412.2
USB3TN1_C: length 4
  BOTTOM w0.102: C412.1 307.3,55.57 307.55,55.57 307.76,55.79 307.76,56.61 308.13,56.98 308.36,56.98 308.68,57.3 L96.1 309.47,57.3 R1606.1
USB3TN1_D-: length 9.8
  BOTTOM w0.102: JUSB1.8 318.19,55.11 318.09,55.01 317.66,55.01 316.9,55.77 315.85,55.77 314.97,56.66 314.97,56.68 314.52,57.13 314.04,57.13 313.89,57.28 D78.4 D78.7 311.96,57.28 311.79,57.11 311.63,57.11 311.5,56.98 311.35,56.98 311.03,57.3 L96.2 310.42,57.3 R1606.2
USB3TN2: length 160.7
  IN3 w0.102: v1(150.69,30.55) 150.49,30.75 149.88,30.75 149.72,30.92 148.52,30.92 148.45,30.84 148.39,30.84 148.38,30.83 148.36,30.83
  IN3 w0.122: v3(27.2,49.68) 27.4,49.49 27.4,49.1 27.69,48.81 40.19,48.81 48.53,40.47 52.68,40.47 55.9,37.24 55.9,16.63 56.58,15.95 64.99,15.95 66.51,17.47 72.62,17.47 75.47,20.33 85.29,20.33 86.79,21.83 99.32,21.83 106.88,29.39 112.3,29.39 114.04,27.65 116.25,27.65 116.55,27.95 119.64,27.95 121.63,29.94 127.68,29.94 128.15,30.41 147.76,30.41 148.18,30.83 148.36,30.83
  BOTTOM w0.102: C1243.2 26.59,50.99 26.76,51.17 27.06,51.17 27.54,50.68 27.54,50 27.23,49.68 v3(27.2,49.68) ; v1(150.69,30.55) 150.38,30.86 UH4.BB26
USB3TN2_D-: length 10.9
  BOTTOM w0.102: R1703.2 22.6,50.82 L115.2 22.17,50.83 21.9,51.1 21.69,51.1 21.44,50.85 D89.2 D89.9 19.48,50.85 19.35,50.99 19.06,50.99 19.04,50.97 18.5,50.97 18.49,50.99 v1(17.34,50.99) 16.71,50.99 16.07,51.62 14.92,51.62 14.15,52.38 13.89,52.38 13.81,52.31 JUSB3.8
USB3TN3: length 188.8
  IN1 w0.084: v1(153.29,31.44) 153.29,31.44 153.05,31.67 153.05,31.75 153.16,31.86 154.19,31.86 154.32,31.74 162.28,31.74 162.41,31.61 162.88,31.61 163.12,31.36 163.12,31.19 165.37,28.94 168.84,28.94 169.07,28.72 169.07,28.47 171.23,26.31 171.48,26.31 171.92,25.87 172.62,25.87 173.11,25.37 174.48,25.37 174.48,25.37 174.53,25.37 174.54,25.37 174.55,25.37
  IN1 w0.091: v1(261.71,23.57) 261.49,23.79 257.64,23.79 256.23,22.38 237.02,22.38 235.12,20.48 201.81,20.48 201.17,21.12 190.91,21.12 188.59,23.44 185.38,23.44 184.11,24.71 181.43,24.71 179.51,22.79 178.5,22.79 177.39,23.89 176.19,23.89 174.71,25.37 174.55,25.37
  IN3 w0.122: v3(261.14,89.67) 261.3,89.5 261.35,89.46 261.35,88.8 259.94,87.39 259.94,82.59 258.81,81.46 258.81,70.05 258.28,69.53 258.28,67.39 257.63,66.73 257.63,63.49 258.98,62.13 258.98,53.86 259.29,53.55 259.29,44.12 259.87,43.55 259.87,41.58 260.41,41.04 260.41,24.21 260.82,23.8 261.49,23.8 v1(261.71,23.57)
  BOTTOM w0.102: v1(153.29,31.44) 153,31.73 UH4.AU28 ; v3(261.14,89.67) 261.33,89.86 261.33,90.35 C1234.2
USB3TN3_D-: length 10.3
  BOTTOM w0.102: R1678.2 258.34,92.08 L110.2 257.45,92.08 257.35,92.18 256.79,92.18 256.56,92.41 v1(256.56,92.81) 256.56,93.1 256.41,93.25 256.41,93.38 256.22,93.56 D88.2 D88.9 256.22,95.46 256.36,95.59 256.36,95.76 256.63,96.03 258.74,96.03 259.26,96.56 259.26,97.09 259.12,97.24 JESA1.15
USB3TP1: length 200.1
  IN1 w0.084: 174.55,24.4 172.67,24.4 171.3,25.78 171,25.78 169.3,27.48 169.3,27.71 168.93,28.08 165.21,28.08 164.99,28.29 164.99,28.62 162.81,30.8 158.39,30.8 158.2,31 156.65,31 156.58,30.93 155.13,30.93 154.25,30.05 152.23,30.05 152.18,30.1 152.18,30.18 152.51,30.51 v1(152.71,30.51)
  IN1 w0.091: 174.55,24.4 174.78,24.4 176.28,22.9 177.47,22.9 178.5,21.87 185.75,21.87 187.01,20.61 189.44,20.61 190.33,19.72 198.51,19.72 199.76,18.46 202.6,18.46 203.22,19.08 240.79,19.08 242.69,20.98 256.9,20.98 257.78,21.86 261.99,21.86 262.47,22.34 267.65,22.34 267.98,22.67 287.16,22.67 287.91,23.42 304.56,23.42 309.95,28.81 309.95,43.29 307,46.24 307,52.55 305.95,53.6 305.95,55.57 305.86,55.66 305.63,55.66 305.55,55.59 305.55,55.23 305.4,55.08 305.3,55.08 v3(305.18,55.19)
  BOTTOM w0.102: v3(305.18,55.19) 305.18,55.24 305.39,55.45 305.62,55.45 C413.2 ; UH4.AU26 153,30.79 152.71,30.5 v1(152.71,30.51)
USB3TP1_C: length 3.9
  BOTTOM w0.102: R1603.1 309.47,56.45 L96.4 308.67,56.45 308.35,56.76 308.22,56.76 307.99,56.54 v1(307.99,56.04) 307.99,55.71 307.64,55.36 307.18,55.36 C413.1
USB3TP1_D+: length 9.8
  BOTTOM w0.102: R1603.2 310.42,56.45 L96.3 311.05,56.45 311.37,56.76 311.59,56.76 311.72,56.9 311.83,56.9 311.94,56.78 D78.6 D78.5 313.91,56.78 314.05,56.92 314.41,56.92 v1(314.6,56.73) 315.77,55.56 316.81,55.56 317.57,54.79 318.09,54.79 318.19,54.69 JUSB1.9
USB3TP2: length 160.7
  IN3 w0.102: 148.36,31.05 148.38,31.05 148.44,31.11 149.8,31.11 149.96,30.95 150.59,30.95 150.7,31.06 v3(150.7,31.38)
  IN3 w0.122: 148.36,31.05 148.09,31.05 147.67,30.63 128.06,30.63 127.59,30.16 121.54,30.16 119.55,28.17 116.46,28.17 116.16,27.86 114.13,27.86 112.39,29.6 106.79,29.6 99.23,22.04 86.7,22.04 85.2,20.54 75.38,20.54 72.53,17.69 66.43,17.69 64.9,16.17 56.67,16.17 56.11,16.72 56.11,37.33 52.77,40.68 48.62,40.68 40.28,49.02 27.78,49.02 27.62,49.19 27.62,49.46 v1(27.84,49.68)
  BOTTOM w0.102: v1(27.84,49.68) 27.76,49.77 27.76,50.77 27.15,51.38 26.84,51.38 C1242.2 ; v3(150.7,31.38) 151.02,31.06 UH4.AY26
USB3TP2_D+: length 10.8
  BOTTOM w0.102: JUSB3.9 13.81,52.77 13.98,52.6 14.24,52.6 15.01,51.84 16.16,51.84 16.8,51.2 17.06,51.2 17.08,51.21 17.61,51.21 17.62,51.2 v1(18.78,51.2) 19.35,51.2 19.5,51.35 D89.10 D89.1 21.55,51.35 21.59,51.32 21.74,51.32 22.1,51.68 L115.3 22.6,51.7 R1706.2
USB3TP3: length 188.8
  IN1 w0.084: v1(152.62,31.49) 152.78,31.49 152.89,31.6 152.89,31.82 153.09,32.03 154.26,32.03 154.39,31.9 162.35,31.9 162.48,31.77 162.95,31.77 163.29,31.43 163.29,31.26 165.44,29.11 168.91,29.11 169.23,28.79 169.23,28.54 171.3,26.48 171.54,26.48 171.99,26.03 172.69,26.03 173.18,25.54 174.55,25.54
  IN1 w0.091: 174.55,25.54 174.78,25.54 176.26,24.06 177.47,24.06 178.57,22.96 179.43,22.96 181.36,24.88 184.19,24.88 185.46,23.61 188.66,23.61 190.99,21.29 201.24,21.29 201.88,20.65 235.05,20.65 236.95,22.55 256.15,22.55 257.57,23.96 261.47,23.96 261.71,24.21 v1(261.71,24.2)
  IN3 w0.122: v1(261.71,24.2) 261.52,24.01 260.91,24.01 260.62,24.3 260.62,41.13 260.08,41.67 260.08,43.63 259.5,44.21 259.5,53.64 259.19,53.94 259.19,62.22 257.84,63.58 257.84,66.64 258.5,67.3 258.5,69.44 259.02,69.96 259.02,81.37 260.15,82.5 260.15,87.3 261.56,88.71 261.56,89.46 v3(261.77,89.67)
  BOTTOM w0.102: C1235.2 261.55,90.35 261.55,89.89 v3(261.77,89.67) ; v1(152.62,31.49) 152.31,31.8 UH4.AV28
USB3TP3_D+: length 10.3
  BOTTOM w0.102: R1681.2 258.34,92.93 L110.3 257.52,92.93 257.52,92.93 257.42,92.93 257.31,92.82 257.31,92.5 257.2,92.4 256.88,92.4 256.77,92.5 256.77,92.53 256.79,92.54 256.79,93.07 256.77,93.09 256.77,93.19 256.62,93.34 256.62,93.43 256.72,93.53 D88.1 D88.10 256.72,95.43 256.57,95.57 256.57,95.67 256.72,95.82 258.83,95.82 259.48,96.47 259.48,97.09 259.63,97.24 JESA1.16
USB30_SMI#: length 3.1
  TOP w0.102: v1(164.15,34.48) 164.15,34.25 RH357.1 163,33.09 v2(162.44,33.09)
  BOTTOM w0.102: UH4.N32 164.43,34.2 v1(164.15,34.48)
USB_MCARD1_DET#: length 134.1
  TOP w0.102: v2(241.77,27.66) 241.78,27.66 v1(242.49,27.66)
  IN2 w0.102: v1(165.65,20.64) 166.12,21.11 166.12,21.42 166.34,21.64 166.86,21.64 167.15,21.34 167.15,19.73 167.69,19.2 167.92,19.2 168.43,18.69 171.38,18.69 171.86,19.17 173.35,19.17 174.33,18.19 174.55,18.19
  IN2 w0.122: v1(242.49,27.66) 242.36,27.52 235.9,27.52 230.03,21.65 220.57,21.65 218.27,19.35 202.33,19.35 201.7,18.73 198.01,18.73 197.68,18.41 196.94,18.41 195.78,19.56 190.85,19.56 189.48,18.2 187.91,18.2 186.19,16.48 178.78,16.48 177.84,17.42 176.36,17.42 175.59,18.19 174.55,18.19
  IN3 w0.122: v1(246.1,64.51) 246.24,64.37 246.24,58.07 v1(245.47,57.3) 244.75,56.57 244.75,47.6 244.46,47.31 244.46,44.48 245.1,43.84 245.1,32.83 245.78,32.15 245.78,27.95 245.48,27.66 v1(242.49,27.66)
  BOTTOM w0.102: v1(245.47,57.3) 245.39,57.22 R701.1 R698.1 ; v1(165.65,20.64) 165.66,20.64 166.07,20.23 UH4.K4 ; JMINI2.40 247,65.41 v1(246.1,64.51)
USB_MCARD2_DET#: length 129.3
  TOP w0.102: v1(281.75,45.92) 281.05,45.21 v2(281.05,44.61) 281.05,44.01 281.04,44.01 R697.1 281.96,42.46 R694.2
  IN2 w0.102: 174.07,38.38 174.55,38.38
  IN2 w0.122: v1(281.75,45.92) 281.5,45.66 257.03,45.66 255,43.63 247.95,43.63 244.65,40.34 237.12,40.34 227.71,30.93 195.15,30.93 193.8,32.27 190.05,32.27 187.9,34.42 184.28,34.42 180.45,38.25 179.24,38.25 178.93,38.56 177.37,38.56 176.99,38.19 174.91,38.19 174.72,38.38 174.55,38.38 ; v1(173.61,38.83) 174.07,38.38
  BOTTOM w0.102: JMINI1.40 281,45.16 v1(281.75,45.92) ; v1(173.61,38.83) 173.26,38.83 172.32,37.89 UH4.A40
USB_MCARD3_DET#: length 6
  TOP w0.102: v2(258.81,22.5) v1(258.81,23.17) 258.86,23.12 C627.1 R712.2 262.01,23.12 262.06,23.17 R708.1
  BOTTOM w0.102: v1(258.81,23.17) 259.08,22.9 JMINI3.40
USB_OC0#: length 351.9
  TOP w0.102: v1(309.86,53.46) 310.1,53.22 v2(310.1,52.12) 310.1,48.33 v1(310.56,47.87) ; v1(16.87,47.55) 18.19,46.23 20.33,46.23 20.67,46.57 U48.5
  IN2 w0.102: 174.55,23.86 173.52,23.86 173.16,24.21 172.46,24.21 171.58,25.09 v1(171.11,25.09)
  IN2 w0.122: v1(310.56,47.87) 309.2,46.51 305.62,46.51 304.85,47.28 301.17,47.28 298.9,45.01 297.44,45.01 295.2,42.77 291.77,42.77 286.46,37.46 278.98,37.46 277.4,35.87 271.33,35.87 268.89,33.44 265.26,33.44 264.3,34.39 262.73,34.39 260.71,36.41 254.78,36.41 254.29,35.92 239,35.92 229.64,26.56 200.63,26.56 199.82,25.75 194.15,25.75 193.59,26.31 190.28,26.31 189.56,27.03 187.79,27.03 186.69,25.93 186.04,25.93 184.59,24.48 183.69,24.48 183.34,24.14 180.28,24.14 179.25,23.11 177.86,23.11 177.11,23.86 174.55,23.86
  IN4 w0.084: v1(16.87,47.55) 17.68,48.36 33.74,48.36 39.01,43.09 41.39,43.09 49.49,34.99 49.49,28.76 50.33,27.92 63.3,27.92 71.99,19.23 94,19.23 94.74,19.97 101.05,19.97 104.01,22.93 109.56,22.93 113.67,27.04 126.33,27.04 131.08,22.3 135.72,22.3 136.46,23.04 141.91,23.04 142.5,22.46 142.88,22.46 144.66,20.67 147.9,20.67 148.58,21.35 153.46,21.35 154.64,22.53 156.4,22.53 156.98,23.11 158.02,23.11 160.87,25.96 166.14,25.96 166.22,25.88 168.6,25.88 168.69,25.96 169.59,25.96 170.46,25.09 v1(171.11,25.09)
  BOTTOM w0.102: UH4.A14 170.6,25.09 v1(171.11,25.09) 171.58,25.09 172.2,24.47 172.81,24.47 173.67,23.62 174.86,23.62 RH350.1 ; U75.6 309.93,52.88 310.05,52.99 310.05,53.27 v1(309.86,53.46)
USB_OC1#: length 162.2
  IN2 w0.122: v1(166.04,27.51) 166.52,27.04 169.98,27.04 170.3,27.35 175.94,27.35 178.25,25.05 v1(179,25.05) 179.51,25.05 179.71,25.24 181.96,25.24 182.49,25.77 183.45,25.77 185.35,27.68 186.83,27.68 188.05,28.9 192.41,28.9 194.56,26.74 199.41,26.74 200.22,27.55 229.23,27.55 238.59,36.91 253.88,36.91 254.37,37.4 267.89,37.4 268.67,36.62 276.7,36.62 278.3,38.22 286.17,38.22 292.86,44.92 296.68,44.92 297.21,45.45 298.86,45.45 301.02,47.61 304.87,47.61 305.61,48.35 308.3,48.35 308.77,47.88 v1(309.75,47.88)
  BOTTOM w0.102: v1(166.04,27.51) 166.41,27.88 UH4.K20 ; U75.10 309.91,50.88 310.03,50.76 310.03,50.06 309.75,49.78 v2(309.75,48.73) v1(309.75,47.88) ; RH341.1 178.85,25.19 v1(179,25.05)
USB_OC2#: length 11.4
  BOTTOM w0.102: RH349.1 179.61,24.9 179.61,25.44 179.33,25.71 175.71,25.71 v2(175.16,26.27) 174.96,26.46 173.56,26.46 173.44,26.34 171.09,26.34 170.8,26.63 170.21,26.63 UH4.B17
USB_OC3#: length 6.1
  BOTTOM w0.102: RH343.1 174.85,25.46 v2(174.07,25.46) 173.53,25.46 172.92,26.07 170.89,26.07 170.65,26.31 170.38,26.31 170.07,26.01 UH4.C16
USB_OC4#: length 13.5
  TOP w0.102: v1(174.29,24.96) 174.82,24.43 RH345.1 175.58,23.96 v2(177.32,23.96)
  IN4 w0.102: v1(166.05,26.5) 166.05,26.34 166.31,26.08 168.52,26.08 168.6,26.17 169.72,26.17 170.39,25.5 171.36,25.5 172.39,24.47 173.79,24.47 v1(174.29,24.96)
  BOTTOM w0.102: UH4.L16 165.77,26.22 v1(166.05,26.5)
USB_OC5#: length 8.7
  BOTTOM w0.102: UH4.A16 170.66,25.87 172.56,25.87 v2(172.76,25.67) 173.91,24.52 174.52,24.52 174.72,24.72 177.86,24.72 RH346.1
USB_OC6#: length 7.6
  TOP w0.102: v1(168.63,24.46) 170.16,24.46 171.14,23.47 v2(172.79,23.47) 175.11,23.47 RH347.1
  BOTTOM w0.102: v1(168.63,24.46) 168.95,24.78 UH4.D14
USB_PWR_SHR_EN#: length 55.2
  TOP w0.102: U46.B2 260.59,71.11 260.75,71.27 260.75,71.59 v1(261.19,72.03) ; v1(259.09,68.7) 259.09,68.7 R776.2
  IN4 w0.084: v1(259.09,68.7) 260.22,69.83 275.86,69.83 276.46,69.24 298.25,69.24 299.87,67.62 v1(301.43,67.62)
  BOTTOM w0.102: v1(301.43,67.62) 303.26,67.62 303.95,66.93 v2(303.95,66.61) 303.95,65.43 R1626.2 ; v1(259.09,68.7) 259.31,68.7 261.63,71.02 261.63,71.6 v1(261.19,72.03)
USB_PWR_SHR_VBUS_EN: length 58.1
  TOP w0.102: v1(260.34,79.28) 260.59,79.52 U46.B50 ; R778.2 258.63,82.65 v1(259,82.28)
  IN1 w0.084: v1(260.34,79.28) 259,80.62 v1(259,82.28)
  IN4 w0.084: v1(260.34,79.28) 261.47,80.4 272.41,80.4 275.86,76.95 279.11,76.95 282.11,73.94 298.4,73.94 301.68,70.66 v1(301.68,70.04)
  BOTTOM w0.102: v1(301.68,70.04) 302.38,70.04 v2(304.06,68.36) 304.6,67.82 304.6,65.67 R784.1
USB_SIDE_EN#: length 383.4
  TOP w0.102: U48.4 20.67,44.13 20.88,44.35 23.44,44.35 26.35,47.25 v4(28.44,47.25) 33.6,47.25 34.68,46.17 40.91,46.17 v1(41.6,45.49) ; R768.2 268.89,82.2 v1(268.61,81.92) 267.84,81.15 U46.A33
  IN1 w0.084: v1(41.6,45.49) 41.6,51.27 44.95,54.63 44.95,71.09 43.68,72.36 43.68,79.2 42.59,80.29 42.59,84.49 v1(42.96,84.86)
  IN2 w0.122: v1(42.96,84.86) 45.05,86.95 65.15,86.95 66.38,88.19 72.69,88.19 74.36,86.51 77.21,86.51 84.06,93.35 87.2,93.35 88.58,94.73 92.18,94.73 94.09,96.63 94.09,99.09 100.25,105.26 103.52,105.26 105.9,102.87 135.01,102.87 136.53,101.35 137.38,101.35 137.84,100.89 147.67,100.89 147.91,101.13 155.43,101.13 156.27,100.29 156.27,99.81 156.22,99.76 156.22,98.66 158.85,96.02 164.33,96.02 165.68,94.67 165.68,82.35 166.98,81.05 166.98,78.75 166.48,78.24 166.48,68.92 167.39,68.01 167.39,67.17 167.83,66.73 167.83,54.96 173.55,49.24 180.49,49.24 186.96,42.76 192.91,42.76 199.11,36.57 211.41,36.57 213.08,38.24 217.76,38.24 221.26,41.74 221.26,42.35 231.27,52.35 232.73,52.35 234.6,54.22 236.07,54.22 243.06,61.22 250.66,61.22 253.23,63.79 254.24,63.79 255.26,64.81 255.26,68.96 256.38,70.07 257.02,70.07 258.31,71.37 258.31,75.28 258.48,75.45 258.48,78.74 260.02,80.28 266.65,80.28 268.29,81.92 v1(268.61,81.92)
USBP0+: length 172.6
  IN1 w0.102: v1(171.62,30.32) 171.82,30.11 171.82,29.96 172.12,29.66 172.49,29.66 172.51,29.69 174.09,29.69 174.54,30.13 175.94,30.13 176.36,30.55 180.43,30.55 181.97,29.01 186.74,29.01 188.71,27.05 189.63,27.05 190.91,25.76 192.74,25.76 193.53,24.98 231.82,24.98 235.76,28.91 237.59,28.91 238.15,29.47 245.99,29.47 247.21,30.69 251.98,30.69 252.76,29.92 261.68,29.92 262.92,31.16 301.55,31.16 302.21,31.82 302.21,61.42 302.48,61.69 v3(303.39,61.69)
  BOTTOM w0.102: v3(303.39,61.69) 303.63,61.92 303.74,61.92 303.88,61.79 U2.6 ; v1(171.62,30.32) 171.69,30.32 171.87,30.13 171.87,30.02 171.33,29.47 170.93,29.47 170.81,29.6 170.81,29.73 170.89,29.82 171.06,29.82 171.18,29.93 171.18,30.09 171.06,30.21 170.62,30.21 170.53,30.11 UH4.A24
USBP0-: length 172.6
  IN1 w0.102: v3(172.25,30.32) 172.15,30.32 172.04,30.21 172.04,30.05 172.21,29.88 172.4,29.88 172.42,29.91 174,29.91 174.45,30.35 175.85,30.35 176.27,30.77 180.52,30.77 182.06,29.23 186.84,29.23 188.8,27.26 189.72,27.26 191.01,25.98 192.83,25.98 193.62,25.19 231.73,25.19 235.67,29.13 237.5,29.13 238.06,29.69 245.9,29.69 247.12,30.91 252.08,30.91 252.85,30.13 261.59,30.13 262.83,31.38 301.46,31.38 302,31.91 302,61.51 302.39,61.91 302.97,61.91 303.18,62.11 303.29,62.11 303.39,62.21 v1(303.39,62.32)
  BOTTOM w0.102: U2.7 303.97,62.29 303.83,62.14 303.57,62.14 303.39,62.32 v1(303.39,62.32) ; UH4.C24 169.76,29.84 170.14,29.84 170.47,29.51 170.59,29.51 170.84,29.26 171.42,29.26 172.09,29.93 172.09,30.16 v3(172.25,30.32)
USBP0_D+: length 2.1
  BOTTOM w0.102: R736.1 308.06,61.54 L51.4 307.75,61.86 307.03,61.86 306.95,61.79 U2.3
USBP0_D-: length 2.3
  BOTTOM w0.102: U2.2 306.94,62.29 307.16,62.07 307.29,62.07 307.36,62.14 307.36,62.37 307.43,62.44 L51.1 308.03,62.46 R740.1
USBP0_R_D+: length 13.1
  IN4 w0.102: JUSB1.3 316.69,57.83 316.58,57.72 315.7,57.72 312,61.42 312,61.86 312.15,62.01 312.31,62.01 v3(312.54,61.78)
  BOTTOM w0.102: v3(312.54,61.78) 312.54,61.5 312.17,61.13 D72.2 311.62,61.89 311.52,61.99 311.12,61.99 310.91,61.78 310.34,61.78 310.22,61.66 309.78,61.66 L51.3 309.66,61.54 R736.2
