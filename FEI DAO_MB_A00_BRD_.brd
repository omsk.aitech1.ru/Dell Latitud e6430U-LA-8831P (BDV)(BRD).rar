# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Nets (continued)
+3.3V_ALW: C288.1 C292.1 C705.1 C706.1 C707.1 C708.1 C709.1 C710.1 C720.1 C725.1 C726.1 C727.1 C728.1 C729.1 C730.1 C731.1 C732.1 C739.1 C756.1 C777.1 C778.1 C779.1 C780.1 C781.1 C782.1 C783.1 C784.1 C785.2 C1248.1 C1249.1 C1308.1 JLID1.4 JTP1.11 PC1342.2 PJP19.2 PJP103.2 PJP301.2 PR6.1 PR12.2 PR112.2 PR204.1 PR400.1 PR1351.1 PU1302.5 Q18.1 Q18.2 Q18.5 Q18.6 Q34.1 Q34.2 Q34.5 Q34.6 Q38.1 Q38.2 Q38.5 Q38.6 Q40.1 Q40.2 Q40.5 Q40.6 Q42.1 Q42.2 Q42.5 Q42.6 Q49.1 Q49.2 Q49.5 Q49.6 Q58.1 Q58.2 Q58.5 Q58.6 Q61.5 Q61.6 Q61.7 Q61.8 R414.1 R418.1 R420.1 R589.2 R590.2 R591.2 R592.2 R713.1 R721.1 R728.1 R755.2 R759.1 R760.1 R761.1 R763.1 R764.2 R766.1 R768.1 R769.1 R773.2 R774.1 R776.1 R778.1 R785.2 R796.1 R798.1 R800.1 R805.1 R814.1 R817.2 R818.1 R820.1 R821.2 R822.1 R823.2 R824.1 R827.1 R828.1 R829.1 R847.1 R848.1 R849.1 R850.1 R854.1 R856.1 R858.1 R859.1 R860.1 R861.2 R864.1 R871.2 R872.2 R875.1 R932.1 R937.1 R1125.1 R1162.1 R1171.1 R1728.1 R1729.1 RH202.1 U7.5 U46.A17 U46.A43 U46.A54 U46.B5 U46.B30 U50.5 U51.A11 U51.A22 U51.A26 U51.A41 U51.A52 U51.A58 U51.B3 U51.B35 U58.5
+3.3V_ALW2: PC107.1 PR100.2 PR1341.1 PU100.8 R565.1 R907.1 R909.1 R918.1 RC74.1 UH5.5
+3.3V_ALW_PCH: C760.1 CC156.1 CH1.1 CH59.1 CH60.1 CH66.1 CH70.1 CH91.1 DH2.2 JXDP2.16 Q49.4 R692.2 R712.1 R835.2 R908.1 R928.1 R1622.2 RC18.1 RC124.1 RH41.1 RH53.2 RH66.1 RH80.1 RH81.2 RH94.2 RH97.2 RH98.1 RH101.1 RH103.1 RH139.1 RH140.1 RH142.1 RH144.1 RH152.2 RH170.2 RH177.2 RH201.1 RH287.1 RH288.1 RH298.2 RH299.2 RH300.1 RH301.1 RH302.1 RH303.1 RH304.1 RH341.2 RH343.2 RH345.2 RH346.2 RH347.2 RH348.2 RH349.2 RH350.2 RH354.1 RH357.2 UC2.5 UH4.AN24 UH4.N20 UH4.N22 UH4.P20 UH4.P22 UH4.P24 UH4.P32 UH4.T23 UH4.T24 UH4.V23 UH4.V24
+3.3V_ALW_PCH_JTAG: RH43.2 RH44.2 RH45.2 RH288.2
+3.3V_ALWP: PC110.1 PC120.2 PJP103.1 PL101.1 PR101.1 PU100.7
+3.3V_LAN: C475.1 C476.1 C478.1 C1167.1 C1168.1 C1169.1 C1178.1 JLOM1.9 JLOM1.12 Q34.4 R545.1 R546.1 R549.1 R553.1 R554.1 R563.1 RH305.1 RH306.1 U15.5 U31.5
+3.3V_LAN_OUT: C464.1 U31.4 U31.15 U31.19 U31.29
+3.3V_M: C745.1 C746.1 C768.1 CH54.1 JTAA1.1 JTAA1.3 Q58.4 R385.1 R388.1 R389.1 R395.1 R426.1 R563.2 R890.1 R891.1 R893.1 R916.1 R919.1 U52.8 U53.8 UH4.V1
+3.3V_M_CHG: Q60.1 R916.2
+3.3V_PCIE_FLASH: C621.1 C622.1 C623.1 C624.2 C625.2 C626.1 JMINI3.2 JMINI3.24 JMINI3.39 JMINI3.41 JMINI3.52 PJP3.1 Q42.4 R730.1
+3.3V_PCIE_WWAN: C610.1 C611.1 C612.1 C613.1 C614.1 C615.1 JMINI1.2 JMINI1.24 JMINI1.39 JMINI1.41 JMINI1.52 Q40.4 Q77.2 R719.2 R723.1 R1159.1 R1160.1
+3.3V_RTC_LDO: PD4.3 PR100.1
+3.3V_RUN: C243.1 C301.1 C661.1 C662.1 C763.2 C764.1 C776.2 C777.2 C779.2 C780.2 C781.2 C782.2 C783.2 C784.2 C787.1 C1246.1 C1247.1 C1279.1 C1304.1 C1305.1 C1316.1 C1331.1 CC140.1 CD17.1 CD18.1 CD43.1 CD44.1 CH43.1 CH51.1 CH72.1 CH75.1 CH76.1 CH102.1 DH3.2 JBT1.9 JCAP2.2 JDIMM1.199 JDIMM2.199 JFP1.6 JLVDS1.9 JSC1.7 L44.1 L45.1 LH1.1 PJP3.2 PJP60.1 PJP61.1 PR79.1 PR300.1 PR500.2 PR728.1 Q23.3 Q61.1 Q61.2 Q61.3 Q120.2 Q120.5 Q121.2 QH5.2 QH5.5 QH6.2 QH6.5 R159.1 R160.1 R402.1 R457.1 R458.1 R547.1 R694.1 R695.1 R699.2 R701.2 R711.1 R743.1 R745.1 R747.1 R771.2 R772.1 R777.1 R780.1 R782.1 R799.1 R838.1 R841.1 R888.1 R913.1 R929.1 R1081.1 R1082.1 R1087.1 R1099.1 R1118.1 R1161.1 R1165.1 R1168.2 R1169.1 R1197.1 R1594.1 R1595.1 R1708.1 R1710.1 R1743.1 RC19.1 RC141.2 RD13.2 RH28.1 RH30.1 RH35.1 RH52.2 RH87.1 RH137.1 RH158.1 RH163.1 RH164.2 RH165.1 RH166.1 RH171.2 RH173.2 RH178.1 RH181.2 RH203.1 RH215.1 RH256.1 RH263.2 RH266.2 RH267.2 RH268.1 RH269.1 RH316.1 RH317.1 RH324.1 RH325.1 RH326.1 RH327.1 RH328.1 RH329.1 RH330.1 RH331.1 RH332.1 RH351.1 RH352.1 RH355.1 RH363.1 RH364.1 RH365.2 U44.6 U44.16 UC1.5 UH3.5 UH4.AA16 UH4.AJ2 UH4.AK36 UH4.BH29 UH4.T34 UH4.V33 UH4.V34 UH4.W16
+3.3V_RUN_CARD: C572.1 C579.1 JSD1.9 R826.1 U38.15
+3.3V_RUN_CHG: Q69.1 R929.2
+3.3V_RUN_DVDD: C952.1 C953.1 C994.1 PJP60.2 U72.3 U72.9
+3.3V_RUN_TPM: C550.1 C551.1 C552.1 C553.1 PJP61.2 R656.2 R657.1 R658.1 R873.1 R1663.1 U37.10 U37.19 U37.24 U39.10 U39.19 U39.24
+3.3V_RUN_VCC_CLKF33: CH73.1 CH74.1 RH215.2 UH4.T38
+3.3V_SB3V: C44.1 C45.1 R873.2 U37.5 U39.5
+3.3V_TP: C755.1 C765.1 JTP1.5 R902.1 R903.1 R1161.2 R1162.2
+3.3V_WLAN: C603.1 C604.1 C605.1 C606.2 C607.2 C608.1 C609.1 JMINI2.2 JMINI2.24 JMINI2.39 JMINI2.41 JMINI2.52 Q38.4 Q124.2 Q124.5 Q126.2 R705.2 R715.1 R718.2 R1734.2
+3.3VDDH: C575.1 C576.1 C577.1 L45.2 U38.16
+5V_ALW: C302.1 C675.1 C676.1 C715.1 C763.1 C774.1 C775.1 C785.1 C1230.1 C1231.1 C1322.1 JLED1.1 JLVDS1.6 PC75.2 PC272.2 PC405.1 PC505.1 PC1316.1 PC1336.1 PC1337.1 PJP101.2 PR15.1 PR82.2 PR202.1 PR714.2 PR717.2 PR720.1 PR1334.2 PU7.18 PU200.12 PU400.7 PU500.7 PU1300.11 PU1304.8 Q55.5 Q55.6 Q55.7 Q55.8 Q75.3 Q79.3 QH4.1 R816.2 R1614.2 U2.5 U48.2 U48.3 U75.2 U75.3
+5V_ALW2: PC114.1 PR114.2 PU100.17
+5V_ALW_PCH: CH98.1 QH4.3 R1630.1 RH208.1 RH278.1
+5V_ALWP: PC111.1 PC121.1 PJP101.1 PL103.2 PR102.2 PU100.24
+5V_HDMI_DDC: D65.1 R1152.2 R1153.2 R1163.2
+5V_RUN: C219.1 C758.1 C761.1 C774.2 C775.2 C776.1 C786.1 C1278.1 C1317.1 D2.1 D65.2 JCAP2.1 JFAN1.4 JSC1.9 JSC1.10 JTP1.12 L77.2 PR713.1 PR732.1 Q55.1 Q55.2 Q55.3 QH7.2 R845.1 R846.1 R851.1 R852.1 R910.1 R923.1 R1095.1 R1163.1 RH213.1 U76.1 U77.1
+5V_RUN_CHG: Q67.1 R923.2
+5V_USB_CHG_PWR: C651.1 C654.1 JUSB1.1 U75.8
+5V_USB_PWR: C1244.1 C1245.1 JUSB3.1 U48.6 U48.7 U48.8
+DVDD_CORE: C954.1 U72.1
+V1.05S_VCCPP_B+: PC500.1 PC501.1 PC502.1 PC503.1 PJP500.2 PQ500.5
+V1.05SP_B+: PC400.1 PC401.1 PC402.1 PC403.1 PJP400.2 PQ400.5
+VCC_4022: C273.1 C1179.1 R388.2 R393.2 U9.1
+VCC_CORE: PC1119.1 PC1120.1 PC1121.1 PC1122.1 PC1123.1 PC1126.1 PC1127.1 PC1128.1 PC1129.1 PC1130.1 PC1131.1 PC1136.1 PC1168.1 PC1169.1 PC1170.1 PC1202.1 PC1203.1 PC1204.1 PC1205.1 PC1206.1 PC1207.1 PC1208.1 PC1209.1 PC1210.1 PC1211.1 PC1212.1 PC1213.1 PC1214.1 PC1215.1 PC1216.1 PC1217.1 PL702.1 RC66.1 RC120.1 U1.A26 U1.A29 U1.A31 U1.A34 U1.A35 U1.A38 U1.A39 U1.A42 U1.C26 U1.C27 U1.C32 U1.C34 U1.C37 U1.C39 U1.C42 U1.D27 U1.D32 U1.D34 U1.D37 U1.D39 U1.D42 U1.E26 U1.E28 U1.E32 U1.E34 U1.E37 U1.E38 U1.F25 U1.F26 U1.F28 U1.F32 U1.F34 U1.F37 U1.F38 U1.F42 U1.G42 U1.H25 U1.H26 U1.H28 U1.H29 U1.H32 U1.H34 U1.H35 U1.H37 U1.H38 U1.H40 U1.J25 U1.J26 U1.J28 U1.J29 U1.J32 U1.J34 U1.J35 U1.J37 U1.J38 U1.J40 U1.J42 U1.K26 U1.K27 U1.K29 U1.K32 U1.K34 U1.K35 U1.K37 U1.K39 U1.K42 U1.L25 U1.L28 U1.L33 U1.L36 U1.L40 U1.N26 U1.N30 U1.N34 U1.N38
+VCC_GFXCORE: PC1111.1 PC1112.1 PC1113.1 PC1114.1 PC1115.1 PC1116.1 PC1117.1 PC1118.1 PC1132.1 PC1133.1 PC1134.1 PC1135.1 PC1137.1 PC1138.1 PC1139.1 PC1140.1 PC1141.1 PC1142.1 PC1147.1 PC1148.1 PC1149.1 PC1150.1 PC1151.1 PC1157.1 PC1158.1 PL704.1 RC99.1 RC122.1 U1.AA46 U1.AB47 U1.AB50 U1.AB51 U1.AB52 U1.AB53 U1.AB55 U1.AB56 U1.AB58 U1.AB59 U1.AC61 U1.AD47 U1.AD48 U1.AD50 U1.AD51 U1.AD52 U1.AD53 U1.AD55 U1.AD56 U1.AD58 U1.AD59 U1.AE46 U1.N45 U1.P47 U1.P48 U1.P50 U1.P51 U1.P52 U1.P53 U1.P55 U1.P56 U1.P61 U1.T48 U1.T58 U1.T59 U1.T61 U1.U46 U1.V47 U1.V48 U1.V50 U1.V51 U1.V52 U1.V53 U1.V55 U1.V56 U1.V58 U1.V59 U1.W50 U1.W51 U1.W52 U1.W53 U1.W55 U1.W56 U1.W61 U1.Y48 U1.Y61
+VCC_PWR_SRC: PC732.1 PC733.1 PC734.1 PC736.1 PC753.1 PC754.1 PJP702.1 PL700.1 PQ704.5
+VCC_SA: CC168.1 CC169.1 CC170.1 CC171.1 CC172.1 CC183.1 CC260.1 CC261.1 CC262.1 CC263.1 CC264.1 PJP20.2 U1.L17 U1.L21 U1.N16 U1.N20 U1.N22 U1.P17 U1.P20 U1.R16 U1.R18 U1.R21 U1.U15 U1.V16 U1.V17 U1.V18 U1.V21 U1.W20
+VCCADAC: CH34.1 CH35.1 CH36.1 LH1.2 UH4.U48
+VCCDIFFCLKN: CH81.1 RH100.2 RH359.2 UH4.AF33 UH4.AF34 UH4.AG34
+VCCDSW3_3: CH55.1 RH201.2 RH202.2 UH4.T16
+VCCRTCEXT: CH78.1 UH4.N16
+VCCSA_BT: PR84.1 PU7.12
+VCCSA_BT_1: PC76.1 PR84.2
+VCCSA_EN: PR83.1 PU7.13
+VCCSA_P: PC80.1 PC81.2 PC82.2 PC83.1 PC84.2 PC85.2 PJP20.1 PL15.2 PR87.1
+VCCSA_PHASE: PC76.2 PC77.1 PL15.1 PU7.7 PU7.8 PU7.9 PU7.10 PU7.11
+VCCSA_PWR_SRC: PC86.2 PC87.1 PC88.1 PC89.1 PJP19.1 PU7.22 PU7.23 PU7.24
+VCCSA_PWRGD: PR79.2 PR80.2 PU7.16
+VCCSST: CH84.1 UH4.V16
+VDDA_AVDD: C955.1 C956.1 C957.1 L77.1 R1078.1 R1083.1 U72.27 U72.38
+VDDA_PVDD: C958.1 C959.1 C960.1 C961.1 R1095.2 U72.39 U72.45
+VDDH_SD: C561.1 C562.1 L47.2 U38.9
GND: C36.2 C37.2 C38.2 C39.2 C44.2 C45.2 C219.2 C243.2 C246.2 C273.2 C274.2 C278.2 C282.2 C288.2 C289.2 C292.2 C293.2 C296.2 C298.2 C299.2 C300.2 C301.2 C302.2 C337.2 C338.2 C462.2 C463.2 C464.2 C466.2 C467.2 C468.2 C469.2 C470.1 C471.1 C475.2 C476.2 C477.2 C478.2 C550.2 C551.2 C552.2 C553.2 C554.2 C559.2 C560.2 C561.2 C562.2 C563.2 C564.2 C565.2 C566.2 C572.2 C573.2 C574.2 C575.2 C576.2 C577.2 C578.2 C579.2 C593.2 C594.2 C595.2 C600.2 C601.2 C602.2 C603.2 C604.2 C605.2 C606.1 C607.1 C608.2 C609.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C619.2 C620.2 C621.2 C622.2 C623.2 C624.1 C625.1 C626.2 C627.2 C628.2 C629.2 C630.2 C631.2 C632.2 C644.2 C650.2 C651.2 C654.2 C661.2 C662.2 C675.2 C676.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C712.2 C713.2 C714.2 C715.2 C716.2 C720.2 C721.2 C722.2 C723.2 C725.2 C726.2 C727.2 C728.2 C729.2 C730.2 C731.2 C732.2 C735.2 C737.2 C739.2 C740.2 C741.2 C742.2 C743.2 C744.2 C745.2 C746.2 C747.2 C749.2 C750.2 C751.2 C752.2 C755.2 C756.2 C758.2 C759.2 C760.2 C761.2 C762.2 C764.2 C765.2 C766.2 C767.2 C768.2 C769.2 C770.2 C771.2 C772.2 C773.2 C778.2 C786.2 C787.2 C952.2 C953.2 C954.2 C958.2 C959.2 C960.2 C961.2 C967.2 C977.2 C978.2 C981.2 C982.2 C983.2 C994.2 C1104.1 C1167.2 C1168.2 C1169.2 C1177.2 C1178.2 C1179.2 C1201.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.2 C1209.2 C1210.2 C1216.2 C1217.2 C1218.2 C1219.2 C1220.2 C1221.2 C1222.2 C1223.2 C1224.1 C1225.1 C1230.2 C1231.2 C1232.2 C1233.2 C1244.2 C1245.2 C1246.2 C1247.2 C1248.2 C1249.2 C1278.2 C1279.2 C1304.2 C1305.2 C1306.2 C1307.2 C1308.2 C1311.2 C1316.2 C1317.2 C1318.2 C1319.2 C1320.2 C1321.2 C1322.2 C1323.2 C1324.2 C1325.2 C1330.2 C1331.2 C1332.2 C1333.2 CC65.2 CC135.2 CC136.2 CC140.2 CC141.2 CC156.2 CC161.2 CC162.2 CC163.2 CC164.2 CC165.2 CC166.2 CC167.2 CC168.2 CC169.2 CC170.2 CC171.2 CC172.2 CC174.2 CC175.2 CC176.2 CC177.2 CC180.2 CC181.2 CC183.2 CC250.2 CC251.2 CC252.2 CC253.2 CC254.2 CC255.2 CC256.2 CC257.2 CC258.2 CC259.2 CC260.2 CC261.2 CC262.2 CC263.2 CC264.2 CC573.2 CC574.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CE3.2 CE4.2 CE757.2 CH1.2 CH2.2 CH3.2 CH4.1 CH5.1 CH6.2 CH18.1 CH19.1 CH30.2 CH31.2 CH32.2 CH33.2 CH34.2 CH35.2 CH36.2 CH43.2 CH44.2 CH45.2 CH46.2 CH47.2 CH48.2 CH49.2 CH50.2 CH51.2 CH52.2 CH53.2 CH54.2 CH55.2 CH56.2 CH59.2 CH60.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH69.2 CH70.2 CH71.2 CH72.2 CH73.2 CH74.2 CH75.2 CH76.2 CH77.2 CH78.2 CH79.2 CH81.2 CH82.2 CH84.2 CH85.2 CH86.2 CH87.2 CH88.2 CH89.2 CH90.2 CH91.2 CH92.2 CH93.2 CH94.2 CH95.2 CH96.2 CH97.2 CH98.2 CH101.2 CH102.2 CH103.2 CH104.2 CH105.2 CH106.2 CH107.2 CH109.2 CH110.2 CH111.2 CH112.2 CMOS1.1 D2.2 D9.1 D23.1 D37.1 D72.1 D73.1 D77.1 D78.3 D83.1 D87.1 D88.3 D89.3 D90.1 DE1.1 DE2.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H16.1(TP-1) H17.1(TP-1) H19.1(TP-1) H20.1(TP-1) H21.1(TP-1) H22.1(TP-1) H23.1(TP-1) H24.1(TP-1) H26.1(TP-1) JBT1.1 JBT1.10 JBT1.13 JBT1.14 JCAP2.3 JCAP2.4 JCAP2.9 JCAP2.10 JCRT1.5 JCRT1.6 JCRT1.7 JCRT1.8 JCRT1.10 JCRT1.16 JCRT1.17 JDEG2.10 JDEG2.11 JDEG2.12 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.205 JDIMM2.206 JESA1.4 JESA1.5 JESA1.8 JESA1.11 JESA1.14 JESA1.17 JESA1.18 JESA1.19 JESA1.20 JFAN1.1 JFAN1.5 JFAN1.6 JFP1.1 JFP1.5 JFP1.7 JFP1.8 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JHP1.7 JLED1.2 JLED1.9 JLED1.10 JLID1.1 JLID1.5 JLID1.6 JLOM1.14 JLOM1.15 JLVDS1.4 JLVDS1.13 JLVDS1.16 JLVDS1.19 JLVDS1.22 JLVDS1.29 JLVDS1.33 JLVDS1.39 JLVDS1.41 JLVDS1.42 JLVDS1.43 JLVDS1.44 JLVDS1.45 JLVDS1.46 JLVDS2.3 JLVDS2.6 JLVDS2.9 JLVDS2.12 JLVDS2.13 JLVDS2.14 JMINI1.4 JMINI1.9 JMINI1.15 JMINI1.18 JMINI1.21 JMINI1.26 JMINI1.27 JMINI1.29 JMINI1.34 JMINI1.35 JMINI1.43 JMINI1.50 JMINI1.53 JMINI1.54 JMINI2.4 JMINI2.9 JMINI2.15 JMINI2.18 JMINI2.21 JMINI2.26 JMINI2.27 JMINI2.29 JMINI2.34 JMINI2.35 JMINI2.43 JMINI2.50 JMINI2.53 JMINI2.54 JMINI3.4 JMINI3.9 JMINI3.15 JMINI3.18 JMINI3.21 JMINI3.26 JMINI3.27 JMINI3.29 JMINI3.34 JMINI3.35 JMINI3.43 JMINI3.50 JMINI3.53 JMINI3.54 JRTC1.2 JRTC1.3 JRTC1.4 JSC1.3 JSC1.4 JSC1.6 JSC1.8 JSC1.11 JSC1.12 JSD1.6 JSD1.10 JSD1.16 JSD1.17 JSIM1.5 JSIM1.9 JSIM1.10 JSIM1.11 JSIM1.12 JSIM1.13 JSNIF1.3 JSNIF1.4 JSNIF1.5 JSNIF1.6 JSPK1.5 JSPK1.6 JTAA1.2 JTAA1.6 JTAA1.10 JTAA1.12 JTAG1.2 JTP1.1 JTP1.2 JTP1.8 JTP1.14 JTP1.15 JTP1.17 JTP1.18 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB3.4 JUSB3.7 JUSB3.10 JUSB3.11 JUSB3.12 JUSB3.13 JXDP1.3 JXDP1.6 JXDP1.9 JXDP1.19 JXDP1.25 JXDP1.27 JXDP1.28 JXDP2.3 JXDP2.6 JXDP2.9 JXDP2.19 JXDP2.25 JXDP2.27 JXDP2.28 ME1.1 PBATT1.5 PBATT1.7 PBATT1.8 PBATT1.9 PC3.2 PC4.2 PC5.2 PC8.2 PC11.2 PC12.2 PC13.2 PC14.2 PC15.2 PC16.2 PC17.2 PC18.2 PC74.2 PC75.1 PC78.2 PC80.2 PC81.1 PC82.1 PC83.2 PC84.1 PC85.1 PC86.1 PC87.2 PC88.2 PC89.2 PC92.1 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC253.2 PC255.2 PC263.2 PC265.2 PC272.1 PC274.2 PC276.2 PC277.2 PC279.2 PC280.2 PC281.2 PC282.2 PC300.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.2 PC400.2 PC401.2 PC402.2 PC403.2 PC405.2 PC406.2 PC407.2 PC408.2 PC500.2 PC501.2 PC502.2 PC503.2 PC505.2 PC506.2 PC508.2 PC511.2 PC701.1 PC703.2 PC706.1 PC711.2 PC714.2 PC715.2 PC719.2 PC729.2 PC732.2 PC733.2 PC734.2 PC736.2 PC737.2 PC741.2 PC743.2 PC746.2 PC747.2 PC748.2 PC749.2 PC752.2 PC753.2 PC754.2 PC1111.2 PC1112.2 PC1113.2 PC1114.2 PC1115.2 PC1116.2 PC1117.2 PC1118.2 PC1119.2 PC1120.2 PC1121.2 PC1122.2 PC1123.2 PC1124.2 PC1125.2 PC1126.2 PC1127.2 PC1128.2 PC1129.2 PC1130.2 PC1131.2 PC1132.2 PC1133.2 PC1134.2 PC1135.2 PC1136.2 PC1137.2 PC1138.2 PC1139.2 PC1140.2 PC1141.2 PC1142.2 PC1147.2 PC1148.2 PC1149.2 PC1150.2 PC1151.2 PC1154.2 PC1155.2 PC1156.2 PC1157.2 PC1158.2 PC1159.2 PC1160.2 PC1161.2 PC1162.2 PC1165.2 PC1166.2 PC1167.2 PC1168.2 PC1169.2 PC1170.2 PC1172.2 PC1175.2 PC1176.2 PC1177.2 PC1178.2 PC1179.2 PC1180.2 PC1181.2 PC1182.2 PC1183.2 PC1184.2 PC1185.2 PC1186.2 PC1188.2 PC1189.2 PC1190.2 PC1191.2 PC1192.2 PC1193.2 PC1194.2 PC1195.2 PC1196.2 PC1197.2 PC1198.2 PC1199.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1205.2 PC1206.2 PC1207.2 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1215.2 PC1216.2 PC1217.2 PC1301.2 PC1302.2 PC1306.2 PC1311.2 PC1312.2 PC1313.2 PC1314.2 PC1315.2 PC1317.2 PC1329.2 PC1330.2 PC1331.2 PC1332.2 PC1336.2 PC1337.2 PC1338.2 PC1339.2 PC1340.2 PC1341.2 PC1342.1 PD5.1 PD6.1 PD7.1 PJP21.1 PJP62.2 PJP801.2 PL6.2 PQ3.3 PQ6.3 PQ102.1 PQ102.2 PQ102.3 PQ103.1 PQ103.2 PQ103.3 PQ104.1 PQ104.4 PQ105.3 PQ210.1 PQ210.2 PQ210.3 PQ405.1 PQ405.2 PQ405.3 PQ501.1 PQ501.2 PQ501.3 PQ706.1 PQ706.2 PQ706.3 PQ710.1 PQ710.2 PQ710.3 PQ711.1 PQ711.2 PQ711.3 PQ1305.1 PQ1305.2 PQ1305.3 PQ1306.1 PQ1306.4 PQ1307.1 PQ1307.4 PQ1311.1 PQ1311.4 PR16.1 PR22.2 PR23.1 PR24.2 PR85.2 PR86.1 PR103.1 PR104.2 PR105.1 PR106.2 PR111.2 PR203.2 PR238.1 PR304.2 PR305.2 PR402.1 PR405.2 PR407.1 PR410.2 PR501.1 PR505.2 PR514.2 PR705.2 PR712.1 PR725.1 PR742.2 PR751.2 PR760.2 PR1316.2 PR1332.1 PR1346.2 PR1347.2 PR1348.2 PR1350.2 PU7.19 PU7.20 PU7.21 PU7.25 PU100.15 PU200.1 PU200.3 PU200.14 PU200.21 PU300.11 PU400.11 PU500.11 PU700.41 PU1300.19 PU1302.3 PU1304.4 PWRSW1.2 Q19.1 Q19.4 Q20.3 Q22.3 Q26.3 Q35.1 Q35.4 Q39.1 Q39.4 Q41.1 Q41.4 Q43.1 Q43.4 Q45.3 Q47.3 Q48.3 Q50.3 Q51.1 Q51.4 Q52.1 Q52.4 Q53.3 Q56.3 Q57.1 Q57.4 Q60.3 Q62.3 Q64.3 Q66.3 Q67.3 Q68.3 Q69.3 Q70.3 Q71.3 Q72.3 Q73.3 Q78.4 Q127.3 QC1.3 QC4.1 QC4.4 QH8.3 R3.1 R403.2 R404.2 R406.2 R557.2 R561.2 R562.2 R659.2 R660.2 R677.1 R715.2 R716.2 R726.2 R730.2 R733.2 R749.1 R751.1 R752.1 R767.1 R775.1 R786.1 R789.1 R790.1 R791.1 R793.2 R803.2 R804.2 R812.1 R826.2 R836.2 R843.1 R869.2 R876.1 R878.1 R879.1 R880.1 R882.1 R883.1 R889.1 R892.1 R908.2 R910.2 R913.2 R919.2 R921.2 R931.2 R938.2 R941.2 R942.2 R950.2 R1128.2 R1137.2 R1138.2 R1141.2 R1142.2 R1610.2 R1611.2 R1613.1 R1617.2 R1618.2 R1619.2 R1620.2 R1621.2 R1625.2 R1627.2 R1628.2 R1629.2 R1632.2 R1638.2 R1641.2 R1642.2 R1643.2 R1658.2 R1659.2 R1660.2 R1661.2 R1669.2 R1677.2 R1709.2 RC16.2 RC40.1 RC41.1 RC42.2 RC43.2 RC45.2 RC50.2 RC51.2 RC52.2 RC53.2 RC54.2 RC56.2 RC70.2 RC73.2 RC78.2 RC81.2 RC96.1 RC97.1 RC100.2 RC121.1 RC123.1 RC130.2 RC133.2 RC143.2 RD8.1 RD9.1 RD14.2 RH31.1 RH46.2 RH47.2 RH48.2 RH49.2 RH59.2 RH74.2 RH75.2 RH76.2 RH77.2 RH78.2 RH79.2 RH91.2 RH112.1 RH126.2 RH131.1 RH132.1 RH133.1 RH134.1 RH145.1 RH151.2 RH172.2 RH174.2 RH183.2 RH260.2 RH270.1 RH271.2 RH273.2 RH278.2 RH333.2 RH342.2 RH344.1 SW1.1 SW1.3 T108.1(TP-1) T109.1(TP-1) U1.A5 U1.A9 U1.A13 U1.A17 U1.A21 U1.A25 U1.A28 U1.A33 U1.A37 U1.A40 U1.A45 U1.A49 U1.A53 U1.A57 U1.AA1 U1.AA8 U1.AA13 U1.AA50 U1.AA51 U1.AA52 U1.AA53 U1.AA55 U1.AA56 U1.AB16 U1.AB18 U1.AB21 U1.AB48 U1.AB61 U1.AC6 U1.AC10 U1.AC14 U1.AC46 U1.AD4 U1.AD17 U1.AD20 U1.AD61 U1.AE8 U1.AE13 U1.AF1 U1.AF17 U1.AF21 U1.AF47 U1.AF48 U1.AF50 U1.AF51 U1.AF52 U1.AF53 U1.AF55 U1.AF56 U1.AF58 U1.AF59 U1.AG7 U1.AG10 U1.AG14 U1.AG18 U1.AG47 U1.AG52 U1.AG61 U1.AH4 U1.AH58 U1.AJ7 U1.AJ13 U1.AJ16 U1.AJ20 U1.AJ22 U1.AJ26 U1.AJ30 U1.AJ34 U1.AJ38 U1.AJ42 U1.AJ45 U1.AJ48 U1.AK1 U1.AK52 U1.AL10 U1.AL13 U1.AL17 U1.AL21 U1.AL25 U1.AL28 U1.AL33 U1.AL36 U1.AL40 U1.AL43 U1.AL47 U1.AL61 U1.AM4 U1.AM13 U1.AM20 U1.AM22 U1.AM26 U1.AM30 U1.AM34 U1.AM38 U1.AM42 U1.AM45 U1.AM48 U1.AM58 U1.AN1 U1.AN21 U1.AN25 U1.AN28 U1.AN33 U1.AN36 U1.AN40 U1.AN43 U1.AN47 U1.AN50 U1.AN54 U1.AP7 U1.AP10 U1.AP51 U1.AP55 U1.AR7 U1.AR13 U1.AR17 U1.AR21 U1.AR41 U1.AR48 U1.AR61 U1.AT4 U1.AT14 U1.AT19 U1.AT36 U1.AT45 U1.AT52 U1.AT58 U1.AU1 U1.AU7 U1.AU11 U1.AU28 U1.AU32 U1.AU51 U1.AV17 U1.AV21 U1.AV22 U1.AV34 U1.AV40 U1.AV48 U1.AV55 U1.AW7 U1.AW13 U1.AW43 U1.AW61 U1.AY4 U1.AY9 U1.AY14 U1.AY19 U1.AY30 U1.AY36 U1.AY41 U1.AY45 U1.AY49 U1.AY55 U1.AY58 U1.BA1 U1.BA11 U1.BA17 U1.BA21 U1.BA26 U1.BA32 U1.BA48 U1.BA51 U1.BB53 U1.BC5 U1.BC13 U1.BC57 U1.BC61 U1.BD3 U1.BD8 U1.BD12 U1.BD16 U1.BD19 U1.BD23 U1.BD27 U1.BD32 U1.BD36 U1.BD40 U1.BD44 U1.BD48 U1.BD52 U1.BD56 U1.BD59 U1.BE4 U1.BE5 U1.BE58 U1.BG5 U1.BG9 U1.BG13 U1.BG17 U1.BG21 U1.BG24 U1.BG28 U1.BG37 U1.BG41 U1.BG45 U1.BG49 U1.BG53 U1.BG57 U1.C3 U1.C29 U1.C35 U1.C40 U1.C58 U1.D4 U1.D6 U1.D10 U1.D14 U1.D18 U1.D22 U1.D26 U1.D29 U1.D35 U1.D40 U1.D43 U1.D46 U1.D50 U1.D54 U1.D58 U1.D59 U1.E1 U1.E3 U1.E25 U1.E29 U1.E35 U1.E40 U1.E61 U1.F13 U1.F15 U1.F19 U1.F29 U1.F35 U1.F40 U1.F55 U1.G6 U1.G51 U1.G61 U1.H4 U1.H10 U1.H14 U1.H17 U1.H21 U1.H53 U1.H58 U1.J1 U1.J49 U1.J55 U1.K8 U1.K11 U1.K21 U1.K51 U1.L16 U1.L20 U1.L22 U1.L26 U1.L30 U1.L34 U1.L38 U1.L43 U1.L48 U1.L61 U1.M4 U1.M6 U1.M11 U1.M15 U1.M58 U1.N1 U1.N17 U1.N21 U1.N25 U1.N28 U1.N33 U1.N36 U1.N40 U1.N43 U1.N47 U1.N48 U1.N51 U1.N52 U1.N56 U1.N61 U1.P9 U1.P14 U1.P16 U1.P18 U1.P21 U1.P58 U1.P59 U1.R4 U1.R17 U1.R20 U1.R46 U1.T1 U1.T47 U1.T50 U1.T51 U1.T52 U1.T53 U1.T55 U1.T56 U1.U8 U1.U13 U1.V20 U1.V61 U1.W8 U1.W13 U1.W15 U1.W18 U1.W21 U1.W46 U1.Y4 U1.Y47 U1.Y58 U1.Y59 U2.9 U4.2 U7.3 U9.2 U9.3 U9.6 U9.33 U15.3 U31.49 U37.1 U37.2 U37.4 U37.8 U37.11 U37.18 U37.25 U38.33 U39.1 U39.2 U39.4 U39.8 U39.11 U39.18 U39.25 U40.2 U44.3 U44.13 U44.17 U44.21 U46.B27 U46.C1 U48.1 U50.3 U51.B11 U51.B54 U51.B60 U51.B66 U51.C1 U52.4 U53.4 U58.3 U72.7 U72.42 U72.49 U73.3 U74.3 U75.1 U75.11 U76.2 U77.2 UC1.3 UC2.3 UH3.3 UH4.AA2 UH4.AA3 UH4.AA17 UH4.AA33 UH4.AA34 UH4.AB4 UH4.AB5 UH4.AB7 UH4.AB11 UH4.AB14 UH4.AB39 UH4.AB43 UH4.AC2 UH4.AC19 UH4.AC21 UH4.AC24 UH4.AC33 UH4.AC34 UH4.AC48 UH4.AD4 UH4.AD8 UH4.AD10 UH4.AD11 UH4.AD12 UH4.AD13 UH4.AD14 UH4.AD16 UH4.AD19 UH4.AD24 UH4.AD26 UH4.AD27 UH4.AD33 UH4.AD34 UH4.AD36 UH4.AD37 UH4.AD38 UH4.AD39 UH4.AD40 UH4.AD42 UH4.AD43 UH4.AD45 UH4.AD46 UH4.AD47 UH4.AE2 UH4.AE3 UH4.AE47 UH4.AE48 UH4.AF4 UH4.AF5 UH4.AF7 UH4.AF8 UH4.AF10 UH4.AF12 UH4.AF16 UH4.AF19 UH4.AF24 UH4.AF26 UH4.AF27 UH4.AF29 UH4.AF31 UH4.AF38 UH4.AF42 UH4.AF46 UH4.AG2 UH4.AG19 UH4.AG31 UH4.AG48 UH4.AH3 UH4.AH7 UH4.AH8 UH4.AH10 UH4.AH11 UH4.AH36 UH4.AH39 UH4.AH40 UH4.AH42 UH4.AH46 UH4.AJ3 UH4.AJ19 UH4.AJ21 UH4.AJ24 UH4.AJ33 UH4.AJ34 UH4.AK3 UH4.AK4 UH4.AK8 UH4.AK10 UH4.AK11 UH4.AK12 UH4.AK37 UH4.AK38 UH4.AK42 UH4.AK46 UH4.AL2 UH4.AL16 UH4.AL17 UH4.AL19 UH4.AL21 UH4.AL23 UH4.AL26 UH4.AL27 UH4.AL31 UH4.AL33 UH4.AL34 UH4.AL48 UH4.AM7 UH4.AM11 UH4.AM14 UH4.AM36 UH4.AM39 UH4.AM43 UH4.AM45 UH4.AM46 UH4.AN2 UH4.AN3 UH4.AN29 UH4.AN31 UH4.AP1 UH4.AP3 UH4.AP4 UH4.AP8 UH4.AP12 UH4.AP13 UH4.AP19 UH4.AP28 UH4.AP30 UH4.AP32 UH4.AP38 UH4.AP42 UH4.AP46 UH4.AR2 UH4.AR48 UH4.AT7 UH4.AT11 UH4.AT13 UH4.AT18 UH4.AT22 UH4.AT26 UH4.AT28 UH4.AT30 UH4.AT32 UH4.AT34 UH4.AT39 UH4.AT42 UH4.AT46 UH4.AU24 UH4.AU30 UH4.AV4 UH4.AV8 UH4.AV11 UH4.AV16 UH4.AV20 UH4.AV24 UH4.AV30 UH4.AV38 UH4.AV43 UH4.AW2 UH4.AW14 UH4.AW18 UH4.AW22 UH4.AW26 UH4.AW28 UH4.AW32 UH4.AW34 UH4.AW36 UH4.AW40 UH4.AW48 UH4.AY4 UH4.AY8 UH4.AY12 UH4.AY22 UH4.AY28 UH4.AY42 UH4.AY46 UH4.B7 UH4.B11 UH4.B15 UH4.B19 UH4.B23 UH4.B27 UH4.B31 UH4.B35 UH4.B39 UH4.B43 UH4.BB4 UH4.BB12 UH4.BB16 UH4.BB20 UH4.BB22 UH4.BB24 UH4.BB28 UH4.BB30 UH4.BB38 UH4.BB46 UH4.BC2 UH4.BC14 UH4.BC16 UH4.BC18 UH4.BC22 UH4.BC26 UH4.BC32 UH4.BC34 UH4.BC36 UH4.BC40 UH4.BC42 UH4.BC48 UH4.BD3 UH4.BD5 UH4.BD46 UH4.BE10 UH4.BE16 UH4.BE22 UH4.BE26 UH4.BE40 UH4.BF8 UH4.BF10 UH4.BF12 UH4.BF16 UH4.BF20 UH4.BF22 UH4.BF24 UH4.BF26 UH4.BF28 UH4.BF30 UH4.BF38 UH4.BF40 UH4.BG8 UH4.BG17 UH4.BG21 UH4.BG22 UH4.BG24 UH4.BG28 UH4.BG29 UH4.BG33 UH4.BG41 UH4.BG44 UH4.BH7 UH4.BH11 UH4.BH15 UH4.BH17 UH4.BH19 UH4.BH27 UH4.BH31 UH4.BH33 UH4.BH35 UH4.BH39 UH4.BH43 UH4.BJ28 UH4.C22 UH4.D3 UH4.D8 UH4.D12 UH4.D16 UH4.D18 UH4.D22 UH4.D24 UH4.D26 UH4.D30 UH4.D32 UH4.D34 UH4.D38 UH4.D42 UH4.E18 UH4.E26 UH4.F3 UH4.F45 UH4.G14 UH4.G18 UH4.G20 UH4.G26 UH4.G28 UH4.G36 UH4.G48 UH4.H5 UH4.H10 UH4.H12 UH4.H16 UH4.H18 UH4.H22 UH4.H24 UH4.H26 UH4.H30 UH4.H32 UH4.H34 UH4.H46 UH4.K7 UH4.K18 UH4.K26 UH4.K39 UH4.K46 UH4.L2 UH4.L18 UH4.L20 UH4.L26 UH4.L28 UH4.L36 UH4.L48 UH4.M4 UH4.M8 UH4.M12 UH4.M14 UH4.M18 UH4.M22 UH4.M24 UH4.M30 UH4.M32 UH4.M34 UH4.M38 UH4.M42 UH4.M46 UH4.N18 UH4.N24 UH4.N47 UH4.P7 UH4.P11 UH4.P16 UH4.P18 UH4.P30 UH4.P40 UH4.P43 UH4.P47 UH4.R2 UH4.R48 UH4.T4 UH4.T8 UH4.T12 UH4.T31 UH4.T33 UH4.T36 UH4.T37 UH4.T42 UH4.T46 UH4.T47 UH4.U47 UH4.V7 UH4.V11 UH4.V17 UH4.V26 UH4.V27 UH4.V29 UH4.V31 UH4.V36 UH4.V39 UH4.V43 UH4.W2 UH4.W17 UH4.W19 UH4.W27 UH4.W34 UH4.W48 UH4.Y4 UH4.Y8 UH4.Y12 UH4.Y38 UH4.Y42 UH4.Y46 UH5.3 Y3.2 Y3.4 YH2.2 YH2.4
GND_CHASSIS: C1104.2 R1111.2 R1112.2 R1113.2 R1114.2
GNDA: C955.2 C956.2 C957.2 C963.2 C964.2 C965.2 C966.2 C979.2 C980.2 C981.1 C982.1 C983.1 C1180.2 C1211.2 C1212.2 C1213.2 D81.1 D82.1 JHP1.3 JHP1.5 PJP62.1 Q107.4 U72.26 U72.30 U72.33
GNDA_CHG: PC1303.1 PC1305.2 PC1307.2 PC1309.2 PC1316.2 PC1323.2 PC1324.2 PC1325.2 PC1326.2 PC1327.2 PC1328.2 PC1333.1 PC1335.2 PJP801.1 PR1317.2 PR1329.2 PU1300.1 PU1300.12 PU1300.14 PU1300.29
GNDA_VCCSA: PC90.2 PJP21.2 PU7.1
VCC_AXG_SENSE: PC703.1 PR702.2 PR704.2 RC76.2 RC99.2 U1.F45
VCC_VAL_SENSE: RC71.1 RC120.2 U1.H43
VCCP: PC715.1 PR717.1 PU700.26
VCCP_PWRCTRL: RC140.2 RC141.1
VCCPWRGOOD_0_R: RC25.2 RC130.1 U1.B46
VCCSA_SENSE: PR88.2 U1.U10
VCCSA_VID_0: PR91.2 U1.D48
VCCSA_VID_1: PR90.2 U1.D49
VCCSAPWROK: PR80.1 U50.2
VCCSENSE: PC737.1 PR736.2 PR740.2 RC66.2 RC67.2 RC75.1
VCCSENSE_R: RC67.1 U1.F43
VDD_1.5V: PC253.1 PR201.1 PR202.2 PU200.11
VDD_PWRGD: R389.2 U9.13
VSS_AXG_SENSE: PC706.2 PU700.39 RC76.1 RC100.1 U1.G45
VSS_NCTF_1: UH4.A4
VSS_NCTF_2: UH4.A44
VSS_NCTF_3: UH4.A45
VSS_NCTF_4: UH4.A46
VSS_NCTF_5: UH4.A5
VSS_NCTF_6: UH4.A6
VSS_NCTF_7: UH4.B3
VSS_NCTF_8: UH4.B47
VSS_NCTF_9: UH4.BD1
VSS_NCTF_10: UH4.BD49
VSS_NCTF_11: UH4.BE1
VSS_NCTF_12: UH4.BE49
VSS_NCTF_13: UH4.BF1
VSS_NCTF_14: UH4.BF49
VSS_NCTF_15: UH4.BG2
VSS_NCTF_16: UH4.BG48
VSS_NCTF_17: UH4.BH3
VSS_NCTF_18: UH4.BH47
VSS_NCTF_19: UH4.BJ4
VSS_NCTF_20: UH4.BJ44
VSS_NCTF_21: UH4.BJ45
VSS_NCTF_22: UH4.BJ46
VSS_NCTF_23: UH4.BJ5
VSS_NCTF_24: UH4.BJ6
VSS_NCTF_25: UH4.C2
VSS_NCTF_26: UH4.C48
VSS_NCTF_27: UH4.D1
VSS_NCTF_28: UH4.D49
VSS_NCTF_29: UH4.E1
VSS_NCTF_30: UH4.E49
VSS_NCTF_31: UH4.F1
VSS_NCTF_32: UH4.F49
VSS_VAL_SENSE: RC71.2 RC121.2 U1.K43
VSSAXG_VAL_SENSE: RC69.2 RC123.2 U1.K45
VSSIO_SENSE_R: PR513.2 RC133.1 U1.AN17
VSSIO_SENSE_R_FB: PR510.1 PR513.1 PR514.1
VSSSENSE: PC741.1 PU700.16 RC68.2 RC70.1 RC75.2
VSSSENSE_R: RC68.1 U1.G43
+ADDR_XEN: R393.1 U9.32
+BL_PWR_SRC: C246.1 C296.1 JLVDS1.30 JLVDS1.31 JLVDS1.32 Q21.1 Q21.2 Q21.5 Q21.6
+CAMERA_VDD: C299.1 C300.1 C1311.1 JLVDS1.37 Q23.1
+CAP_LDO: C714.1 U46.B46
+COINCELL: JRTC1.1 PR1.1
+CRT_VCC: C1201.1 C1224.2 C1225.2 JCRT1.9 R1644.1 R1645.1 R1646.1 R1647.1 U73.5 U74.5 U77.3
+DC1_PWR_SRC: PC100.1 PC102.1 PC103.1 PC104.1 PC105.1 PC106.1 PC116.1 PC118.1 PC119.1 PD100.1 PL100.2 PQ100.5 PQ101.5 PU100.16
+DC_IN: PC10.2 PC16.1 PL5.2 PQ5.1 PQ5.2 PQ5.3 PR21.1 PR24.1 PR1335.1
+DC_IN_SS: PC11.1 PC13.1 PC14.1 PC15.1 PC1306.1 PQ5.5 PQ5.6 PQ5.7 PQ5.8 PQ1300.5 PQ1301.4 PR22.1 PR410.1 PR1306.1 PU1300.22
+DCIN_JACK: PC12.1 PJPDC1.4 PJPDC1.5 PL5.1
+DDR_CHG: Q72.1 R927.2
+DIMM0_1_CA_CPU: QD2.3 RC97.2 RD6.1 U1.BG7
+DIMM0_1_VREF_CPU: QD1.3 RC96.2 RD5.1 U1.BE7
+DIMM1_VREF_CA: CD7.1 CD8.1 JDIMM1.126 RD7.2
+DIMM1_VREF_DQ: CD1.1 CD2.1 JDIMM1.1 RD1.2 RD2.2
+DIMM2_VREF_CA: CD29.1 CD30.1 JDIMM2.126 RD12.2
+DIMM2_VREF_DQ: CD23.1 CD24.1 JDIMM2.1 RD10.2 RD11.2
+GFX_PWR_SRC: PC746.1 PC747.1 PC748.1 PC749.1 PC752.1 PJP702.2 PQ708.5
+LCDVDD: C298.1 C1330.1 JLVDS1.7 JLVDS1.8 Q18.4 R413.1
+OZ_AVDD: C563.1 C564.1 U38.8
+OZ_DVDD: C559.1 C560.1 U38.10
+PCH_V5REF_RUN: CH71.1 DH3.1 RH213.2 UH4.P34
+PCH_V5REF_SUS: CH63.1 DH2.1 RH208.2 UH4.M26
+PE_VDDH: C573.1 C574.1 C578.1 L44.2 U38.32
+PECI_VREF: C737.1 R862.1 U51.B51
+PWR_SRC: C297.1 PC9.1 PJP200.2 PJP400.1 PJP500.1 PL100.1 PL700.2 PL1300.2 PQ4.3 PQ1301.1 PQ1301.2 PQ1301.3 PR19.1 PR1301.1 Q21.4 R422.1
+PWR_SRC_S: PC8.1 PQ4.1 R412.1 R564.1 R714.1 R722.1 R729.1 R905.1 R917.1 R920.1 R930.1 R933.1 R940.1 RC72.1 RH279.1
+RSVD_VCC3P3_1: R553.2 U31.1
+RSVD_VCC3P3_2: R554.2 U31.2
+RTC_CELL: C274.1 CH88.1 CH89.1 CH90.1 PC3.1 PD4.1 R390.2 R810.1 R813.1 R815.1 R870.2 R1156.1 RH11.1 RH22.1 RH23.1 RH38.1 RH127.2 U9.16 UH4.A22
+RTC_CELL_VBAT: C723.1 R815.2 U51.B64
+SATA_SIDE_PWR: C1232.1 C1233.1 JESA1.1 U75.9
+SDC_IN: PQ1300.1 PQ1300.2 PQ1300.3 PR1301.4 PR1308.2 PR1313.2
+SIM_PWR: C616.1 JMINI1.8 JSIM1.1 U40.5
+SKT_VCC: C565.1 C566.1 U38.17
+TRM_CT1: C39.1 TR1.10
+TRM_CT2: C38.1 TR1.9
+TRM_CT3: C37.1 TR1.4
+TRM_CT4: C36.1 TR1.3
+V_DDR_REF: PC277.1 PU200.4 RD2.1 RD7.1 RD11.1 RD12.1
+V_DDR_REFA_M3: QD1.1 RD1.1 RD5.2
+V_DDR_REFB_M3: QD2.1 RD6.2 RD10.1
+V_DDR_SMREF: QC5.1 RC80.2 RC81.1 RC134.1
+V_SM_VREF_CNT: QC5.3 RC78.1 RC84.2 RC134.2 U1.AY43
+VCHGR: PC1329.1 PC1330.1 PC1331.1 PC1332.1 PL2.2 PQ1301.5 PQ1301.6 PQ1301.7 PQ1301.8 PR1326.1 PR1328.2
+VCHGR_B: PC1310.2 PC1319.2 PC1322.1 PL1301.1 PQ1304.1 PQ1304.2 PQ1304.3 PQ1305.5 PR1322.1
+VCHGR_L: PL1301.2 PR1326.4
+VDISPLAY_VCC: C337.1 C338.1 JHDMI1.18 U76.3
+VR_CAP: C740.1 U51.B12
+VREFOUT: C1180.1 R1143.1 U72.23
+XCLK_RCOMP: RH100.1 UH4.Y47
-DCIN_JACK: PC18.1 PJPDC1.2 PJPDC1.3 PL6.1
A_ENABLE: C770.1 Q57.3 Q58.3 R917.2 R1617.1
A_ON_3.3V#: Q57.5 Q57.6 Q60.2 R918.2
AC_PRESENT: R835.1 U51.A54 UH4.H20
ACAV_IN: PQ1306.2 PQ1311.5 PR1310.2 PR1311.2 PR1316.1 PR1320.1 U9.21 U51.B1
ACAV_IN_NB: PR1342.2 U51.A15
ALERT#: PR718.2 PR735.1 PU700.6
ALW_ENABLE: C762.1 Q49.3 Q51.3 R905.2 R1619.1
ALW_ON_3.3V#: Q51.5 Q51.6 Q66.2 QH8.2 R907.2
ALW_PWRGD_3V_5V: PR112.1 PU100.23 U51.B15
ALWON: PR115.1 U51.A60
AUD_HP_NB_SENSE: C967.1 Q107.5 R1087.2 R1652.2 U46.A41
AUD_HP_OUT_L: R1650.2 U72.31
AUD_HP_OUT_L1: L105.2 R1650.1
AUD_HP_OUT_L2: C1213.1 D81.3 JHP1.1 L105.1
AUD_HP_OUT_R: R1651.2 U72.32
AUD_HP_OUT_R1: L106.2 R1651.1
AUD_HP_OUT_R2: C1212.1 D81.2 JHP1.2 L106.1
AUD_NB_MUTE#: R1099.2 U46.A39 U72.47
AUD_PC_BEEP: C1105.2 C1106.2 U72.12
AUD_SENSE_A: C980.1 R1083.2 R1086.1 U72.13
AUD_SENSE_B: C979.1 R1078.2 U72.14
AUX_EN_WOWL: Q39.2 R716.1 U46.B67
B: C1207.1 JCRT1.3 L101.2
BAT1_LED#: Q83.1 R959.1 U46.B64
BAT1_LED#_Q: Q83.6 R951.1
BAT2_LED#: Q83.4 R958.1 U46.A9
BAT2_LED#_Q: Q83.3 R949.1
BATT_WHITE: JLED1.4 R949.2
BATT_WHITE_LED: JLVDS1.1 R958.2
BATT_YELLOW: JLED1.5 R951.2
BATT_YELLOW_LED: JLVDS1.2 R959.2
BAY_SMBCLK: R856.2 U51.A7
BAY_SMBDAT: R854.2 U51.B7
BBS_BIT0_R: RH52.1 UH4.P1
BBS_BIT1: RH342.1 UH4.D47
BC_CLK_ECE1117: JTP1.7 U51.A20
BC_CLK_ECE5048: U46.A30 U51.A43
BC_CLK_EMC4021: U9.8 U51.A12
BC_DAT_ECE1117: JTP1.9 R817.1 U51.B21
BC_DAT_ECE5048: R814.2 U46.B31 U51.B45
BC_DAT_EMC4021: R821.1 U9.7 U51.B13
BC_INT#_ECE1117: JTP1.10 U51.A19
BC_INT#_ECE5048: U46.A29 U51.A42
BC_INT#_EMC4021: R385.2 U9.9 U51.A13
BEEP: R1120.2 U51.A16
BIA_PWM_EC: D68.2 U51.B25
BIA_PWM_LVDS: D66.1 D68.1 LE92.2 R1137.1
BIA_PWM_LVDS_L: JLVDS1.26 LE92.1
BIA_PWM_PCH: D66.2 UH4.P45
BLUE_CRT: C1204.1 D77.3 L101.1 R1643.1 RH131.2 UH4.N48
BOARD_ID: C744.1 R875.2 U51.B10
BOOT: PR1318.1 PU1300.25
BOOT1: PR749.2 PU700.20
BOOT1G: PR763.2 PU700.31
BOOT_1.5V: PR200.2 PU200.18
BOOT_D: PC1310.1 PD1301.1 PR1318.2
BPM#6: T107.1(TP-1) U1.J59
BPM#7: T127.1(TP-1) U1.J61
BREATH_LED#: Q84.1 R955.1 U46.B39
BREATH_LED#_Q: JLED1.7 R1733.2
BREATH_WHITE_LED: JLVDS1.3 R955.2
BST1_3V: PC108.2 PR107.1
BST1_5V: PC109.1 PR108.2
BST_3V: PR107.2 PU100.9
BST_5V: PR108.1 PU100.22
BST_+V1.05S_VCCPP: PR502.1 PU500.10
BST_+V1.05SP: PR401.1 PU400.10
BT_ACTIVE: JBT1.6 Q78.5 R950.1
BT_COEX_STATUS2: JBT1.4 R1708.2
BT_DET#: JBT1.2 RH328.2 UH4.E40
BT_LED#: JMINI2.46 Q126.3 R1734.1
BT_PRI_STATUS: JBT1.5 R1710.2
BT_RADIO_DIS#: D93.1 D94.1 R1727.1 R1729.2 R1730.1 U46.A13
BT_RADIO_DIS#_CON: C1307.1 D94.2 JBT1.7 R1730.2
BT_RADIO_DIS#_R: D93.2 JMINI2.51 R1727.2
CAM_MIC_CBL_DET#: JLVDS1.34 RH331.2 UH4.C42
CAP_INT#: JCAP2.6 R1743.2 U51.A2
CAP_R_RST#: Q127.2 R888.2 U51.B22
CAP_RST#: JCAP2.5 R1744.1
CAP_SMB_CLK: JCAP2.7 R841.2 R877.2
CAP_SMB_DAT: JCAP2.8 R838.2 R874.2
CARD_SMBCLK: R589.1 U51.A49
CARD_SMBDAT: R590.1 U51.B52
CCD_OFF: Q23.2 U46.B43
CFD_PWRBTN#_XDP: JXDP1.11 RC6.2
CFG0: RC7.1 U1.B50
CFG2: RC51.1 U1.B54
CFG4: RC52.1 U1.A51
CFG5: RC54.1 U1.C53
CFG6: RC53.1 U1.C55
CFG7: RC56.1 U1.H49
CHAGER_SRC: PC1301.1 PC1302.1 PC1312.1 PC1313.1 PC1314.1 PC1315.1 PL1300.1 PQ1304.5
CHARGE_EN: R3.2 U46.A45
CHARGER_SMBCLK: PU1300.10 R828.2 U51.B50
CHARGER_SMBDAT: PU1300.9 R827.2 U51.A47
CHG_LGATE: PQ1305.4 PU1300.20
CHG_UGATE: PC1319.1 PQ1304.4 PU1300.24
CLK_80H: RH314.2 UH4.H47
CLK_BUF_BCLK: RH91.1 UH4.BG30 UH4.BJ30
CLK_BUF_CKSSCD: RH79.1 UH4.AK5
CLK_BUF_CKSSCD#: RH78.1 UH4.AK7
CLK_BUF_DMI: RH75.1 UH4.BE18
CLK_BUF_DMI#: RH74.1 UH4.BF18
CLK_BUF_DOT96: RH77.1 UH4.E24
CLK_BUF_DOT96#: RH76.1 UH4.G24
CLK_CPU_DMI: U1.J3 UH4.AU22
CLK_CPU_DMI#: U1.H2 UH4.AV22
CLK_CPU_ITP: RH107.2 RH109.2 UH4.AK13
CLK_CPU_ITP#: RH106.2 RH108.2 UH4.AK14
CLK_DDC_CRT: JCRT1.15 QH6.6 R1645.2
CLK_KBD: R845.2 U51.A38
CLK_MSE: R851.2 U51.A39
CLK_PCH_14M: RH183.1 UH4.K45
CLK_PCI_5048: CH110.1 R795.1 RH160.2 U46.A28
CLK_PCI_LOOPBACK: CH111.1 RH105.2 UH4.H45
CLK_PCI_MEC: CH109.1 R885.1 RH102.2 U51.A29
CLK_PCI_TPM_TCM: CH112.1 RE5.1 RH311.1 U37.21 U39.21
CLK_PCIE_LAN: U31.44 UH4.AB47
CLK_PCIE_LAN#: U31.45 UH4.AB49
CLK_PCIE_MINI1: JMINI1.13 UH4.Y39
CLK_PCIE_MINI1#: JMINI1.11 UH4.Y40
CLK_PCIE_MINI2: JMINI2.13 UH4.V46
CLK_PCIE_MINI2#: JMINI2.11 UH4.V45
CLK_PCIE_MMI: U38.2 UH4.AA47
CLK_PCIE_MMI#: U38.1 UH4.AA48
CLK_SIO_14M: R794.1 RH313.1 U46.A32
CLK_TP_SIO: C751.1 L55.2 R902.2 U51.A37
CLK_XDP: JXDP1.14 RH107.1
CLK_XDP#: JXDP1.15 RH106.1
CLK_XDP_ITP: RH109.1 U1.N59
CLK_XDP_ITP#: RH108.1 U1.N58
CLKRUN#: RH137.2 U37.15 U39.15 U46.B20 U51.A32 UH4.N3
CODEC_CAP2: C965.1 U72.22
CODEC_VN: C964.1 U72.34
CODEC_VREF: C966.1 U72.21
CODEC_VREG: C963.1 U72.37
COEX1_BT_ACTIVE: JBT1.3 R702.1
COEX2_WLAN_ACTIVE: C600.1 C1306.1 JBT1.8 R700.1 R1709.1
COMP: PC723.1 PC727.1 PR742.1 PU700.18
CONTACTLESS_DET#: RH256.2 UH4.C40
CPU1.5V_S3_GATE: R889.2 RC79.1 U51.A36
CPU_DETECT#: R763.2 U1.C57 U46.A3
CPU_DPLL: RC16.1 U1.AG3
CPU_DPLL#: RC17.1 U1.AG1
CPU_VTT_ON: PR503.1 R789.2 U46.B17
CRT_IREF: RH126.1 UH4.T43
CS_1.5V: PR201.2 PU200.13
CSSN_1: PR1301.2 PR1303.1 PR1305.1
CSSP_1: PR1301.3 PR1303.2 PR1304.1
D_CLKRUN#: R777.2 U46.A19
D_DLDRQ1#: R782.2 U46.B24
D_SERIRQ: R780.2 U46.A20
DAT_DDC_CRT: JCRT1.12 QH6.3 R1644.2
DAT_KBD: R846.2 U51.B41
DAT_MSE: R852.2 U51.B42
DAT_TP_SIO: C752.1 L54.2 R903.2 U51.B40
DBC_ENABLE: JLVDS1.28 RH269.2 RH273.1 UH4.D40
DC_TEST_A59_C59: U1.A59 U1.C59
DC_TEST_A61_C61: U1.A61 U1.C61
DC_TEST_BE1_BG1: U1.BE1 U1.BG1
DC_TEST_BE3_BG3: U1.BE3 U1.BG3
DC_TEST_BE59_BE61: U1.BE59 U1.BE61
DC_TEST_BG59_BG61: U1.BG59 U1.BG61
DC_TEST_C4_D3: U1.C4 U1.D3
DDR3_DRAMRST#: QC2.1 RC48.2 RD3.2 RD4.2
DDR3_DRAMRST#_CPU: QC2.3 RC48.1 RC50.1 U1.AT30
DDR3_DRAMRST#_R: JDIMM1.30 JDIMM2.30 RD4.1
DDR_A_BS0: JDIMM1.109 U1.BD37
DDR_A_BS1: JDIMM1.108 U1.BF36
DDR_A_BS2: JDIMM1.79 U1.BA28
DDR_A_CAS#: JDIMM1.115 U1.BE39
DDR_A_D0: JDIMM1.5 U1.AG6
DDR_A_D1: JDIMM1.7 U1.AJ6
DDR_A_D2: JDIMM1.15 U1.AP11
DDR_A_D3: JDIMM1.17 U1.AL6
DDR_A_D4: JDIMM1.4 U1.AJ10
DDR_A_D5: JDIMM1.6 U1.AJ8
DDR_A_D6: JDIMM1.16 U1.AL8
DDR_A_D7: JDIMM1.18 U1.AL7
DDR_A_D8: JDIMM1.21 U1.AR11
DDR_A_D9: JDIMM1.23 U1.AP6
DDR_A_D10: JDIMM1.33 U1.AU6
DDR_A_D11: JDIMM1.35 U1.AV9
DDR_A_D12: JDIMM1.22 U1.AR6
DDR_A_D13: JDIMM1.24 U1.AP8
DDR_A_D14: JDIMM1.34 U1.AT13
DDR_A_D15: JDIMM1.36 U1.AU13
DDR_A_D16: JDIMM1.39 U1.BC7
DDR_A_D17: JDIMM1.41 U1.BB7
DDR_A_D18: JDIMM1.51 U1.BA13
DDR_A_D19: JDIMM1.53 U1.BB11
DDR_A_D20: JDIMM1.40 U1.BA7
DDR_A_D21: JDIMM1.42 U1.BA9
DDR_A_D22: JDIMM1.50 U1.BB9
DDR_A_D23: JDIMM1.52 U1.AY13
DDR_A_D24: JDIMM1.57 U1.AV14
DDR_A_D25: JDIMM1.59 U1.AR14
DDR_A_D26: JDIMM1.67 U1.AY17
DDR_A_D27: JDIMM1.69 U1.AR19
DDR_A_D28: JDIMM1.56 U1.BA14
DDR_A_D29: JDIMM1.58 U1.AU14
DDR_A_D30: JDIMM1.68 U1.BB14
DDR_A_D31: JDIMM1.70 U1.BB17
DDR_A_D32: JDIMM1.129 U1.BA45
DDR_A_D33: JDIMM1.131 U1.AR43
DDR_A_D34: JDIMM1.141 U1.AW48
DDR_A_D35: JDIMM1.143 U1.BC48
DDR_A_D36: JDIMM1.130 U1.BC45
DDR_A_D37: JDIMM1.132 U1.AR45
DDR_A_D38: JDIMM1.140 U1.AT48
DDR_A_D39: JDIMM1.142 U1.AY48
DDR_A_D40: JDIMM1.147 U1.BA49
DDR_A_D41: JDIMM1.149 U1.AV49
DDR_A_D42: JDIMM1.157 U1.BB51
DDR_A_D43: JDIMM1.159 U1.AY53
DDR_A_D44: JDIMM1.146 U1.BB49
DDR_A_D45: JDIMM1.148 U1.AU49
DDR_A_D46: JDIMM1.158 U1.BA53
DDR_A_D47: JDIMM1.160 U1.BB55
DDR_A_D48: JDIMM1.163 U1.BA55
DDR_A_D49: JDIMM1.165 U1.AV56
DDR_A_D50: JDIMM1.175 U1.AP50
DDR_A_D51: JDIMM1.177 U1.AP53
DDR_A_D52: JDIMM1.164 U1.AV54
DDR_A_D53: JDIMM1.166 U1.AT54
DDR_A_D54: JDIMM1.174 U1.AP56
DDR_A_D55: JDIMM1.176 U1.AP52
DDR_A_D56: JDIMM1.181 U1.AN57
DDR_A_D57: JDIMM1.183 U1.AN53
DDR_A_D58: JDIMM1.191 U1.AG56
DDR_A_D59: JDIMM1.193 U1.AG53
DDR_A_D60: JDIMM1.180 U1.AN55
DDR_A_D61: JDIMM1.182 U1.AN52
DDR_A_D62: JDIMM1.192 U1.AG55
DDR_A_D63: JDIMM1.194 U1.AK56
DDR_A_DQS0: JDIMM1.12 U1.AJ11
DDR_A_DQS1: JDIMM1.29 U1.AR10
DDR_A_DQS2: JDIMM1.47 U1.AY11
DDR_A_DQS3: JDIMM1.64 U1.AU17
DDR_A_DQS4: JDIMM1.137 U1.AW45
DDR_A_DQS5: JDIMM1.154 U1.AV51
DDR_A_DQS6: JDIMM1.171 U1.AT56
DDR_A_DQS7: JDIMM1.188 U1.AK54
DDR_A_DQS#0: JDIMM1.10 U1.AL11
DDR_A_DQS#1: JDIMM1.27 U1.AR8
DDR_A_DQS#2: JDIMM1.45 U1.AV11
DDR_A_DQS#3: JDIMM1.62 U1.AT17
DDR_A_DQS#4: JDIMM1.135 U1.AV45
DDR_A_DQS#5: JDIMM1.152 U1.AY51
DDR_A_DQS#6: JDIMM1.169 U1.AT55
DDR_A_DQS#7: JDIMM1.186 U1.AK55
DDR_A_MA0: JDIMM1.98 U1.BG35
DDR_A_MA1: JDIMM1.97 U1.BB34
DDR_A_MA2: JDIMM1.96 U1.BE35
DDR_A_MA3: JDIMM1.95 U1.BD35
DDR_A_MA4: JDIMM1.92 U1.AT34
DDR_A_MA5: JDIMM1.91 U1.AU34
DDR_A_MA6: JDIMM1.90 U1.BB32
DDR_A_MA7: JDIMM1.86 U1.AT32
DDR_A_MA8: JDIMM1.89 U1.AY32
DDR_A_MA9: JDIMM1.85 U1.AV32
DDR_A_MA10: JDIMM1.107 U1.BE37
DDR_A_MA11: JDIMM1.84 U1.BA30
DDR_A_MA12: JDIMM1.83 U1.BC30
DDR_A_MA13: JDIMM1.119 U1.AW41
DDR_A_MA14: JDIMM1.80 U1.AY28
DDR_A_MA15: JDIMM1.78 U1.AU26
DDR_A_RAS#: JDIMM1.110 U1.BD39
DDR_A_WE#: JDIMM1.113 U1.AT41
DDR_B_BS0: JDIMM2.109 U1.BG39
DDR_B_BS1: JDIMM2.108 U1.BD42
DDR_B_BS2: JDIMM2.79 U1.AT22
DDR_B_CAS#: JDIMM2.115 U1.AV43
DDR_B_D0: JDIMM2.5 U1.AL4
DDR_B_D1: JDIMM2.7 U1.AL1
DDR_B_D2: JDIMM2.15 U1.AN3
DDR_B_D3: JDIMM2.17 U1.AR4
DDR_B_D4: JDIMM2.4 U1.AK4
DDR_B_D5: JDIMM2.6 U1.AK3
DDR_B_D6: JDIMM2.16 U1.AN4
DDR_B_D7: JDIMM2.18 U1.AR1
DDR_B_D8: JDIMM2.21 U1.AU4
DDR_B_D9: JDIMM2.23 U1.AT2
DDR_B_D10: JDIMM2.33 U1.AV4
DDR_B_D11: JDIMM2.35 U1.BA4
DDR_B_D12: JDIMM2.22 U1.AU3
DDR_B_D13: JDIMM2.24 U1.AR3
DDR_B_D14: JDIMM2.34 U1.AY2
DDR_B_D15: JDIMM2.36 U1.BA3
DDR_B_D16: JDIMM2.39 U1.BE9
DDR_B_D17: JDIMM2.41 U1.BD9
DDR_B_D18: JDIMM2.51 U1.BD13
DDR_B_D19: JDIMM2.53 U1.BF12
DDR_B_D20: JDIMM2.40 U1.BF8
DDR_B_D21: JDIMM2.42 U1.BD10
DDR_B_D22: JDIMM2.50 U1.BD14
DDR_B_D23: JDIMM2.52 U1.BE13
DDR_B_D24: JDIMM2.57 U1.BF16
DDR_B_D25: JDIMM2.59 U1.BE17
DDR_B_D26: JDIMM2.67 U1.BE18
DDR_B_D27: JDIMM2.69 U1.BE21
DDR_B_D28: JDIMM2.56 U1.BE14
DDR_B_D29: JDIMM2.58 U1.BG14
DDR_B_D30: JDIMM2.68 U1.BG18
DDR_B_D31: JDIMM2.70 U1.BF19
DDR_B_D32: JDIMM2.129 U1.BD50
DDR_B_D33: JDIMM2.131 U1.BF48
DDR_B_D34: JDIMM2.141 U1.BD53
DDR_B_D35: JDIMM2.143 U1.BF52
DDR_B_D36: JDIMM2.130 U1.BD49
DDR_B_D37: JDIMM2.132 U1.BE49
DDR_B_D38: JDIMM2.140 U1.BD54
DDR_B_D39: JDIMM2.142 U1.BE53
DDR_B_D40: JDIMM2.147 U1.BF56
DDR_B_D41: JDIMM2.149 U1.BE57
DDR_B_D42: JDIMM2.157 U1.BC59
DDR_B_D43: JDIMM2.159 U1.AY60
DDR_B_D44: JDIMM2.146 U1.BE54
DDR_B_D45: JDIMM2.148 U1.BG54
DDR_B_D46: JDIMM2.158 U1.BA58
DDR_B_D47: JDIMM2.160 U1.AW59
DDR_B_D48: JDIMM2.163 U1.AW58
DDR_B_D49: JDIMM2.165 U1.AU58
DDR_B_D50: JDIMM2.175 U1.AN61
DDR_B_D51: JDIMM2.177 U1.AN59
DDR_B_D52: JDIMM2.164 U1.AU59
DDR_B_D53: JDIMM2.166 U1.AU61
DDR_B_D54: JDIMM2.174 U1.AN58
DDR_B_D55: JDIMM2.176 U1.AR58
DDR_B_D56: JDIMM2.181 U1.AK58
DDR_B_D57: JDIMM2.183 U1.AL58
DDR_B_D58: JDIMM2.191 U1.AG58
DDR_B_D59: JDIMM2.193 U1.AG59
DDR_B_D60: JDIMM2.180 U1.AM60
DDR_B_D61: JDIMM2.182 U1.AL59
DDR_B_D62: JDIMM2.192 U1.AF61
DDR_B_D63: JDIMM2.194 U1.AH60
DDR_B_DQS0: JDIMM2.12 U1.AM2
DDR_B_DQS1: JDIMM2.29 U1.AV1
DDR_B_DQS2: JDIMM2.47 U1.BE11
DDR_B_DQS3: JDIMM2.64 U1.BD18
DDR_B_DQS4: JDIMM2.137 U1.BE51
DDR_B_DQS5: JDIMM2.154 U1.BA61
DDR_B_DQS6: JDIMM2.171 U1.AR59
DDR_B_DQS7: JDIMM2.188 U1.AK61
DDR_B_DQS#0: JDIMM2.10 U1.AL3
DDR_B_DQS#1: JDIMM2.27 U1.AV3
DDR_B_DQS#2: JDIMM2.45 U1.BG11
DDR_B_DQS#3: JDIMM2.62 U1.BD17
DDR_B_DQS#4: JDIMM2.135 U1.BG51
DDR_B_DQS#5: JDIMM2.152 U1.BA59
DDR_B_DQS#6: JDIMM2.169 U1.AT60
DDR_B_DQS#7: JDIMM2.186 U1.AK59
DDR_B_MA0: JDIMM2.98 U1.BF32
DDR_B_MA1: JDIMM2.97 U1.BE33
DDR_B_MA2: JDIMM2.96 U1.BD33
DDR_B_MA3: JDIMM2.95 U1.AU30
DDR_B_MA4: JDIMM2.92 U1.BD30
DDR_B_MA5: JDIMM2.91 U1.AV30
DDR_B_MA6: JDIMM2.90 U1.BG30
DDR_B_MA7: JDIMM2.86 U1.BD29
DDR_B_MA8: JDIMM2.89 U1.BE30
DDR_B_MA9: JDIMM2.85 U1.BE28
DDR_B_MA10: JDIMM2.107 U1.BD43
DDR_B_MA11: JDIMM2.84 U1.AT28
DDR_B_MA12: JDIMM2.83 U1.AV28
DDR_B_MA13: JDIMM2.119 U1.BD46
DDR_B_MA14: JDIMM2.80 U1.AT26
DDR_B_MA15: JDIMM2.78 U1.AU22
DDR_B_RAS#: JDIMM2.110 U1.BF40
DDR_B_WE#: JDIMM2.113 U1.BD45
DDR_CKE0_DIMMA: JDIMM1.73 U1.AY26
DDR_CKE1_DIMMA: JDIMM1.74 U1.BB26
DDR_CKE2_DIMMB: JDIMM2.73 U1.AR22
DDR_CKE3_DIMMB: JDIMM2.74 U1.BF27
DDR_CS0_DIMMA#: JDIMM1.114 U1.BB40
DDR_CS1_DIMMA#: JDIMM1.121 U1.BC41
DDR_CS2_DIMMB#: JDIMM2.114 U1.BE41
DDR_CS3_DIMMB#: JDIMM2.121 U1.BE47
DDR_HVREF_RST: CC177.1 QC2.2 QD1.2 QD2.2 RC46.2 RC47.2
DDR_HVREF_RST_GATE: RC47.1 U51.A34
DDR_HVREF_RST_PCH: RC46.1 RH300.2 UH4.A12
DDR_ON: PR206.1 R876.2 U51.B14
DDR_XDP_WAN_SMBCLK: JDIMM1.202 JDIMM2.202 QH5.1 R1157.2 RH363.2
DDR_XDP_WAN_SMBDAT: JDIMM1.200 JDIMM2.200 QH5.4 R1158.2 RH364.2
DEEP_S3_WAKE: R881.1 RH365.1 UH4.E16
DEVICE_DET#: R1125.2 U51.A17
DF_TVS: RH358.2 UH4.AY1
DF_TVS_R: RH149.2 RH150.2 RH358.1
DH_1.5V: PQ200.4 PU200.17
DISP_ON: D67.1 D69.1 JLVDS1.27 R1138.1
DL_1.5V: PQ210.4 PU200.15
DMI_COMP_R: RH111.2 UH4.BG25 UH4.BJ24
DMI_CRX_PTX_N0: U1.M2 UH4.AW24
DMI_CRX_PTX_N1: U1.P6 UH4.AW20
DMI_CRX_PTX_N2: U1.P1 UH4.BB18
DMI_CRX_PTX_N3: U1.P10 UH4.AV18
DMI_CRX_PTX_P0: U1.N3 UH4.AY24
DMI_CRX_PTX_P1: U1.P7 UH4.AY20
DMI_CRX_PTX_P2: U1.P3 UH4.AY18
DMI_CRX_PTX_P3: U1.P11 UH4.AU18
DMI_CTX_PRX_N0: U1.K1 UH4.BC24
DMI_CTX_PRX_N1: U1.M8 UH4.BE20
DMI_CTX_PRX_N2: U1.N4 UH4.BG18
DMI_CTX_PRX_N3: U1.R2 UH4.BG20
DMI_CTX_PRX_P0: U1.K3 UH4.BE24
DMI_CTX_PRX_P1: U1.M7 UH4.BC20
DMI_CTX_PRX_P2: U1.P4 UH4.BJ18
DMI_CTX_PRX_P3: U1.T3 UH4.BJ20
DMIC0: D9.2 JLVDS1.40 U72.4
DMIC_CLK: D9.3 JLVDS1.38 LE3.2
DMIC_CLK_L: LE3.1 U72.2
DOCK_AC_OFF_EC: R1629.1 U46.A63
DOCK_DET#: R755.1 U46.B41
DOCK_HP_DET: R1082.2 U46.A7
DOCK_MIC_DET: R1081.2 U46.B8
DOCK_SMB_ALERT#: R785.1 U46.A51
DSWODVREN: RH127.1 UH4.A18
DYN_TUR_CURRNT_SET#: PQ1306.5 R1171.2 U51.A35
DYN_TURB_PWR_ALRT#: R796.2 U46.A46
EC_32KHZ_ECE5048: R867.1 U46.B35
EDP_COMP: RC2.2 U1.AD2 U1.AF3
EN_1.8VSP: PC304.1 PR303.2 PR304.1 PR306.2 PU300.5
EN_+V1.05S_VCCPP: PC506.1 PR307.2 PR503.2 PU500.3
EN_+V1.05SP: PC407.1 PR403.2 PR408.2 PR409.2 PU400.3
EN_INVPWR: Q22.2 R882.2 U51.A25
EN_LCDPWR: D6.1 Q20.2
ENAB_3VLAN: C477.1 Q34.3 Q35.3 R564.2 R1638.1
ENTRIP1: PQ104.6 PR106.1 PU100.1
ENTRIP2: PQ104.3 PR105.2 PU100.6
ENVDD_PCH: D6.3 RH134.2 U46.B38 UH4.M45
ESATA_CD#: R746.1 RH163.2 UH4.U2
ESATA_CD#_R: R746.2 R751.2 U44.18
ESATA_PE1: R743.2 U44.9
ESATA_PE2: R745.2 U44.8
ESATA_PRX_DTX_N4: C665.1 U44.4
ESATA_PRX_DTX_N4_C: C665.2 R1722.2 UH4.Y7
ESATA_PRX_DTX_N4_RP: C1238.1 R1723.1 U44.12
ESATA_PRX_DTX_P4: C666.1 U44.5
ESATA_PRX_DTX_P4_C: C666.2 R1724.2 UH4.Y5
ESATA_PRX_DTX_P4_RP: C1239.1 R1725.1 U44.11
ESATA_PTX_DRX_N4: C664.1 U44.2
ESATA_PTX_DRX_N4_C: C664.2 R1720.2 UH4.AD3
ESATA_PTX_DRX_N4_RP: C1237.1 R1721.1 U44.14
ESATA_PTX_DRX_P4: C663.1 U44.1
ESATA_PTX_DRX_P4_C: C663.2 R1718.2 UH4.AD1
ESATA_PTX_DRX_P4_RP: C1236.1 R1719.1 U44.15
ESATA_USB_PWR_EN#: R769.2 U46.B44 U75.4
EXPCLK_REQ#: RH94.1 UH4.L12
EXT_MIC: C1211.1 D82.3 JHP1.4 L104.1
FAN1_PWM#: JFAN1.2 R402.2 U9.15
FAN1_TACH_FB: JFAN1.3 R426.2 U9.10
FB_3V: PC120.1 PR101.2 PR103.2 PU100.5
FB_5V: PC121.2 PR102.1 PR104.1 PU100.2
FB_+V1.05S_VCCPP: PR507.2 PR510.2 PU500.4
FB_+V1.05SP: PR406.2 PR407.2 PU400.4
FDI_CTX_PRX_N0: U1.U7 UH4.BJ14
FDI_CTX_PRX_N1: U1.W11 UH4.AY14
FDI_CTX_PRX_N2: U1.W1 UH4.BE14
FDI_CTX_PRX_N3: U1.AA6 UH4.BH13
FDI_CTX_PRX_N4: U1.W6 UH4.BC12
FDI_CTX_PRX_N5: U1.V4 UH4.BJ12
FDI_CTX_PRX_N6: U1.Y2 UH4.BG10
FDI_CTX_PRX_N7: U1.AC9 UH4.BG9
FDI_CTX_PRX_P0: U1.U6 UH4.BG14
FDI_CTX_PRX_P1: U1.W10 UH4.BB14
FDI_CTX_PRX_P2: U1.W3 UH4.BF14
FDI_CTX_PRX_P3: U1.AA7 UH4.BG13
FDI_CTX_PRX_P4: U1.W7 UH4.BE12
FDI_CTX_PRX_P5: U1.T4 UH4.BG12
FDI_CTX_PRX_P6: U1.AA3 UH4.BJ10
FDI_CTX_PRX_P7: U1.AC8 UH4.BH9
FDI_FSYNC0: U1.AA11 UH4.AV12
FDI_FSYNC1: U1.AC12 UH4.BC10
FDI_INT: U1.U11 UH4.AW16
FDI_LSYNC0: U1.AA10 UH4.AV14
FDI_LSYNC1: U1.AG8 UH4.BB10
FWP#: R872.1 R879.2 U51.B65
G: C1206.1 JCRT1.2 L100.2
GP1_SW: PL704.3 PR758.2
GP1_VO: PL704.2 PR759.1
GPU_SMBCLK: R822.2 U51.B49
GPU_SMBDAT: R829.2 U51.B48
GREEN_CRT: C1203.1 D77.2 L100.1 R1642.1 RH132.2 UH4.P49
H_CATERR#: RC128.2 U1.C49
H_CPU_SVIDALRT#: RC61.1 U1.A44
H_CPUPWRGD: CC141.1 RC5.1 RC25.1 UH4.AY11
H_CPUPWRGD_XDP: JXDP1.10 RC5.2
H_PM_SYNC: T63.1(TP-1) U1.C48 UH4.AP14
H_PROCHOT#: PC719.1 PR721.1 PR1339.2 Q47.1 R1180.2 RC44.2 RC57.1
H_PROCHOT#_R: RC57.2 U1.C45
H_SNB_IVB#: RH150.1 U1.F49
H_THERMTRIP#: Q16.3 RC126.2 RC129.1
H_THERMTRIP#_R: RC129.2 U1.D45
HDD_DET#: JMINI3.51 RH30.2 RH290.2
HDD_DET#_R: RH290.1 UH4.V14
HDMI_CEC: JHDMI1.13 R1165.2
HDMI_HPD_SINK: JHDMI1.19 Q121.1 R1128.1
HDMI_OB: Q26.1 R448.2 R449.2 R450.2 R452.2 R453.2 R454.2 R455.2 R456.2
HDMIB_PCH_HPD: Q121.3 R1168.1 UH4.AT40
HOST_DEB_RX: JDEG2.9 R855.1
HOST_DEB_TX: JDEG2.8 R853.1
HOST_DEBUG_RX: JMINI2.17 R849.2 R855.2 U51.B46
HOST_DEBUG_TX: C595.1 JMINI2.16 R848.2 R853.2 U51.B44
HSYNC: RH123.2 UH4.M47
HSYNC_BUF: R1668.1 RH123.1 U73.2
HSYNC_CRT: L102.1 R1668.2 U73.4
HW_GPS_DISABLE2#: JMINI1.51 R798.2 U46.B34
ICOUT: PC1309.1 PR1319.2 PU1300.26
IMVP_PWRGD: PR708.2 PR726.2 PR728.2 U46.A62
IMVP_VR_ON: PR722.1 R765.2
INT_SPK_L+: C976.1 L94.1 U72.40
INT_SPK_L-: C975.1 L93.1 U72.41
INT_SPK_R+: C974.1 L92.1 U72.44
INT_SPK_R-: C973.1 L91.1 U72.43
INT_SPKL_L+: C1318.1 DE1.2 JSPK1.4 L94.2
INT_SPKR_L-: C1319.1 DE1.3 JSPK1.3 L93.2
INT_SPKR_R+: C1320.1 DE2.2 JSPK1.2 L92.2
INT_SPKR_R-: C1321.1 DE2.3 JSPK1.1 L91.2
INTRUDER#: RH11.2 UH4.K22
IRQ_SERIRQ: RH28.2 U37.27 U39.27 U46.B21 U51.A28 UH4.V5
ISEN1G: PU700.2
ISEN2: PR732.2 PU700.12
ISEN2G: PR713.2 PU700.3
JETWAY_14M: RH315.2 UH4.K49
JETWAY_CLK14M: RE6.1 RH315.1 U37.13 U39.13
JTAG_CLK: JDEG2.4 R860.2 U51.B56
JTAG_RST#: C735.1 JTAG1.1 R824.2 R836.1 U51.B57
JTAG_TDI: JDEG2.2 R858.2 U51.A51
JTAG_TDO: JDEG2.5 R861.1 U51.B55
JTAG_TMS: JDEG2.3 R859.2 U51.A53
JVGA_HS: C1210.1 JCRT1.13 L102.2 R1647.2
JVGA_VS: C1209.1 JCRT1.14 L103.2 R1646.2
KB_DET#: JTP1.16 RH170.1 UH4.D6
LAN_ACTLED_YEL#: R1089.1 U31.26
LAN_ACTLED_YEL#_R: C1323.1 JLOM1.10 R1089.2
LAN_DISABLE#_R: R549.2 R555.2 R557.1 U31.3 U46.B47
LAN_SMBCLK: R551.1 RH305.2 UH4.C8
LAN_SMBCLK_R: R551.2 U31.28
LAN_SMBDATA: R552.1 RH306.2 UH4.G12
LAN_SMBDATA_R: R552.2 U31.31
LAN_TEST_EN: R561.1 U31.30
LAN_TX0+: L124.1 U31.13
LAN_TX0+_L: L124.2 R1735.1
LAN_TX0+_R: C1326.1 R1735.2 TR1.12
LAN_TX0-: L125.1 U31.14
LAN_TX0-_L: L125.2 R1736.1
LAN_TX0-_R: C1326.2 R1736.2 TR1.11
LAN_TX1+: L126.1 U31.17
LAN_TX1+_L: L126.2 R1737.1
LAN_TX1+_R: C1327.1 R1737.2 TR1.8
LAN_TX1-: L127.1 U31.18
LAN_TX1-_L: L127.2 R1738.1
LAN_TX1-_R: C1327.2 R1738.2 TR1.7
LAN_TX2+: L128.1 U31.20
LAN_TX2+_L: L128.2 R1739.1
LAN_TX2+_R: C1328.1 R1739.2 TR1.6
LAN_TX2-: L129.1 U31.21
LAN_TX2-_L: L129.2 R1740.1
LAN_TX2-_R: C1328.2 R1740.2 TR1.5
LAN_TX3+: L130.1 U31.23
LAN_TX3+_L: L130.2 R1741.1
LAN_TX3+_R: C1329.1 R1741.2 TR1.2
LAN_TX3-: L131.1 U31.24
LAN_TX3-_L: L131.2 R1742.1
LAN_TX3-_R: C1329.2 R1742.2 TR1.1
LANCLK_REQ#: R1187.1 UH4.M1
LANCLK_REQ#_R: R547.2 R1187.2 U31.48
LAT_ON_SW#: R870.1 U51.B63
LCD_A0+_PCH: JLVDS1.15 UH4.AN47
LCD_A0-_PCH: JLVDS1.14 UH4.AN48
LCD_A1+_PCH: JLVDS1.18 UH4.AM49
LCD_A1-_PCH: JLVDS1.17 UH4.AM47
LCD_A2+_PCH: JLVDS1.21 UH4.AK49
LCD_A2-_PCH: JLVDS1.20 UH4.AK47
LCD_ACLK+_PCH: JLVDS1.24 UH4.AK40
LCD_ACLK-_PCH: JLVDS1.23 UH4.AK39
LCD_B0+_PCH: JLVDS2.10 UH4.AH43
LCD_B0-_PCH: JLVDS2.11 UH4.AH45
LCD_B1+_PCH: JLVDS2.7 UH4.AH49
LCD_B1-_PCH: JLVDS2.8 UH4.AH47
LCD_B2+_PCH: JLVDS2.4 UH4.AF47
LCD_B2-_PCH: JLVDS2.5 UH4.AF49
LCD_BCLK+_PCH: JLVDS2.1 UH4.AF39
LCD_BCLK-_PCH: JLVDS2.2 UH4.AF40
LCD_CBL_DET#: JLVDS1.25 RH330.2 UH4.G42
LCD_SMBCLK: R418.2 U51.B5
LCD_SMBDAT: R420.2 U51.A4
LCD_TST: JLVDS1.10 R767.2 U46.A36
LCD_VCC_TEST_EN: D6.2 U46.A40
LDDC_CLK_PCH: C1332.1 JLVDS1.11 R159.2 UH4.T40
LDDC_DATA_PCH: C1333.1 JLVDS1.12 R160.2 UH4.K47
LED_10_GRN#: R1091.1 U15.2 U31.25
LED_10_GRN#_R: C1324.1 JLOM1.11 R1091.2
LED_100_ORG#: R1090.1 U15.1 U31.27
LED_100_ORG#_R: C1325.1 JLOM1.13 R1090.2
LED_SATA_DIAG_OUT#: D62.1 U46.A10
LED_WWAN_OUT#: JMINI1.42 Q77.3 R719.1
LG_3V: PQ102.4 PU100.12
LG_5V: PQ103.4 PU100.19
LG_+V1.05S_VCCPP: PQ501.4 PU500.6
LG_+V1.05SP: PQ405.4 PU400.6
LGATE1: PQ706.4 PU700.23
LGATE1G: PQ710.4 PQ711.4 PU700.34
LID_CL#: JLID1.2 R807.1 U58.2
LID_CL_SIO#: C716.1 R805.2 R807.2 U46.B54
LPC_LAD0: JMINI3.16 U37.26 U39.26 U46.A27 U51.A30 UH4.C38
LPC_LAD1: JMINI3.14 U37.23 U39.23 U46.A26 U51.B32 UH4.A38
LPC_LAD2: JMINI3.12 U37.20 U39.20 U46.B26 U51.A31 UH4.B37
LPC_LAD3: JMINI3.10 U37.17 U39.17 U46.B25 U51.B33 UH4.C37
LPC_LDRQ1#: U46.A22 UH4.K36
LPC_LDRQ#_MEC: R823.1 U51.B29
LPC_LFRAME#: JMINI3.8 U37.22 U39.22 U46.A21 U51.B31 UH4.D36
LVD_IBG: RH344.2 UH4.AF37
LX_3V: PC108.1 PL101.2 PQ100.1 PQ100.2 PQ100.3 PQ102.5 PR109.1 PU100.11
LX_5V: PC109.2 PL103.1 PQ101.1 PQ101.2 PQ101.3 PQ103.5 PR110.1 PU100.20
M_CLK_DDR0: JDIMM1.101 U1.AU36
M_CLK_DDR1: JDIMM1.102 U1.AT40
M_CLK_DDR2: JDIMM2.101 U1.BA34
M_CLK_DDR3: JDIMM2.102 U1.BA36
M_CLK_DDR#0: JDIMM1.103 U1.AV36
M_CLK_DDR#1: JDIMM1.104 U1.AU40
M_CLK_DDR#2: JDIMM2.103 U1.AY34
M_CLK_DDR#3: JDIMM2.104 U1.BB36
M_ID2#: C1208.1 JCRT1.4
M_ODT0: JDIMM1.116 U1.AY40
M_ODT1: JDIMM1.120 U1.BA41
M_ODT2: JDIMM2.116 U1.AT43
M_ODT3: JDIMM2.120 U1.BG47
MASK_BASE_LEDS#: Q74.2 Q78.2 Q83.2 Q83.5 Q84.2 U58.4
MASK_SATA_LED#: Q74.5 U46.B9
MAX8731_IINP: PC1323.1 PR1329.1 PR1343.1 PU1300.8 R387.2
MAX8731_REF: PC1327.1 PR1311.1 PR1327.1 PR1336.1 PR1338.1 PU1300.3
MAX8731A_LDO: PC1311.1 PD1301.2 PR1310.1 PR1319.1 PU1300.21
MCARD_MISC_PWREN: Q43.2 R733.1 R806.1
MCARD_PCIE_SATA#: R457.2 U46.B3
MCARD_WWAN_PWREN: Q41.2 R726.1 U46.B42
MCARD_WWAN_PWREN#: Q41.5 Q41.6 Q73.2 R721.2
ME_FWP: R793.1 RH50.1 U46.A8
ME_SUS_PWR_ACK: RH144.2 RH323.1 U51.A8 UH4.K16
MEC_XTAL1: C743.1 U51.A61 Y6.1
MEC_XTAL2: C741.1 R1068.2 Y6.2
MEC_XTAL2_R: R1068.1 U51.A62
MEM_SMBCLK: QH5.6 RH302.2 UH4.H14
MEM_SMBDATA: QH5.3 RH303.2 UH4.C9
MIC_IN_L: C1163.1 U72.28
MIC_IN_R: C1163.2 L104.2 R1143.2 U72.29
MINI1CLK_REQ#: JMINI1.7 RH81.1 UH4.J2
MINI2CLK_REQ#: JMINI2.7 RH97.1 UH4.L14
MINI3CLK_REQ#: RH152.1 UH4.A8
MMICLK_REQ#: RH87.2 U38.31 UH4.V10
MOD_SATA_PCIE#_DET: R773.1 U46.A42
MODULE_BATT_PRES#: R764.1 U46.B15
MSATA_DET#: JMINI3.37 R708.2 R711.2 UH4.C41
MSATA_EN: R806.2 R808.1 U46.B53
MSATA_PRX_DTX_N0: C1309.2 JMINI3.25
MSATA_PRX_DTX_N0_C: C1309.1 UH4.AM3
MSATA_PRX_DTX_P0: C1310.2 JMINI3.23
MSATA_PRX_DTX_P0_C: C1310.1 UH4.AM1
MSATA_PTX_DRX_N0: C617.2 JMINI3.31
MSATA_PTX_DRX_N0_C: C617.1 UH4.AP7
MSATA_PTX_DRX_P0: C618.2 JMINI3.33
