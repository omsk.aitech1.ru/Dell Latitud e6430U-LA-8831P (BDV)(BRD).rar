# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP0_R_D-: length 13.2
  IN4 w0.102: v1(312.54,62.42) 312.35,62.23 312.06,62.23 311.78,61.95 311.78,61.33 315.61,57.5 316.43,57.5 316.69,57.24 JUSB1.2
  BOTTOM w0.102: v1(312.54,62.42) 312.54,62.66 312.14,63.06 D72.3 311.62,62.31 311.52,62.21 311.03,62.21 310.82,62 310.6,62 310.15,62.44 L51.2 309.7,62.46 R740.2
USBP1+: length 206.2
  IN3 w0.122: v1(25.46,47.15) 25.67,47.36 40.44,47.36 49.87,37.93 53.99,37.93 54.4,37.52 54.4,20.8 52.11,18.51 52.11,14.7 53.06,13.76 70.03,13.76 75.76,8.02 78.1,8.02 78.61,7.51 86.73,7.51 88.4,9.18 90.96,9.18 98.14,16.36 130.28,16.36 132.3,14.35 134.13,14.35 134.72,13.76 140.94,13.76 141.62,13.08 144.84,13.08 145.23,13.47 146.56,13.47 147.41,14.32 154.02,14.32 154.21,14.13 157.04,14.13 157.5,14.59 159.74,14.59 160.75,15.59 162.4,15.59 163,16.19 163,16.34 164.13,17.47 170.26,17.47 173.43,20.64 173.43,25.32 173.26,25.5 173.26,29.62 173.48,29.84 173.48,30.14 v3(173.66,30.32)
  BOTTOM w0.102: R1707.1 23.93,47.15 L113.1 24.7,47.15 24.95,47.41 25.2,47.41 v1(25.46,47.15) ; v3(173.66,30.32) 173.37,30.6 173.37,30.89 173.13,31.13 171.21,31.13 170.7,30.63 170.38,30.63 170.18,30.82 170.05,30.82 169.91,30.69 169.91,30.56 170,30.46 UH4.B25
USBP1-: length 206.2
  IN3 w0.122: v1(172.9,30.32) 173.13,30.32 173.27,30.18 173.27,29.93 173.04,29.71 173.04,25.41 173.22,25.23 173.22,20.73 170.17,17.69 164.04,17.69 162.78,16.43 162.78,16.28 162.31,15.81 160.66,15.81 159.65,14.8 157.41,14.8 156.95,14.35 154.3,14.35 154.11,14.54 147.32,14.54 146.47,13.69 145.14,13.69 144.75,13.3 141.71,13.3 141.03,13.97 134.81,13.97 134.22,14.56 132.39,14.56 130.37,16.58 98.05,16.58 90.87,9.4 88.31,9.4 86.64,7.73 78.7,7.73 78.19,8.24 75.85,8.24 70.12,13.97 53.15,13.97 52.33,14.79 52.33,18.42 54.62,20.71 54.62,37.61 54.08,38.15 49.96,38.15 40.53,47.58 25.58,47.58 25.56,47.59 25.51,47.59 25.46,47.64 v3(25.46,47.79)
  BOTTOM w0.102: UH4.C25 169.63,30.46 169.93,30.16 170.22,30.16 170.48,30.41 170.79,30.41 171.3,30.91 173.04,30.91 173.16,30.8 173.16,30.57 v1(172.9,30.32) ; v3(25.46,47.79) 25.29,47.62 24.99,47.62 24.85,47.76 24.85,47.86 24.71,48 L113.4 23.93,48 R1705.1
USBP1_R_D+: length 13.6
  IN1 w0.091: v1(16.89,46.24) 16.67,46.45 16.45,46.45 16.19,46.72 16.19,49.31 16.07,49.43 15.39,49.43 15.31,49.35 JUSB3.3
  BOTTOM w0.102: R1707.2 22.97,47.15 L113.2 22.07,47.15 21.76,47.46 20.26,47.46 19.16,46.36 18.69,46.36 18.69,46.36 18.51,46.18 D90.2 17.79,45.51 17.68,45.62 17.68,46.31 17.62,46.37 17.02,46.37 v1(16.89,46.24)
USBP1_R_D-: length 13.6
  IN1 w0.091: v3(16.89,46.87) 16.64,46.63 16.52,46.63 16.36,46.79 16.36,49.38 16.14,49.6 15.4,49.6 15.31,49.69 JUSB3.2
  BOTTOM w0.102: v3(16.89,46.87) 17.17,46.59 17.56,46.59 17.68,46.71 17.68,47.33 17.8,47.44 D90.3 18.51,46.8 18.74,46.57 19.07,46.57 20.17,47.67 21.79,47.67 22.12,48 L113.3 22.97,48 R1705.2
USBP2+: length 156.3
  IN1 w0.091: v1(254.17,30.68) 253.94,30.91 253.94,31.3 253.67,31.57 246.85,31.57 245.65,30.37 237.61,30.37 237.12,29.88 235.48,29.88 232.18,26.57 200.01,26.57 199.29,25.85 194.21,25.85 192.43,27.63 190.91,27.63 188.54,30 182.22,30 180.23,31.99 176.41,31.99 175.54,31.12 172.45,31.12 172.3,31.27 172.3,31.86 v3(172.67,32.22)
  IN3 w0.122: v1(254.17,30.68) 253.94,30.91 253.94,37.25 254.62,37.93 254.62,43.67 254.54,43.75 254.54,54.49 254.25,54.79 254.25,56.86 253.36,57.74 253.36,66.86 254.83,68.33 254.83,75.02 255.35,75.53 255.35,78.65 254.74,79.26 254.74,85.43 251.68,88.49 251.68,89.5 v1(251.86,89.69)
  BOTTOM w0.102: R1680.1 252,91.21 L111.4 252,90.64 251.69,90.33 251.69,89.86 v1(251.86,89.69) ; v3(172.67,32.22) 172.45,32.44 172.28,32.44 172.19,32.35 172.19,31.56 171.96,31.33 171.08,31.33 170.92,31.17 170.74,31.17 UH4.A26
USBP2-: length 156.3
  IN1 w0.084: 172.13,31.2 172.13,31.87
  IN1 w0.091: 172.13,31.87 v1(171.77,32.23) ; 172.13,31.2 172.38,30.95 175.61,30.95 176.48,31.82 180.15,31.82 182.14,29.83 188.46,29.83 190.84,27.46 192.35,27.46 194.14,25.68 199.36,25.68 200.08,26.4 232.25,26.4 235.56,29.7 237.19,29.7 237.68,30.2 245.72,30.2 246.92,31.4 253.6,31.4 253.77,31.23 253.77,30.91 v3(253.54,30.68)
  IN3 w0.122: v3(253.54,30.68) 253.73,30.88 253.73,37.34 254.41,38.02 254.41,43.58 254.33,43.66 254.33,54.4 254.03,54.7 254.03,56.77 253.14,57.65 253.14,66.95 254.61,68.42 254.61,75.11 255.13,75.62 255.13,78.56 254.52,79.17 254.52,85.34 251.46,88.4 251.46,89.45 v1(251.22,89.69)
  BOTTOM w0.102: UH4.C26 169.72,31.05 170.15,31.05 170.49,31.39 170.83,31.39 170.99,31.55 171.87,31.55 171.97,31.65 171.97,32.03 v1(171.77,32.23) ; v1(251.22,89.69) 251.47,89.94 251.47,90.27 251.15,90.6 L111.1 251.15,91.21 R1679.1
USBP2_D+: length 21.6
  IN3 w0.122: v1(246.97,95.19) 247.15,95.01 254.27,95.01 254.79,95.53 254.79,97.58 255.94,98.73 255.94,99.14 255.81,99.27 JESA1.3
  BOTTOM w0.102: v1(246.97,95.19) 247.18,94.98 247.4,94.98 248.78,93.6 249.11,93.6 249.19,93.69 D87.2 250.04,94.56 250.16,94.45 250.16,94.08 250.37,93.86 v1(251.06,93.86) 251.34,93.86 251.68,93.52 251.68,93.11 252,92.8 L111.3 252,92.17 R1680.2
USBP2_D-: length 21.6
  IN3 w0.122: v3(246.97,94.56) 247.21,94.8 254.36,94.8 255.01,95.44 255.01,97.49 256.16,98.64 256.16,99.07 256.36,99.27 JESA1.2
  BOTTOM w0.102: R1679.2 251.15,92.17 L111.2 251.15,92.83 251.47,93.15 251.47,93.43 251.26,93.63 250.65,93.63 250.64,93.65 250.31,93.65 250.16,93.49 250.16,92.73 250.05,92.63 D87.3 249.19,93.24 249.05,93.39 248.69,93.39 247.31,94.76 247.18,94.76 v3(246.97,94.56)
USBP4+: length 131.7
  IN1 w0.084: 174.38,29.18 174.27,29.07 173.37,29.07 173.17,28.86 171.86,28.86 171.39,29.33 171.39,29.74 171.22,29.91 171.22,30.55 169.74,32.03 168.49,32.03 168.36,32.16 168.36,32.66 168.41,32.7 168.62,32.7 168.78,32.54 v1(168.78,32.45)
  IN1 w0.091: v3(250.12,29.62) 250.12,29.51 250,29.4 249.74,29.4 249.52,29.17 247.36,29.17 246.6,28.41 235.93,28.41 231.62,24.1 191.51,24.1 189.69,25.93 187.44,25.93 185.87,27.5 183.59,27.5 182.97,28.12 182.12,28.12 180.19,30.05 177.38,30.05 176.88,29.55 174.76,29.55 174.38,29.18
  IN3 w0.122: v1(248.93,64.94) 249.14,65.15 249.32,65.15 249.49,64.99 249.49,61.11 250.2,60.39 250.2,54.21 249.45,53.46 249.45,50.1 249.98,49.56 249.98,33.85 250.81,33.03 250.81,29.64 250.57,29.41 250.33,29.41 v3(250.12,29.62)
  BOTTOM w0.102: JMINI2.38 247.8,65.89 247.87,65.82 247.87,65.39 248.11,65.15 248.72,65.15 v1(248.93,64.94) ; UH4.D28 168.89,31.95 168.7,32.14 168.7,32.37 v1(168.78,32.45)
USBP4-: length 131.7
  IN1 w0.084: v3(167.95,32.46) 168.19,32.22 168.19,32.09 168.42,31.86 169.67,31.86 171.06,30.48 171.06,29.84 171.23,29.67 171.23,29.26 171.79,28.7 173.24,28.7 173.44,28.9 174.34,28.9 174.45,29.01 174.45,29.01 174.49,29.04 174.49,29.04 174.5,29.05
  IN1 w0.091: v1(250.12,28.99) 247.42,28.99 246.67,28.23 236,28.23 231.69,23.93 191.44,23.93 189.61,25.76 187.37,25.76 185.8,27.33 183.52,27.33 182.9,27.95 182.05,27.95 180.12,29.88 177.45,29.88 176.95,29.38 174.83,29.38 174.5,29.05
  IN3 w0.122: v1(250.12,28.99) 250.32,29.19 250.66,29.19 251.02,29.55 251.02,33.12 250.2,33.94 250.2,49.65 249.67,50.19 249.67,53.37 250.42,54.12 250.42,60.48 249.7,61.2 249.7,65.08 249.41,65.36 249.14,65.36 v1(248.93,65.57)
  BOTTOM w0.102: JMINI2.36 248.6,65.94 248.45,65.8 248.18,65.8 248.08,65.7 248.08,65.47 248.2,65.36 248.72,65.36 v1(248.93,65.57) ; v3(167.95,32.46) 168.31,32.1 UH4.E28
USBP5+: length 129.9
  IN1 w0.084: 173.69,32.09 173.69,31.82
  IN1 w0.091: v1(280.9,36.68) 280.9,36.54 280.82,36.46 279.16,36.46 276.41,33.72 270.87,33.72 269.38,32.22 246.16,32.22 245.79,31.85 236.55,31.85 231.91,27.22 199.69,27.22 198.97,26.5 194.5,26.5 188.09,32.9 181.44,32.9 180.35,34 176.24,34 175.68,33.43 175.68,32.24 175.51,32.07 174.71,32.07 174.33,31.69 173.82,31.69 173.69,31.82 ; 173.69,32.09 173.78,32.18 v3(174.06,32.18)
  BOTTOM w0.102: UH4.A28 170.47,31.95 170.42,32 170.42,32.18 170.51,32.28 170.67,32.28 170.83,32.11 170.93,32.11 171.09,32.27 171.09,32.54 171.44,32.89 173.41,32.89 173.68,32.62 173.68,32.32 173.82,32.18 v3(174.06,32.18) ; JMINI1.38 281.8,41.65 281.88,41.56 282.19,41.56 282.3,41.46 282.3,36.99 281.76,36.45 281.12,36.45 v1(280.9,36.68)
USBP5-: length 129.9
  IN1 w0.091: v1(173.3,32.18) 173.52,31.97 173.52,31.74 173.75,31.51 174.4,31.51 174.78,31.9 175.58,31.9 175.85,32.17 175.85,33.36 176.31,33.82 180.27,33.82 181.37,32.73 188.02,32.73 194.42,26.32 199.04,26.32 199.76,27.04 231.98,27.04 236.62,31.68 245.86,31.68 246.23,32.05 269.45,32.05 270.94,33.54 276.48,33.54 279.23,36.29 280.65,36.29 v3(280.9,36.04)
  BOTTOM w0.102: v3(280.9,36.04) 281.09,36.24 281.85,36.24 282.51,36.9 282.51,41.52 282.6,41.61 JMINI1.36 ; UH4.C28 170.05,31.95 170.35,31.64 170.77,31.64 171.3,32.18 171.3,32.45 171.53,32.67 173.32,32.67 173.47,32.53 173.47,32.35 v1(173.3,32.18)
USBP7+: length 111.5
  TOP w0.102: v3(79.93,9.59) 79.81,9.71 79.43,9.71 79.08,10.07 79.08,10.52 78.82,10.77 JSC1.1
  IN3 w0.102: v1(165.51,31.49) 165.22,31.2 165.22,31.07 164.99,30.85 164.55,30.85 164.52,30.82
  IN3 w0.122: 164.52,30.82 164.52,30.81 163.66,29.94 163.66,26.15 163.29,25.78 163.29,21.48 163.07,21.26 163.07,20.13 161.64,18.7 159.15,18.7 156.23,15.78 154.77,15.78 154.6,15.95 146.84,15.95 146.24,15.35 138.97,15.35 137.45,16.87 134.11,16.87 132.43,18.55 109.45,18.55 107.77,20.23 96.71,20.23 95.42,18.93 83.26,18.93 81.5,17.18 81.5,10.13 81.04,9.67 80.01,9.67 v3(79.93,9.59)
  BOTTOM w0.102: UH4.M28 165.11,31.89 v1(165.51,31.49)
USBP7-: length 111.5
  TOP w0.102: JSC1.2 79.82,10.76 79.56,10.51 79.35,10.51 79.29,10.45 79.29,10.25 79.29,10.25 79.29,10.16 79.52,9.93 79.63,9.93 v1(79.93,10.23)
  IN3 w0.102: 164.32,30.91 164.33,30.93 164.44,31.03 164.45,31.03 164.47,31.04 164.91,31.04 165.02,31.15 165.02,31.42 164.95,31.5 v3(164.66,31.5)
  IN3 w0.122: 164.32,30.91 163.44,30.03 163.44,26.24 163.08,25.87 163.08,21.57 162.85,21.35 162.85,20.22 161.55,18.92 159.06,18.92 156.14,16 154.86,16 154.69,16.16 146.75,16.16 146.15,15.56 139.06,15.56 137.54,17.08 134.2,17.08 132.52,18.76 109.54,18.76 107.86,20.45 96.62,20.45 95.33,19.15 83.17,19.15 81.29,17.27 81.29,10.22 80.95,9.89 80.27,9.89 v1(79.93,10.23)
  BOTTOM w0.102: v3(164.66,31.5) 164.66,31.87 164.58,31.95 UH4.N28
USBP11+: length 166.1
  TOP w0.102: JBT1.12 315.5,27.4 315.14,27.04 312.39,27.04 306.89,32.53 301.64,32.53 v1(301.42,32.75)
  IN1 w0.084: 174.55,34.03 174.54,34.03 174.53,34.02 174.48,34.02 174.48,34.02 173.99,34.02 173.06,33.08 170.66,33.08 169.73,34.02 167.55,34.02 166.4,32.87 165.94,32.87 165.82,32.99 165.82,33.36 165.87,33.41 v3(166.22,33.41)
  IN1 w0.091: v1(301.42,32.75) 301.14,32.46 294.58,32.46 291.56,35.48 285.48,35.48 283.55,37.41 279.1,37.41 277.42,35.73 271.42,35.73 269.12,33.42 246.33,33.42 245.42,32.5 236.29,32.5 231.65,27.86 199.35,27.86 198.64,27.15 194.76,27.15 188.36,33.54 183.23,33.54 181.55,35.22 176.4,35.22 175.2,34.03 174.55,34.03
  BOTTOM w0.102: UH4.K32 166.41,33.56 166.26,33.41 v3(166.22,33.41)
USBP11-: length 166.1
  TOP w0.102: v3(301.42,32.11) 301.63,32.32 306.8,32.32 308.53,30.58 309.31,29.8 312.3,26.82 315.08,26.82 315.5,26.4 JBT1.11
  IN1 w0.084: 174.55,33.85 174.06,33.85 173.13,32.92 170.59,32.92 169.66,33.85 167.62,33.85 166.47,32.7 165.87,32.7 165.65,32.92 165.65,33.2 v1(165.4,33.45)
  IN1 w0.091: v3(301.42,32.11) 301.25,32.29 294.51,32.29 291.49,35.31 285.4,35.31 283.48,37.23 279.17,37.23 277.49,35.56 271.5,35.56 269.19,33.25 246.41,33.25 245.49,32.33 236.36,32.33 231.72,27.69 199.43,27.69 198.71,26.98 194.68,26.98 188.29,33.37 183.15,33.37 181.48,35.05 176.47,35.05 175.27,33.85 174.55,33.85
  BOTTOM w0.102: UH4.L32 165.77,33.83 v1(165.4,33.45)
USBP12+: length 163.8
  IN3 w0.102: v1(168,33.42) 167.66,33.76 167.15,33.76 166.5,34.41 166.5,34.62 166.35,34.77 165.75,34.77 165.13,35.39 165.13,35.75 163.03,37.86 163.03,39.99 163.53,40.49 163.53,40.51 163.55,40.52
  IN3 w0.122: 163.55,40.52 164.07,41.04 166.6,41.04 167.24,41.68 167.88,41.68 169.47,43.27 169.47,44.16 167.65,45.98 167.65,51.22 167.49,51.37 167.49,52.01 163.47,56.03 163.47,58.54 163.37,58.64 163.37,62.83 162.85,63.35 162.85,72.76 161.72,73.9 161.72,89.45 162.38,90.11 162.38,93.48 161.51,94.34 161.51,99.63 162.05,100.17 162.05,100.42 v1(161.83,100.64)
  IN4 w0.091: v3(105.29,106.96) 105.53,107.2 105.53,108.26 106.6,109.33 133.07,109.33 137.71,104.7 149.51,104.7 151.43,102.79 156.15,102.79 158.92,100.01 161.84,100.01 161.99,100.17 161.99,100.48 v1(161.83,100.64)
  BOTTOM w0.102: v1(168,33.42) 168,33.61 168.31,33.93 UH4.E32 ; v3(105.29,106.96) 105.49,106.75 105.49,106.07 107.19,104.37 107.19,97.47 105.56,95.83 103.75,94.03 103.75,89.3 103.52,89.08 103.35,89.08 103.23,89.19 103.23,89.48 103.14,89.58 102.39,89.58 R427.1
USBP12-: length 163.8
  IN3 w0.102: 163.7,40.37 163.68,40.35 163.67,40.35 163.22,39.9 163.22,37.94 165.33,35.84 165.33,35.48 165.83,34.97 166.43,34.97 166.69,34.7 166.69,34.49 167.23,33.96 167.81,33.96 168,34.15 v3(168,34.45)
  IN3 w0.122: 163.7,40.37 164.16,40.82 166.69,40.82 167.33,41.46 167.97,41.46 169.69,43.18 169.69,44.25 167.86,46.07 167.86,51.31 167.71,51.46 167.71,52.1 163.68,56.12 163.68,58.63 163.59,58.73 163.59,62.92 163.07,63.44 163.07,72.85 161.93,73.98 161.93,89.36 162.6,90.02 162.6,93.57 161.73,94.43 161.73,99.54 162.27,100.08 162.27,100.45 v1(162.47,100.64)
  IN4 w0.091: v1(105.92,106.96) 105.7,107.18 105.7,108.19 106.67,109.16 133,109.16 137.63,104.53 149.44,104.53 151.36,102.61 156.07,102.61 158.85,99.84 161.91,99.84 162.17,100.09 162.17,100.34 v1(162.47,100.64)
  BOTTOM w0.102: v1(105.92,106.96) 105.71,106.74 105.71,106.16 107.41,104.46 107.41,97.38 103.97,93.94 103.97,89.21 103.61,88.86 103.21,88.86 103.12,88.78 102.39,88.78 R428.1 ; UH4.G32 167.68,34.12 v3(168,34.45)
USBP12_D+: length 24.5
  BOTTOM w0.102: JLVDS1.35 94.1,108.57 93.95,108.42 93.95,98.37 99.94,92.38 v1(99.94,91.12) 99.94,90.08 99.95,90.07 99.95,89.46 99.94,89.44 99.94,89.33 100.2,89.08 100.41,89.08 100.51,89.18 100.51,89.48 100.61,89.58 101.38,89.58 R427.2
USBP12_D-: length 24.5
  BOTTOM w0.102: R428.2 101.38,88.78 100.6,88.78 100.51,88.86 100.11,88.86 99.73,89.24 v1(99.73,89.74) 99.73,90.79 99.71,90.8 99.71,91.41 99.73,91.42 99.73,92.29 93.73,98.28 93.73,108.42 93.6,108.55 JLVDS1.36
USBP13+: length 54.1
  IN1 w0.091: v3(197.58,27.72) 197.35,27.95 197.35,28.17 197.06,28.45 195.48,28.45 187.13,36.8 183.63,36.8 181.6,38.84 177.46,38.84 176.86,38.24 176.3,38.24 172.17,34.11 171.64,34.11 v1(171.41,34.34)
  BOTTOM w0.102: R742.1 200.67,13.41 L52.1 199.92,13.41 199.82,13.31 199.82,12.99 199.73,12.9 198.99,12.9 198.14,13.75 198.14,19.26 195.88,21.52 195.88,25.09 197.39,26.61 197.39,27.54 v3(197.58,27.72) ; v1(171.41,34.34) 171.41,34.22 171.24,34.05 170.94,34.05 170.61,34.38 170.46,34.38 170.23,34.14 170.23,34.01 170.31,33.93 UH4.A32
USBP13-: length 54.2
  IN1 w0.084: 171.46,33.94 171.57,33.94
  IN1 w0.091: v1(196.94,27.72) 197.18,27.96 197.18,28.09 196.99,28.28 195.41,28.28 187.06,36.63 183.56,36.63 181.52,38.67 177.53,38.67 176.93,38.07 176.37,38.07 172.24,33.94 171.57,33.94 ; 171.46,33.94 171.37,33.85 v3(171.37,33.53)
  BOTTOM w0.102: R741.1 200.67,12.56 L52.4 199.95,12.56 199.83,12.68 198.9,12.68 197.92,13.66 197.92,19.17 195.66,21.43 195.66,25.18 197.18,26.7 197.18,27.49 v1(196.94,27.72) ; v3(171.37,33.53) 171.37,33.54 171.08,33.83 170.91,33.83 170.7,33.63 170.32,33.63 170.21,33.74 169.82,33.74 UH4.C32
USBP13_R_D+: length 49.7
  TOP w0.102: v1(216.46,10.35) 216.88,10.77 216.88,11.84 217.28,12.24 221.04,12.24 222.22,13.42 230.68,13.42 235.34,18.09 235.34,24 234.95,24.39 JFP1.3
  IN4 w0.091: v3(208.24,12.94) 208.7,12.47 208.7,12.02 209.37,11.35 216.14,11.35 216.67,10.82 216.67,10.57 v1(216.46,10.35)
  BOTTOM w0.102: R742.2 201.87,13.41 L52.2 202.55,13.41 202.87,13.1 203.3,13.1 203.61,13.41 204.81,13.41 206.14,12.07 206.41,12.07 206.62,12.29 D73.2 207.4,12.99 207.52,12.86 207.52,12.3 207.65,12.18 208.2,12.18 208.45,12.43 208.45,12.74 208.25,12.94 v3(208.24,12.94)
USBP13_R_D-: length 49.7
  TOP w0.102: v3(217.09,10.35) 217.09,11.75 217.37,12.02 221.13,12.02 222.31,13.21 230.77,13.21 235.56,18 235.56,24 235.95,24.39 JFP1.4
  IN4 w0.091: v3(217.09,10.35) 216.85,10.6 216.85,10.89 216.22,11.52 209.45,11.52 208.87,12.1 v1(208.87,12.94)
  BOTTOM w0.102: R741.2 201.87,12.56 L52.3 202.56,12.56 202.88,12.88 203.39,12.88 203.7,13.19 204.72,13.19 206.05,11.86 206.44,11.86 206.62,11.68 D73.3 207.42,11.06 207.55,11.19 207.55,11.83 207.68,11.96 208.29,11.96 208.67,12.34 208.67,12.73 v1(208.87,12.94)
USBRBIAS: length 7.6
  BOTTOM w0.102: UH4.C33 UH4.B33 170.23,34.58 170.74,34.58 170.94,34.77 173.67,34.77 v2(174.01,34.42) 174.63,33.81 174.63,32.88 175.11,32.4 RH151.1
USH_DET#: length 11.6
  BOTTOM w0.102: v2(176.21,45.84) 175.7,45.84 174.92,46.62 RH164.1 174.64,45.41 173.81,44.57 173.27,44.57 172.46,43.76 172.46,42.6 172.24,42.38 172.24,41.14 171.55,40.46 171.55,39.9 170.54,38.88 UH4.A42
USH_PWR_ON: length 3.2
  TOP w0.102: T117.1 270.99,71.33 270.26,72.06 U46.A18
USH_PWR_STATE#: length 2.7
  TOP w0.102: R1627.1 268.06,82.98 v2(268.06,82.08) 268.06,81.78 267.34,81.06 U46.A34
USH_SMBCLK: length 14.7
  TOP w0.102: v1(285,51.56) 284.56,51.99 284.56,52.35 284.76,52.54 U51.A50 ; R591.1 278.95,46.3 v1(279.9,46.3) 280.41,46.3 280.68,46.57 280.68,47.13 v1(280.47,47.33)
  BOTTOM w0.102: v1(280.47,47.33) 280.68,47.13 280.68,46.65 280.98,46.35 283.89,46.35 284.54,46.99 284.54,51.46 284.64,51.56 v1(285,51.56)
USH_SMBDAT: length 17.8
  TOP w0.102: U51.B53 284.51,54.29 284.49,54.32 284.49,54.77 v1(284.89,55.17) ; R592.1 278.95,46.07 280.5,46.07 280.9,46.47 280.9,47.13 v3(281.11,47.33)
  BOTTOM w0.102: v3(281.11,47.33) 280.9,47.13 280.9,46.75 281.07,46.58 283.8,46.58 284.31,47.09 284.31,51.55 284.49,51.74 284.49,54.78 v1(284.89,55.17)
VAXG_VAL_SENSE: length 28
  TOP w0.102: RC122.2 RC69.1 v2(139.93,72.98) 140.13,72.78 140.13,68.85 137.14,65.86 136.14,65.86 135.5,65.22 135.5,60.18 133.6,58.28 131.77,58.28 131.34,57.85 130.32,57.85 130.07,57.59 128.36,57.59 v5(127.96,57.99)
  BOTTOM w0.102: U1.H45 128.27,57.68 v5(127.96,57.99)
VCI_IN1#: length 3.7
  TOP w0.102: U51.A63 291.26,52.1 v2(292.11,51.25) 292.63,50.73 292.93,50.73 R1156.2
VCI_IN3#: length 5.5
  TOP w0.102: R813.2 295.5,50.44 294.58,51.36 v2(294.58,52.88) 294.58,53.77 293.76,54.6 U51.A1
VCP2: length 2.5
  BOTTOM w0.102: R387.1 155.54,103.63 v2(155.77,103.86) 156.16,104.24 U9.31
VFB: length 1.8
  TOP w0.102: PR1328.1 29.98,24.99 v2(29.98,25.42)
VGA_ID: length 6.8
  TOP w0.102: v1(257.31,75.41) 256.63,74.74 R800.2 R803.1 ; v1(260.28,75.81) 260.27,75.81 U46.B59
  IN1 w0.084: v1(257.31,75.41) 257.49,75.59 258.09,75.59 258.32,75.81 v1(260.28,75.81)
  BOTTOM w0.102: v2(257.84,75.55) 257.7,75.41 v1(257.31,75.41)
VIDALERT_N: length 72.1
  TOP w0.102: v3(132.92,56.93) 132.47,56.47 131.83,56.47 131.3,57.01 130.61,57.01 RC61.2 129.33,56.26 129.24,56.35 RC60.2
  IN1 w0.084: v1(144.75,91.18) 144.75,91.95 144.56,92.14 143.69,92.14 143.31,91.75 143.31,90.89 144.18,90.03 149.96,90.03 150.74,89.24 154.17,89.24 155.75,87.66 155.75,75.35 153.02,72.61 153.02,63.93 149.26,60.17 146.26,60.17 145.64,60.79 137.17,60.79 133.61,57.24 133.23,57.24 v3(132.92,56.93)
  BOTTOM w0.102: PR718.1 144.72,91.16 v1(144.75,91.18)
VIDSCLK: length 65.3
  IN1 w0.084: v1(133.53,56.75) 137.11,60.33 145.45,60.33 146.07,59.71 149.45,59.71 153.47,63.74 153.47,72.43 155.96,74.92 155.96,88.09 154.36,89.7 150.93,89.7 150.14,90.48 144.52,90.48 v3(143.79,91.21)
  BOTTOM w0.102: v1(133.53,56.75) 133.18,56.4 131.51,56.4 U1.B43 ; PR716.1 143.83,91.17 v3(143.79,91.21)
VIDSOUT: length 96.8
  IN1 w0.084: v1(136.92,78.81) 136.4,78.29 136.4,74.37 133.47,71.43 133.47,57.9 v1(133.56,57.81) 133.7,57.81 137.11,61.22 145.85,61.22 146.45,60.63 149.07,60.63 152.56,64.12 152.56,72.8 155.54,75.79 155.54,87.22 153.98,88.78 150.55,88.78 149.77,89.57 143.62,89.57 142.74,90.45 142.74,92.15 143.16,92.57 144.89,92.57 145.64,91.82 v1(145.64,91.18)
  BOTTOM w0.102: v1(145.64,91.18) 145.67,91.15 PR719.1 ; U1.C44 131.37,57.36 133.11,57.36 v1(133.56,57.81) ; v1(136.92,78.81) 136.94,78.83 RC63.2 137.43,80.13 137.43,81.1 136.92,81.61 v2(136.56,81.61)
VLDOIN_1.5V: length 7.4
  TOP w0.102: PJP204.2 v2(38.23,57.74)
  BOTTOM w0.508: v1(35.57,63.76) 35.57,60.82 36.48,59.9 v1(37.75,59.9)
VOL_DOWN: length 1
  TOP w0.102: R1197.2 R887.1
VOL_MUTE: length 2.1
  TOP w0.102: v2(297.64,52.7) 298.13,52.7 R884.2 298.62,53.2 R1169.2
VOL_UP: length 2.1
  TOP w0.102: R886.2 R1118.2 297.16,56.28 v2(297.69,56.28)
VR_EN: length 6.2
  BOTTOM w0.102: PR723.2 148.58,90.53 v2(148.58,91.06)
  BOTTOM w0.203: PU700.9 145.79,87.41 146.96,88.58 146.96,89.05 PR722.2
  BOTTOM w0.254: PR723.2 PR722.2
VR_HOT#: length 7.8
  TOP w0.254: v1(146.46,88.8) 146.46,89.16 146.94,89.64 v2(147.63,89.64) 148.66,89.64 148.79,89.51 148.79,88.96 148.66,88.84 147.44,88.84 147.31,88.71 PR721.2
  BOTTOM w0.203: v1(146.46,88.8) 146.46,88.57 145.39,87.49 PU700.8
VSB_N_001: length 1.8
  TOP w0.102: 38.82,74.76 v2(38.82,76.57)
VSB_N_002: length 4.5
  TOP w0.102: PC17.1 31.88,75.52 v2(31.5,75.91)
  TOP w0.254: PC17.1 PR25.2 31.97,74.64 31.69,74.36 31.69,73.65 31.83,73.51 PQ6.2
VSB_N_003: length 4.1
  TOP w0.254: PR20.1 35.43,74.04 v2(34.84,74.04) 33.94,74.04 33.62,73.72 33.62,73.05 33.81,72.86 PQ6.1
VSET_4021: length 3.2
  BOTTOM w0.102: U9.28 156.37,102.74 156.15,102.53 v2(155.76,102.53) 155.39,102.53 155.24,102.68 C282.1 R406.1
VSUM+: length 11.5
  BOTTOM w0.203: PC738.1 148.61,87.35 v2(148.13,86.87) 148.13,85.57 147.59,85.04 PU700.14
  BOTTOM w0.254: PR755.1 153.71,89.77 PC740.1 152.27,89.77 PC739.1 PR747.1 150.27,89.13 149.84,88.69 PR746.1 149.84,88.17 149.07,87.4 PC738.1
VSUM-: length 66.6
  TOP w0.102: v2(153,88.22) 153.27,88.22 v1(153.5,88)
  IN3 w0.254: v1(153.5,88) 153.17,88.33 149.87,88.33 149.48,87.94 149.48,84.62 151.72,82.38 151.72,79.36 151.92,79.16 151.92,77.66 154.69,74.89 154.69,68.4 152.76,66.47 152.76,63.69 149.07,59.99 145.74,59.99 145.17,60.56 139.87,60.56 138.21,62.23 138.21,66.56 140.63,68.98 v1(140.63,69.58)
  BOTTOM w0.254: PH703.2 139.5,68.87 139.73,69.1 140.14,69.1 140.62,69.58 v1(140.63,69.58) ; v1(153.5,88) 153.64,87.86 PR757.2 PC743.1 152.75,88.02 152.56,88.21 PR724.1 PC739.2 PR747.2 150.31,87.81 150.31,87.7 PR754.1 PR750.2 149.93,86.43 PC738.2
VSUMG+: length 12.6
  TOP w0.254: v1(142.41,87.92) 141.53,88.8 v2(141.53,91.26) v1(141.53,91.92)
  BOTTOM w0.254: PC707.1 PC708.1 141.18,91.56 v1(141.53,91.92) 141.53,92.99 PC709.1 ; PC707.1 139.3,91.2 PR709.1 ; PC707.1 PR707.1 140.24,92.1 PR758.1 ; PU700.1 142.59,87.74 v1(142.41,87.92)
VSUMG-: length 50.9
  TOP w0.102: v1(109.73,91.02) v2(109.73,91.56)
  IN4 w0.254: v1(109.73,91.02) 110.38,91.02 116.72,97.36 121.75,97.36 128.59,90.51 134.85,90.51 135.46,91.12 136.61,91.12 137.34,90.38 v1(138.52,90.38)
  BOTTOM w0.254: PC707.2 139.3,90.28 PR709.2 138.63,90.28 v1(138.52,90.38) ; PC707.2 140.25,90.07 140.7,89.62 PR711.1 PR710.1 PC711.1 ; PC707.2 PC708.2 PR729.1 142.66,90.83 142.66,92.29 PR759.2 ; PH700.2 115.03,91.45 110.17,91.45 v1(109.73,91.02)
VSYNC: length 4.6
  BOTTOM w0.102: UH4.M49 165.15,42.37 165.75,42.97 165.75,43.06 v2(167.06,44.36) 167.86,45.17 RH124.2
VSYNC_BUF: length 224.7
  TOP w0.102: U74.2 13.72,78 13.65,77.92 R1670.1 12.91,77.92 v1(12.57,78.27)
  IN3 w0.122: v1(167.04,50.92) 166.52,51.44 166.52,52.08 162.83,55.76 162.83,57.91 162.22,58.52 162.22,72.5 161.09,73.63 161.09,89.71 161.75,90.37 161.75,93.1 160.09,94.76 v3(160.09,97.76)
  IN4 w0.084: v1(12.57,78.27) 21.46,78.27 22.07,77.67 24.4,77.67 26.92,80.19 26.92,82.33 29.63,85.04 39.29,85.04 42.14,87.89 63.67,87.89 68.5,92.72 77.97,92.72 78.8,93.55 87.22,93.55 94.2,100.53 94.53,100.53 99.82,105.82 113.22,105.82 115.2,107.8 133.04,107.8 137.25,103.59 138.06,103.59 138.98,102.67 149.87,102.67 150.86,101.68 155.52,101.68 158.37,98.83 158.37,98.56 159.18,97.76 v3(160.09,97.76)
  BOTTOM w0.102: v1(167.04,50.92) 167.47,50.49 167.47,47.74 167.86,47.34 RH124.1
VSYNC_CRT: length 4.2
  TOP w0.102: U74.4 13.43,78.65 R1670.2 v2(12.27,79.81) L103.1
VTT_SENSE: length 44.8
  TOP w0.102: v1(115.7,43.9) 115.89,43.71 RC98.2
  TOP w0.254: PR508.2 130.73,11.64 130.98,11.64 131.36,12.02 131.36,15.13 131.06,15.43 131.06,19.01 129.96,20.1 129.3,20.1 125.79,23.61 v4(125.79,24.32) 125.79,25.23 126.59,26.03 126.59,26.51 125.15,27.95 123.91,27.95 123.64,28.22 v1(123.64,28.55)
  IN4 w0.127: v1(123.64,28.55) 123.64,28.52 120.41,31.75 120.41,42.7 120.04,43.06 116.54,43.06 v1(115.7,43.9)
  BOTTOM w0.102: U1.AN16 116.08,43.53 v1(115.7,43.9)
VTT_SENSE_FB: length 1.8
  TOP w0.254: PR507.1 PR508.1 PC510.2
WIGI_RADIO_DIS#: length 12.3
  TOP w0.102: U46.A1 260.34,69.42 259.64,68.73 259.64,64.5 R1728.2 258.58,63.43 v2(256.41,63.43) 255.87,63.97 D92.1 254.64,63.68 R1726.1
WIGI_RADIO_DIS#_R: length 7.5
  TOP w0.102: D92.2 254.74,62.76 R1726.2 252.71,62.76 v2(251.99,63.48) 251.99,63.76 v1(250.94,64.81)
  BOTTOM w0.102: v1(250.94,64.81) 250.58,65.17 250.58,65.48 250.2,65.85 JMINI2.32
WIMAX_LED#: length 23.7
  IN1 w0.084: v3(249.45,57.3) 249.45,61.82 v1(246.12,65.15)
  BOTTOM w0.102: R706.1 249.45,56.37 v3(249.45,57.3) ; Q124.4 237.15,62.46 237.28,62.33 R705.1 237.72,61.95 239.61,63.84 242.17,63.84 242.75,64.42 245.39,64.42 v1(246.12,65.15) 246.2,65.23 JMINI2.42
WIRELESS_LED#: length 215.7
  TOP w0.102: v1(260.26,81.72) 260.84,81.14 U46.A47
  IN3 w0.122: v1(260.81,43.04) 260.81,43.79 260.13,44.47 260.13,54.32 259.82,54.63 259.82,62.48 259.65,62.65 259.65,79.21 260.26,79.82 v1(260.26,81.72)
  IN4 w0.084: v1(260.26,81.72) 260.26,80.17 258.61,78.52 258.61,72.91 257.5,71.8 256.66,71.8 255.83,70.97 248.27,70.97 247.68,71.56 238.53,71.56 235.93,68.96 235.93,64.98 234.58,63.63 234.58,61.76 v1(234.26,61.44) 234.26,60.55 230.55,56.85 230.55,56.55 228.37,54.36 228.37,52.25 221.59,45.47 214.83,45.47 213.77,44.41 194.73,44.41 194.29,44.85 192.69,44.85 191.4,46.15 189.94,46.15 188.93,47.16 188.56,47.16 177.23,58.5 172.48,58.5 170.87,60.11 170.87,72.72 171,72.84 171,73.59 v1(170.46,74.12)
  BOTTOM w0.102: Q77.1 254.51,50.12 252.81,48.42 Q126.1 246.86,47.55 250.63,43.77 260.08,43.77 v1(260.81,43.04) ; Q78.1 163.59,71.83 163.76,71.66 164.7,71.66 164.89,71.85 Q78.3 164.89,72.8 164.95,72.86 R937.2 165.78,74.12 v2(169.31,74.12) v1(170.46,74.12) ; v1(234.26,61.44) 235.79,62.97 Q124.6 235.85,63.25 237.15,64.55 Q124.3
WIRELESS_ON#/OFF: length 432.6
  TOP w0.102: U46.B13 266.09,71.36 v1(266.12,71.4) ; JSNIF1.2 13.5,3.92 v1(13.94,4.35) ; v1(267.56,68.41) 267.34,68.41 267.07,68.14 R766.2 267.54,67.36 v2(267.54,65.28)
  IN1 w0.084: v1(266.12,71.4) 267.07,70.44 267.07,68.89 v1(267.56,68.41) ; v1(67.61,86.4) 67.35,86.65 46.27,86.65 43.63,84.01 43.63,79.85 44.11,79.37 44.11,72.53 45.38,71.26 45.38,54.45 42.23,51.31 42.23,40.12 39.95,37.83 39.95,33.53 39.66,33.24 39.66,26.96 v1(40.42,26.2)
  IN2 w0.122: v1(267.56,68.41) 266.39,67.24 262.77,67.24 261.92,66.39 261.92,64.12 260.44,62.64 255.16,62.64 251.85,59.33 243.56,59.33 241.26,57.03 240.28,57.03 236.45,53.2 234.98,53.2 233,51.22 231.54,51.22 222.26,41.94 222.26,41.33 218.18,37.24 213.49,37.24 211.82,35.57 198.14,35.57 194.15,39.57 193.01,39.57 191.64,40.93 187.38,40.93 181.75,46.56 177.83,46.56 176.97,47.42 176.57,47.42 175.5,48.49 173.24,48.49 172.47,49.27 172.47,49.27 167.09,54.64 167.09,66.42 166.64,66.86 166.64,67.45 165.73,68.36 165.73,78.47 165.54,78.66 165.54,81.44 164.94,82.04 164.94,94.36 164.03,95.27 163.54,95.27 163.39,95.12 163.39,94.07 162.9,93.57 161.31,93.57 160.37,94.51 159.3,94.51 153.66,100.15 137.88,100.15 137.17,100.85 136.32,100.85 136.02,101.14 131.52,101.14 130.54,102.13 112.07,102.13 110.81,100.87 106.07,100.87 103.54,103.4 101.69,103.4 101.19,102.89 101.19,101.61 100.88,101.31 100.37,101.31 99.33,100.26 99.33,96.47 97.34,94.48 88.68,94.48 87.31,93.1 84.16,93.1 77.18,86.13 67.87,86.13 v1(67.61,86.4)
  IN3 w0.122: v1(40.42,26.2) 42.46,24.17 42.46,13.33 35.21,6.08 32,6.08 30.38,4.47 26.7,4.47 25.6,5.57 25.6,10.89 23.79,12.7 20.41,12.7 19.7,11.99 18.64,11.99 17.89,11.24 17.89,9.37 13.94,5.42 v1(13.94,4.35)
WLAN_LAN_DISB#: length 52.2
  TOP w0.102: U46.A64 257.67,71.56 257.49,71.37 v3(256.9,71.37) ; v1(294.18,83.59) 293.81,83.96 293.81,85.79 293.49,86.1 293.49,86.73 293.68,86.91 U15.4
  IN4 w0.084: v1(294.18,83.59) 290.8,83.59 289.95,84.44 284.64,84.44 280.85,80.65 261.09,80.65 258.86,78.42 258.86,72.76 257.47,71.37 v3(256.9,71.37)
WLAN_LED: length 2.8
  TOP w0.254: R1732.2 162.06,60.45 162.48,60.87 162.92,60.87 v2(162.97,60.91) 163.25,61.2 JLED1.6
WLAN_LED#: length 15.7
  BOTTOM w0.102: Q124.1 235.85,65.43 235.73,65.56 R718.1 235.73,66.35 236.3,66.93 v2(236.3,67.46) 237.75,67.46 241.14,64.07 242.07,64.07 242.66,64.65 245.17,64.65 245.4,64.89 JMINI2.44
WLAN_RADIO_DIS#: length 21.2
  TOP w0.102: v2(257.12,67.29) 257.12,67.68 v1(256.8,68) 256.63,67.83 R693.1 255.77,68.2 D31.1 ; v1(256.94,81.09) 257.56,81.71 259.66,81.71 260.34,81.03 U46.A48
  IN3 w0.122: v1(256.94,81.09) 257.35,80.68 257.35,76.68 256.85,76.18 256.85,74.95 256.4,74.5 256.4,70.19 257.15,69.43 257.15,68.36 v1(256.8,68)
WLAN_RADIO_DIS#_R: length 5.3
  TOP w0.102: D31.2 254.69,66.56 v1(254.69,65.53) 255.48,65.53 v2(255.66,65.71) 256.14,66.19 R693.2
  BOTTOM w0.102: JMINI2.20 255,65.84 v1(254.69,65.53)
WWAN_RADIO_DIS#: length 63.5
  TOP w0.102: U46.A53 257.96,77.06 v1(257.79,76.88) 256.81,77.86 255.77,77.86 R774.2
  BOTTOM w0.102: v1(257.79,76.88) 258.35,76.32 265.99,76.32 267.05,75.27 268.25,75.27 268.71,74.81 268.71,73.57 v2(270.62,71.66) 274.15,68.13 277.27,68.13 278.01,67.4 278.01,66.08 279.3,64.78 279.3,56.09 280.32,55.08 281.23,55.08 281.46,55.31 282.2,55.31 283.39,56.5 285.14,56.5 286.27,55.36 286.27,53.87 286.97,53.17 286.97,51.4 286.2,50.63 286.2,49.11 286.47,48.84 286.47,47.48 289,44.95 JMINI1.20
WWAN_SMBCLK: length 5.4
  TOP w0.102: R1159.2 R1157.1 284.7,41.47 284.19,40.97 284.08,40.97 v3(283.81,40.7)
  BOTTOM w0.102: v3(283.81,40.7) 284,40.89 284.38,40.89 284.76,41.27 284.76,41.7 285,41.94 JMINI1.30
WWAN_SMBDAT: length 8.9
  TOP w0.102: R1158.1 v2(283.83,38.78) 283.42,38.78 283.23,38.97 283.23,40.75 v1(283.81,41.33) 283.95,41.19 284.09,41.19 284.47,41.58 284.47,42.15 R1160.2
  BOTTOM w0.102: JMINI1.32 284.2,42.04 284.54,41.7 284.54,41.37 284.29,41.12 284.02,41.12 v1(283.81,41.33)
XDP_DBRESET#: length 217
  TOP w0.102: v1(100.15,84.24) v4(95.34,79.43) 90.68,74.78 JXDP1.18 ; v1(129.63,66.19) 129.63,66.56 RC19.2 128.87,66.95 128.47,66.55 128.47,65.88 128.72,65.63 129.25,65.63 RC26.1 132.7,64.98 135.33,67.61 137.4,67.61 v1(139.4,69.61) ; v1(122.51,20.8) 122.42,20.71 JXDP2.18
  IN1 w0.084: v1(165.92,18.11) 166.13,17.9 166.13,15.48 166.43,15.19 166.43,11.99 165.16,10.71 165.16,10 164.24,9.08 161.21,9.08 155.34,14.95 140.27,14.95 139.69,15.53 139.47,15.53 137.92,17.07 135.54,17.07 135.2,17.42 128.93,17.42 125.09,21.26 122.97,21.26 v1(122.51,20.8) ; v1(129.63,66.19) 129.63,71.65 128.04,73.25 128.04,77.87 v1(128.57,78.39)
  IN3 w0.122: v1(139.4,69.61) 139.4,68.3 137.58,66.49 137.58,62.25 140.27,59.56 140.27,52.76 141.7,51.33 146.44,51.33 146.91,50.86 149.89,50.86 150.44,51.41 156.64,51.41 158.67,49.38 158.67,45.47 159.78,44.36 159.78,42.58 160.22,42.15 160.22,39.62 161.32,38.52 161.32,38.08 162.21,37.2 162.21,35.15 163.74,33.62 163.74,33.28 164.25,32.76 166.48,32.76 167.5,31.75 167.5,30.95 167.84,30.61 169.1,30.61 170.19,29.52 170.19,21.38 170.42,21.15 170.42,20.4 168.13,18.11 v1(165.92,18.11)
  IN4 w0.084: v1(128.57,78.39) 128.08,77.91 126.68,77.91 125.12,79.47 116.41,79.47 115.35,78.41 114.08,78.41 112.98,79.5 106.98,79.5 105.65,80.83 101.81,80.83 99.76,82.88 99.76,83.86 v1(100.15,84.24)
  BOTTOM w0.102: UH4.K3 166.14,19.16 165.84,18.86 165.84,18.19 v1(165.92,18.11)
XDP_DBRESET#_R: length 3.2
  TOP w0.102: v2(128.06,65.33) 128.64,65.33 RC26.2 128.7,64.7 v5(128.36,64.7)
  BOTTOM w0.102: v5(128.36,64.7) 128.17,64.51 127.28,64.51 U1.K58
XDP_HOOK2: length 11.7
  TOP w0.102: RC7.2 91.34,86.76 v2(91.34,82.98) 91.34,78.99 90.13,77.78 JXDP1.12
XDP_PRDY#: length 70.2
  TOP w0.102: v1(93.49,91.22) v4(92.73,91.22) 92.49,91.22 90.07,88.81 90.07,83.26 89.59,82.78 JXDP1.2
  IN1 w0.084: v1(93.49,91.22) 94.85,89.86 94.85,84.65 97.18,82.32 110.73,82.32 114.74,78.32 125.56,78.32 126.14,77.73 126.14,71.56 125.82,71.24 125.82,67.35 125.05,66.58 125.05,65.31 126.67,63.69 126.67,62.56 126.75,62.48 126.75,62.29 v1(126.28,61.82)
  BOTTOM w0.102: U1.N53 125.98,62.12 v1(126.28,61.82)
XDP_PREQ#: length 69.5
  TOP w0.102: v1(126.28,62.46) 126.49,62.46 RC32.2 ; JXDP1.1 89.6,83.28 89.85,83.53 89.85,89.47 v4(90.97,90.59) v1(91.56,91.18)
  IN1 w0.084: v1(126.28,62.46) 125.9,62.84 125.9,64.2 124.87,65.23 124.87,66.76 125.61,67.5 125.61,71.37 125.93,71.7 125.93,77.64 125.46,78.11 114.63,78.11 110.62,82.11 97.09,82.11 94.62,84.58 94.62,89.24 92.68,91.18 v1(91.56,91.18)
  BOTTOM w0.102: v1(126.28,62.46) 125.97,62.77 U1.N55
XDP_RST#_R: length 8.9
  TOP w0.102: JXDP1.17 89.46,75.28 89.54,75.19 90.33,75.19 92.86,77.72 v4(92.86,78.89) RC8.2
XDP_TCLK: length 64.7
  TOP w0.102: JXDP1.26 90.23,70.78 91.33,71.88 91.51,71.88 v4(95.11,75.48) 103.11,83.48 v1(103.11,84.27) ; v5(127.44,63.77) 127.73,64.06 RC40.2
  IN1 w0.084: v1(127.55,79.42) 127.27,79.14 127.27,77.73 127.41,77.6 127.41,69.77 127.51,69.67 127.51,68.31 126.87,67.67 126.87,67.01 127.06,66.83 127.06,65.19 127.44,64.81 v5(127.44,63.77)
  IN4 w0.084: v1(127.55,79.42) 126.63,80.35 107.33,80.35 105.29,82.38 104.21,82.38 103.11,83.48 v1(103.11,84.27)
  BOTTOM w0.102: U1.L56 126.99,63.49 127.28,63.77 v5(127.44,63.77)
XDP_TDI: length 55.3
  TOP w0.102: RC23.2 133.52,81.34 133.52,81.99 133.29,82.22 131.48,82.22 131.11,82.59 129.88,82.59 129.48,82.2 129.48,80.37 128.97,79.86 127.27,79.86 v1(126.84,79.42) ; JXDP1.22 91.3,72.78 v2(96.12,77.59) 101.84,83.31 v1(101.84,84.27)
  IN4 w0.084: v1(126.84,79.42) 126.13,80.14 107.24,80.14 105.33,82.05 104.06,82.05 v1(101.84,84.27)
XDP_TDI_R: length 20.8
  TOP w0.102: RC23.1 RC29.2 132.42,79.78 131.1,79.78 129.19,77.87 129.19,77.71 128.67,77.19 127.76,77.19 v4(127.75,77.19) 126.8,77.19 v1(126.78,77.22)
  IN1 w0.084: v1(126.15,65.89) 126.04,66 126.04,66.76 126.43,67.15 126.43,69.62 126.93,70.11 126.93,77.06 v1(126.78,77.22)
  BOTTOM w0.102: v1(126.15,65.89) 126.46,65.58 U1.M60
XDP_TDO: length 49.3
  TOP w0.102: v1(129.66,78.99) 129.84,78.99 RC35.2 RC24.2 ; JXDP1.20 90.36,73.78 v4(99.43,82.85) 99.43,82.85 100.19,83.61 v1(100.2,83.61)
  IN4 w0.084: v1(100.2,83.61) 100.95,83.61 103.3,81.25 105.83,81.25 107.15,79.93 125.73,79.93 126.66,78.99 v1(129.66,78.99)
XDP_TDO_R: length 21.9
  TOP w0.102: v1(128.19,79.43) 128.9,79.43 129.71,80.24 129.71,81.89 v4(130.03,82.2) 130.19,82.37 131.01,82.37 131.95,81.43 RC24.1
  IN1 w0.084: v1(128.19,79.43) 127.49,78.73 127.49,77.82 127.62,77.69 127.62,69.9 127.77,69.76 127.77,65.62 v1(127.48,65.33)
  BOTTOM w0.102: v1(127.48,65.33) 127.36,65.33 U1.L59
XDP_TMS: length 67.5
  TOP w0.102: v1(102.47,84.27) 102.47,83.4 98.93,79.85 v4(98.93,79.85) 91.35,72.28 JXDP1.23 ; v1(126.84,78.35) 127.37,78.88 128.83,78.88 RC27.2
  IN1 w0.084: v5(127.42,62.55) 127.04,62.93 127.04,64.87 126.87,65.04 126.87,66.76 126.69,66.94 126.69,67.75 127.31,68.37 127.31,69.5 127.2,69.61 127.2,77.49 126.84,77.85 v1(126.84,78.35) 126.42,78.77 117.25,78.77 115.49,80.54 113.12,80.54 110.91,82.74 102.85,82.74 102.47,83.12 v1(102.47,84.27)
  BOTTOM w0.102: U1.L55 127.15,62.82 v5(127.42,62.55)
XDP_TRST#: length 62.8
  TOP w0.102: RC41.2 127.86,62.74 v5(127.46,63.13) ; JXDP1.21 91.19,73.28 v4(92.61,74.69) 100.76,82.84 100.76,83.06 v1(100.75,83.07)
  IN1 w0.084: v5(127.46,63.13) 127.46,63.23 127.91,63.68 127.91,65.19 128.1,65.38 128.1,69.89 127.83,70.15 127.83,77.78 127.7,77.91 127.7,78.18 v1(127.93,78.41)
  IN4 w0.084: v1(100.75,83.07) 102.78,81.04 105.74,81.04 107.07,79.72 125.61,79.72 126.55,78.78 127.56,78.78 v1(127.93,78.41)
  BOTTOM w0.102: v5(127.46,63.13) 127.46,63.22 127.84,63.6 127.84,64.14 U1.J58
XTAL25_IN: length 6.1
  BOTTOM w0.102: RH309.2 161.89,45.51 RH99.1 161.51,45.13 v2(161.51,44.57) 161.51,44.17 162.19,43.49 162.19,43.04 161.87,42.73 161.87,42.1 162.18,41.8 UH4.V47
XTAL25_OUT: length 7.6
  BOTTOM w0.102: YH2.3 162.76,47.92 CH18.2 163.29,46.79 163.29,45.99 RH99.2 162.81,45.51 v2(162.81,44.52) 162.81,43.37 162.18,42.74 UH4.V49
XTALI: length 8.3
  TOP w0.102: Y3.3 292.89,77.5 C471.2 292.16,77.5 291.79,77.14 291.29,77.14 291.13,76.97 291.13,76.57 290.94,76.38 289.17,76.38 v2(288.62,76.93) 288.31,77.24 U31.10
XTALO: length 5.8
  TOP w0.102: U31.9 287.91,76.98 288.88,76.01 v2(290.4,76.01) 291.33,76.01 R1144.2
Z2805: length 3
  TOP w0.508: R1111.1 311.97,74.72 v1(311.96,74.74)
  BOTTOM w0.508: TR1.22 v1(311.96,74.74)
Z2806: length 3
  TOP w0.508: v1(311.94,82.36) 311.96,82.34 R1113.1
  BOTTOM w0.508: TR1.16 v1(311.94,82.36)
Z2807: length 3.1
  TOP w0.508: v1(311.97,76.01) 312.11,76.15 R1112.1
  BOTTOM w0.508: TR1.21 v1(311.97,76.01)
Z2808: length 3.1
  TOP w0.508: v1(311.94,83.63) 312.04,83.73 R1114.1
  BOTTOM w0.508: TR1.15 v1(311.94,83.63)
Z4012: length 3.4
  TOP w0.102: PD4.2 308.45,7.59 v2(308.02,8.02)
  TOP w0.508: PR1.2 309.77,8.4 PD4.2
Z4304: length 7.8
  TOP w0.254: PBATT1.2 v2(56.62,3.87) PR7.1 56.62,7.72 56.18,8.16 PD5.2
Z4305: length 7.5
  TOP w0.254: PD5.3 54.25,8.16 53.93,7.85 PR9.1 v2(53.93,3.9) 53.93,3.18 PBATT1.3
Z4306: length 11.3
  TOP w0.102: v2(48.35,7.59) 51.92,7.59 52.18,7.34 PD6.3
  TOP w0.254: PBATT1.4 51,3.59 PR8.1 49.99,5.19 50.2,5.39 51.82,5.39 52.18,5.75 PD6.3
ZODD_WAKE#: length 4.9
  TOP w0.102: v2(254.28,74.06) 255.5,74.06 R771.1 256.62,73.86 258.13,73.86 258.33,74.06 U46.A59
N17119947: length 14.8
  TOP w0.102: v2(252.47,77.38) v1(253.15,77.38) R797.2 ; U46.B49 261.09,79.55 260.85,79.32 260.85,79.09 v1(261.36,78.58)
  IN1 w0.084: v1(261.36,78.58) 261.47,78.46 261.47,76.71 261.07,76.3 258.43,76.3 258.09,75.97 254.22,75.97 253.15,77.04 v1(253.15,77.38)
N17205875: length 2.4
  TOP w0.102: v2(284.73,68.55) 284.82,68.46 C747.1 R885.2
N17404646: length 2.3
  TOP w0.102: v2(275.99,76.88) C713.1 R795.2
N17405164: length 1.4
  TOP w0.102: R794.2 C712.1
N17481292: length 3.5
  TOP w0.102: R1717.1 253.79,65.53 v1(253.8,65.51) v2(253.8,64.96)
  BOTTOM w0.102: JMINI2.22 254.2,65.91 v1(253.8,65.51)
N17556679: length 4.8
  BOTTOM w0.102: Q51.2 207.85,2.19 208.04,2 209.15,2 R737.2 R750.2 v2(212.03,2.5)
N17561673: length 2.6
  BOTTOM w0.102: Q26.2 R458.2 62.08,88.43 v2(61.82,88.69)
N18070155: length 9.5
  TOP w0.102: v1(256.88,70.74) 256.77,70.63 R765.1 255.24,69.73 v2(254.39,69.73) ; v1(260.99,72.77) 260.53,72.31 U46.B66
  IN1 w0.084: v1(256.88,70.74) 257.41,70.74 259,72.32 260.55,72.32 v1(260.99,72.77)
N18141816: length 5.1
  TOP w0.102: v2(65.89,81.13) v1(65.89,81.9) 65.72,82.07 RD8.2
  BOTTOM w0.102: v1(65.89,81.9) 65.89,82.87 66.47,83.45 JDIMM1.197
N18141908: length 6.9
  TOP w0.102: v2(72.69,82.25) v1(72.69,82.94) 72.83,83.08 RD9.2
  BOTTOM w0.102: v1(72.69,82.94) 70.97,84.65 JDIMM1.201
N18979703: length 4.1
  TOP w0.102: v5(128.59,58.97) 128.24,58.61 127.16,58.61 126.5,57.95 T110.1
  BOTTOM w0.102: v5(128.59,58.97) 128.59,58.98 128.93,59.31 U1.G48
N19217453: length 6.4
  BOTTOM w0.102: Q35.5 306.13,44.66 306.01,44.78 305.6,44.78 305.48,44.65 Q35.6 305.48,43.99 305.29,43.8 304.56,43.8 304.39,43.98 R565.2 304.84,44.73 v2(304.84,47.15)
N19291438: length 4.6
  BOTTOM w0.102: RH309.1 CH19.2 162.45,47.89 162.45,49.46 YH2.1
N20242522: length 1.9
  TOP w0.102: v2(291.13,11.86) CE757.1
  TOP w0.508: CE757.1 RE678.2
N24959979: length 10.6
  TOP w0.102: v2(288.21,70.72) v1(287.52,70.04) R941.1 ; v1(287.44,62.25) 287.51,62.32 U51.B27
  IN1 w0.084: v1(287.52,70.04) 287.97,69.59 287.97,66.77 287.44,66.25 v1(287.44,62.25)
N24963144: length 12.1
  TOP w0.102: R942.1 v1(286.63,70.06) 286.63,70.58 v2(286.43,70.79) ; v1(286.55,61.58) 286.8,61.58 286.99,61.76 286.99,62.59 287.01,62.61 U51.B28
  IN1 w0.084: v1(286.55,61.58) 286.98,62 286.98,63.6 287.11,63.73 287.11,69.58 v1(286.63,70.06)
N25181996: length 2.8
  TOP w0.102: v1(166.2,22.49) 165.82,22.87 164.48,22.87 T104.1
  BOTTOM w0.102: v1(166.2,22.49) 166.41,22.7 UH4.K10
N25312880: length 3.2
  BOTTOM w0.102: U9.14 163.23,102.24 v2(163.58,101.89) 163.68,101.79 R403.1
N25856953: length 5.4
  TOP w0.102: RH360.2 155.24,35.68 v2(155.24,36.19)
  TOP w0.254: RH360.2 156.52,35.9 v1(156.67,35.9) 156.72,35.96 CH96.1
  BOTTOM w0.254: UH4.AG33 157.03,34.54 157.03,35.05 156.67,35.41 v1(156.67,35.9)
N25909465: length 4.8
  TOP w0.102: U74.1 16.43,77.35 R1669.1 18.27,77.87 18.27,78.39 18.52,78.65 U73.1 v2(19.13,79.9)
N26057763: length 9.1
  BOTTOM w0.102: Q39.3 235.4,56.82 R1620.1 236.59,57.1 236.74,56.96 v2(237.13,56.96) 238.96,56.96 239.32,56.59 Q38.3 239.32,54.98 239.57,54.73 240.25,54.73 R714.2 C632.1
N26067861: length 10.1
  TOP w0.102: Q40.3 309.77,38.32 309.94,38.48 v2(310.67,38.48) 313.34,38.48 313.63,38.19 R722.2 C644.1 R1625.1 316.53,37.8 316.53,37.07 316.32,36.86 Q41.3
N26117328: length 7.5
  BOTTOM w0.102: R414.2 131.96,100.05 v2(131.7,99.79) 131.7,98.41 132.56,97.56 Q19.5 Q19.2 Q20.1
N26124934: length 15.5
  BOTTOM w0.102: C293.1 136.4,103.2 v2(137.74,103.2) 138.05,103.2 139.17,102.08 139.17,101.37 139.76,100.78 R1632.1 139.08,99.96 139.01,99.88 Q18.3 137.53,99.88 137.35,99.7 137.35,97.47 136.78,96.91 Q19.3 135.02,96.91 134.83,96.72 134.83,96.33 135.31,95.84 R412.2
N26158006: length 3.6
  BOTTOM w0.102: U4.1 189.4,32.45 R1630.2 C289.1 v2(187.19,32.46)
N26158260: length 6.1
  BOTTOM w0.102: R1624.1 185.97,29.46 185.97,26.85 185.83,26.71 U7.4 185.14,26.71 v2(183.86,25.44)
N27100114: length 4.1
  BOTTOM w0.102: v2(180.36,5.18) 180.36,3.59 R744.2 R735.2 Q52.2
N28286485: length 2.4
  BOTTOM w0.102: Q81.2 166.07,69.17 v2(165.93,69.31) 166.2,69.58 Q80.6
N28286498: length 3.1
  BOTTOM w0.102: v2(167.16,65.01) 167.16,66.02 Q81.1 166.16,66.47 R938.1
N28286535: length 4
  BOTTOM w0.102: D59.1 v2(170.99,68.58) 170.99,68.16 Q74.3
N28286543: length 11.1
  BOTTOM w0.102: Q74.1 168.61,67.68 168.42,67.86 R932.2 168.42,68.98 v2(168.66,69.22) 168.79,69.36 D59.2 D62.2 168.79,72.87 168.64,73.02 168.14,73.02 168.03,72.91 168.03,71.42 167.79,71.18 166.49,71.18 166.2,71.47 Q80.1
N28286560: length 2.9
  BOTTOM w0.102: Q74.6 v2(168.61,64.08) 168.13,63.6 Q75.2
N29179028: length 4.1
  TOP w0.102: R802.2 269.32,68.37 v2(269.32,68.86) 269.32,70.95 268.96,71.31 U46.B18
N29324689: length 5.8
  TOP w0.102: C962.2 23.09,34 v2(22.71,33.61)
  TOP w0.254: C962.2 24.8,34.76 27.02,34.76 27.42,35.16 U72.35
N30881388: length 2.5
  BOTTOM w0.102: R1677.1 311.08,53.43 v2(310.65,53) 310.03,52.38 U75.7
N31208812: length 18.8
  TOP w0.102: JHP1.6 3.39,39.95 4.16,40.72 6.97,40.72
  TOP w0.254: v1(15.25,40.51) 14.74,40.51 v2(14.44,40.81) 13.68,41.56 7.85,41.56 7.01,40.72 6.97,40.72
  BOTTOM w0.254: D82.2 17.35,39.38 17.48,39.51 R1652.1 15.41,40.35 v1(15.25,40.51)
N31233980: length 3.3
  TOP w0.102: v2(288.34,40.72) v1(288.34,41.31) 288.66,41.64 R704.1
  BOTTOM w0.102: v1(288.34,41.31) 288.2,41.45 JMINI1.22
N31465762: length 5.7
  BOTTOM w0.102: RC140.1 v2(107.04,46.1) 107.07,46.1 107.92,46.95 109.32,46.95 109.37,46.9 109.69,46.9 109.74,46.95 110.25,46.95 110.3,46.9 111.05,46.9 U1.BC22
N31485972: length 16.6
  TOP w0.102: v1(271.2,72.89) 271.8,73.49 v2(273.03,73.49) 277.46,73.49 279.57,75.6 R804.1 ; v1(267.36,72.32) 267.88,71.81 U46.B19
  IN4 w0.084: v1(271.2,72.89) 271.17,72.86 267.91,72.86 v1(267.36,72.32)
N31665312: length 92.1
  TOP w0.102: v1(313.44,17.93) R702.2 ; v1(266.63,19.81) v2(266.63,19.06)
  IN1 w0.084: v1(313.44,17.93) 310.48,20.89 289.95,20.89 289.15,20.09 283.11,20.09 282.44,19.42 276.52,19.42 275.69,20.24 267.07,20.24 v1(266.63,19.81)
  IN3 w0.122: v1(266.63,19.81) 265.63,20.81 265.63,26.59 267.52,28.48 267.52,43.57 265.7,45.38 265.7,49.75 264.62,50.83 v1(264.62,56.65)
  BOTTOM w0.102: v1(264.62,56.65) 264.2,57.07 JMINI2.5
N31665315: length 10.1
  BOTTOM w0.102: R700.2 271.66,63.17 271.33,62.84 v2(270.92,62.84) 269.41,62.84 267.92,61.35 266.36,61.35 265,59.99 JMINI2.3
N31665339: length 6
  TOP w0.102: R707.2 v2(241.27,61.27) 241.27,61.55 v1(241.01,61.81)
  BOTTOM w0.102: JMINI2.49 243.4,58.94 243.4,59.88 241.47,61.81 v1(241.01,61.81)
N31835662: length 20.1
  TOP w0.254: PBATT1.6 45.89,1.14 41.49,1.14 41.18,1.46 41.18,5.78 41.94,6.54 v4(45.4,6.54) PD6.2
N31913039: length 1
  BOTTOM w0.254: PR724.2 152.79,88.86 PC740.2
N31914733: length 1.5
  BOTTOM w0.254: PC709.2 PR729.2
N32001476: length 3.2
  TOP w0.102: U44.10 242.6,78.08 R1594.2 v2(243.33,79.86)
N32001574: length 4.5
  TOP w0.102: v2(245.31,74.91) 245.01,74.91 244.52,75.41 243.81,75.41 R747.2 242.64,76.58 U44.7
N32110637: length 2.5
  TOP w0.254: PU200.7 40.79,64.35 v2(41.06,64.08) 41.81,63.33 PR236.2
N32114800: length 7.9
  TOP w0.254: v1(27.98,22.26) 27.98,22.91 PC1335.1 PR1331.1 ; v1(30.26,21.3) 30.08,21.3 PC1334.2 29.6,20.66 29.73,20.53 PU1300.17
  BOTTOM w0.254: v1(30.26,21.3) v2(28.95,21.3) v1(27.98,22.26)
N32114872: length 7.7
  TOP w0.254: PQ1307.3 42.92,30.18 43.29,30.54 PR1339.1 43.56,31.19 44.4,31.19 v2(44.73,30.86) 44.73,28.29 44.22,27.78 PQ1307.6
N32182108: length 14.3
  TOP w0.102: v1(291.92,56.07) 292.14,55.85 U51.B4 ; v1(301.47,53.4) 302.1,53.4 v2(302.23,53.27) 302.23,51.83 R877.1
  IN1 w0.084: v1(291.92,56.07) 292.52,56.07 294.5,54.08 298.57,54.08 299.23,53.43 301.44,53.43 v1(301.47,53.4)
N32182111: length 12.2
  TOP w0.102: R874.1 301.03,53.05 301.03,53.69 v1(301.47,54.12) v2(301.47,54.8) ; v1(294.48,54.82) 294.48,55.01 293.9,55.6 U51.A3
  IN1 w0.084: v1(301.47,54.12) 300.99,53.64 299.43,53.64 298.78,54.29 294.85,54.29 294.48,54.66 v1(294.48,54.82)
N32182140: length 8.6
  TOP w0.102: v1(260.6,85.38) 260.22,85 T125.1 ; U46.B52 259.19,79.31 v1(258.06,80.43)
  BOTTOM w0.102: v1(258.06,80.43) 258.55,80.92 258.55,83.33 v1(260.6,85.38)
N32182143: length 11.7
  TOP w0.102: U46.A49 258.28,79.06 258.05,79.29 v1(258.05,79.67) ; T126.1 v1(259.19,87.49)
  BOTTOM w0.102: v1(258.05,79.67) 257.61,80.11 257.61,85.91 v1(259.19,87.49)
N32182367: length 8.9
  TOP w0.102: T130.1 270.24,82.26 v1(270.29,82.21) ; U46.B36 267.59,79.69 267.49,79.59 267.49,78.64 267.43,78.58 v1(267.03,78.58)
  IN1 w0.084: v1(270.29,82.21) 270.29,82.19 268.53,80.44 267.34,80.44 266.48,79.58 266.48,79.13 v1(267.03,78.58)
N32182370: length 7.3
  TOP w0.102: v1(267.03,79.21) 267.09,79.27 U46.B37 ; T131.1 v1(271.3,82.23)
  IN1 w0.084: v1(267.03,79.21) 267.03,79.52 267.63,80.12 269.21,80.12 271.3,82.22 v1(271.3,82.23)
N32182373: length 1.5
  TOP w0.102: T133.1 265.14,81.8 265.34,81.61 U46.A38
N32182391: length 4.5
  TOP w0.102: U46.A2 260.84,69.52 259.87,68.55 259.87,65.88 T139.1
N32182394: length 11.8
  TOP w0.102: U46.B45 263.09,79.57 262.94,79.42 262.94,78.99 v1(263.37,78.55) ; v1(261.54,86.76) 262.06,87.28 T140.1
  IN1 w0.084: v1(261.54,86.76) 261.08,86.31 261.08,84.22 262.92,82.38 262.92,78.99 263.36,78.55 v1(263.37,78.55)
N32182397: length 10.5
  TOP w0.102: T141.1 261.42,64.83 v1(261.44,64.84) ; v1(262.08,72.03) 261.65,71.6 261.65,71.05 261.59,70.98 U46.B4
  IN2 w0.122: v1(261.44,64.84) 260.97,65.31 260.97,69.32 262.53,70.88 262.53,71.59 v1(262.08,72.03)
N32182400: length 11.3
  TOP w0.102: v1(253.38,73.37) 252.9,72.89 T145.1 ; U46.B62 259.86,74.31 260.03,74.47 260.71,74.47 260.98,74.74 v1(260.98,74.97)
  IN1 w0.084: v1(260.98,74.97) 260.53,74.52 259.6,74.52 258.74,73.66 254.77,73.66 254.6,73.82 253.84,73.82 v1(253.38,73.37)
N32213779: length 1.4
  TOP w0.102: U46.A55 258.31,76.06 258.21,75.96 T148.1
N32248885: length 14.9
  TOP w0.102: T164.1 271.18,84.26 v1(270.85,83.93) ; U46.B23 267.58,73.81 v1(267.39,73.99)
  IN2 w0.122: v1(270.85,83.93) 270.85,82.14 268.47,79.76 268.47,78.39 268.08,78 267.19,78 266.79,77.61 266.79,74.59 v1(267.39,73.99)
N32251566: length 11.7
  TOP w0.102: U46.A24 270.3,75.06 v1(270.35,75.11) ; v1(269.63,83.07) 270.13,83.58 270.13,84.13 T163.1
  IN3 w0.122: v1(270.35,75.11) 269.63,75.83 v1(269.63,83.07)
N32254249: length 3
  TOP w0.102: T162.1 271.56,75.68 v1(271,75.12) 270.56,75.56 U46.A25
N32256934: length 13.7
  TOP w0.102: v1(274.6,81.35) 274.88,81.63 T161.1 ; U46.B28 267.58,76.31 267.3,76.58 v1(267.3,76.77)
  IN2 w0.122: v1(274.6,81.35) 274.19,80.93 270.35,80.93 268.97,79.56 268.97,77.08 268.19,76.3 267.59,76.3 267.3,76.58 v1(267.3,76.77)
N32259621: length 10.2
  TOP w0.102: v1(273.67,81.39) 273.56,81.29 T160.1 ; v1(268,76.74) 268.07,76.81 U46.B29
  IN2 w0.122: v1(268,76.74) 268.72,77.45 268.72,79.66 270.27,81.21 273.49,81.21 v1(273.67,81.39)
N32262310: length 12.3
  TOP w0.102: T159.1 276.22,81.07 v1(275.94,81.35) ; v1(271.72,75.23) 271.14,74.65 270.05,74.65 269.95,74.56 U46.A23
  IN2 w0.122: v1(271.72,75.23) 271.72,79.5 272.79,80.57 275.15,80.57 v1(275.94,81.35)
N32265001: length 7.2
  TOP w0.102: v1(259.49,80.81) 260.09,80.21 U46.B51 ; T158.1 261.68,85.24 v1(261.52,85.39)
  BOTTOM w0.102: v1(259.49,80.81) 259.49,82.58 261.07,84.16 261.07,84.93 v1(261.52,85.39)
N32267694: length 7.3
  TOP w0.102: v1(262.43,81.57) 262.34,81.48 U46.A44 ; T157.1 260.41,86.34 v1(260.61,86.14)
  IN1 w0.084: v1(260.61,86.14) 260.09,85.62 260.09,84.34 261.97,82.46 261.97,82.03 v1(262.43,81.57)
N32270389: length 4.2
  TOP w0.102: U46.B1 260.09,70.43 259.99,70.33 259.82,70.33 259.17,70.98 258.38,70.98 257.04,69.64 T156.1
N32273086: length 4.5
  TOP w0.102: T155.1 256.48,69.56 258.17,71.24 259,71.24 259.06,71.31 U46.B68
N32275785: length 1.5
  TOP w0.102: T154.1 257.78,75.06 U46.A57
N32283925: length 5.2
  TOP w0.102: U46.A6 262.84,69.25 v1(262.99,69.11) ; T151.1 v1(263.02,65.47)
  IN3 w0.122: v1(262.99,69.11) 262.99,65.51 v1(263.02,65.47)
N32294141: length 1.3
  TOP w0.102: T165.1 289.76,65.03 U51.A21
N32296986: length 13.7
  TOP w0.102: U51.B23 289.51,62.62 289.28,62.39 289.28,61.92 v1(289.72,61.49) ; v1(293.49,68.2) 293.96,68.67 R881.2 293.45,69.35 293.45,70.06 292.83,70.69 v2(292.83,71.21)
  BOTTOM w0.102: v1(293.49,68.2) 293.49,65.78 290.15,62.44 290.15,61.92 v1(289.72,61.49)
N32299833: length 12.1
  TOP w0.102: v1(284.74,70.38) 284.74,70.53 T167.1 ; v1(288.53,62.08) 289.01,62.56 U51.B24
  BOTTOM w0.102: v1(288.53,62.08) 288.53,65.41 287.75,66.19 286.8,66.19 285.84,67.14 285.84,69.28 v1(284.74,70.38)
N32302682: length 11.2
  TOP w0.102: U51.A24 288.26,64.13 288.48,64.35 288.48,64.78 v1(288.1,65.17) ; v1(284.03,70.37) 283.32,71.08 T168.1
  BOTTOM w0.102: v1(284.03,70.37) 285.46,68.93 285.46,67.02 287.31,65.17 v1(288.1,65.17)
N32305533: length 7.7
  TOP w0.102: v1(295.14,65.43) 295.1,65.39 T169.1 ; v1(290.65,62.2) 291.01,62.56 U51.B20
  IN1 w0.084: v1(295.14,65.43) 295.12,65.43 291.47,61.78 291.06,61.78 v1(290.65,62.2)
N32308386: length 9.7
  TOP w0.102: v1(279.1,67.26) 279.08,67.28 T170.1 ; v1(281.84,63.21) 281.84,63.22 282.61,63.99 283.35,63.99 284.01,63.33 U51.B34
  BOTTOM w0.102: v1(281.84,63.21) 281.84,63.6 280.51,64.93 280.51,66.29 279.54,67.26 v1(279.1,67.26)
