# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_GPIO22: length 25.8
  TOP w0.102: v1(163.67,20.98) 164.15,20.49 164.15,20.31 164.51,19.95 164.51,19.42 164.97,18.96 166.08,18.96 167.47,17.57 v2(170.08,17.57) 170.08,17.56 174.5,17.56 175.95,16.11 180.11,16.11 182.66,18.66 182.66,20.91 182.76,21.02 RH181.1
  BOTTOM w0.102: UH4.T5 163.28,20.98 v1(163.67,20.98)
PCH_GPIO33: length 13.9
  TOP w0.102: v1(177.72,36.09) 177.78,36.03 177.78,34.43 177.16,33.82 174.58,33.82 174.49,33.91 v2(173.3,33.91) 172.49,33.1 170.99,33.1 169.32,34.77 v1(169.32,35.38)
  BOTTOM w0.102: RH355.2 177.97,35.84 v1(177.72,36.09) ; UH4.C36 169.63,35.69 v1(169.32,35.38)
PCH_GPIO36: length 36
  TOP w0.102: v1(162.62,21.84) 162.48,21.71 162.48,19.3 163.86,17.92 163.86,16.89 165.44,15.31 168.8,15.31 169.17,14.94 171.89,14.94 173.63,13.2 176.14,13.2 176.57,13.64 181.44,13.64 182.54,14.74 183.57,14.74 183.94,15.11 v2(183.94,17.49) 184.55,18.09 RH174.1 185.04,19.72 185.04,20.39 185.59,20.94 185.95,20.94 RH171.1
  BOTTOM w0.102: UH4.V8 162.33,22.13 v1(162.62,21.84)
PCH_GPIO37: length 24.2
  TOP w0.102: v1(164.68,20.51) 164.84,20.36 164.84,19.63 165.18,19.29 166.22,19.29 167.58,17.93 174.77,17.93 176.25,16.45 v2(179.42,16.45) 180.03,16.45 181.87,18.3 RH172.1 182.42,20.09 182.42,20.84 RH173.1
  BOTTOM w0.102: UH4.M5 165.03,20.86 v1(164.68,20.51)
PCH_GPIO45: length 17.7
  IN4 w0.084: v3(174.34,17.07) 173.7,17.7 167.77,17.7 166.6,18.87 165.44,18.87 165.17,19.14 165.17,22.59 164.92,22.84 164.65,22.84 164.43,23.06 164.43,23.37 164.18,23.62 164.18,24.15 v1(163.73,24.6)
  BOTTOM w0.102: RH101.2 174.58,16.82 v3(174.34,17.07) ; UH4.T13 163.58,24.75 v1(163.73,24.6)
PCH_GPIO46: length 23.1
  IN4 w0.084: v1(174.3,16.43) 173.26,17.47 167.59,17.47 166.48,18.59 165,18.59 164.15,19.44 164.15,23.2 163.91,23.44 163.45,23.44 163.26,23.63 163.26,24.86 163.48,25.08 164.88,25.08 165,24.95 165,24.29 165.27,24.03 165.58,24.03 v3(166.08,23.52)
  BOTTOM w0.102: v1(174.3,16.43) 174.8,15.93 RH103.2 ; v3(166.08,23.52) 166.08,23.7 UH4.K12
PCH_GPIO48: length 15.6
  TOP w0.102: v1(165.12,13.84) v4(165.12,13.15)
  IN1 w0.084: v1(165.12,13.84) 163.25,15.71 163.25,17.42 163.45,17.62 163.45,18.37 162.13,19.69 162.13,23.87 v1(162.62,24.36)
  BOTTOM w0.102: v1(165.12,13.84) 164.9,14.06 164.9,15.29 RH166.2 ; UH4.V13 162.22,24.75 v1(162.62,24.36)
PCH_GPIO69: length 5.2
  TOP w0.102: v1(172.09,39.29) 172,39.38 RH260.1 170.62,39.98 v2(171.07,40.43)
  BOTTOM w0.102: v1(172.09,39.29) 171.66,39.29 170.7,38.33 170.14,38.33 UH4.B41
PCH_GPIO74: length 10
  BOTTOM w0.102: RH301.2 177.83,22.88 174.67,22.88 174.22,23.33 173.64,23.33 172.83,24.14 v2(172.57,24.14) 171.1,24.14 170.91,24.33 170.4,24.33 170.29,24.22 169.95,24.22 169.65,24.52 UH4.C13
PCH_INTVRMEN: length 6.3
  TOP w0.102: v1(172.57,26.75) 172.57,27.34 RH38.2 174.06,27.73 v4(174.22,27.57)
  BOTTOM w0.102: UH4.C17 169.58,26.5 170.39,27.31 172.01,27.31 v1(172.57,26.75)
PCH_JTAG_TCK: length 68.8
  TOP w0.102: v1(166.74,20.54) v4(166.74,19.85) 166.74,19.63 167.8,18.56 169,18.56 169.31,18.87 RH59.1 ; JXDP2.26 126.42,20.47 125.62,21.27 123.84,21.27 123.65,21.07 v1(123.65,20.76)
  IN1 w0.084: v1(166.74,20.54) 166.92,20.36 166.92,17.78 167.46,17.24 167.46,15.78 167.2,15.52 167.2,11.06 164.58,8.44 160.95,8.44 154.86,14.53 140.1,14.53 139.52,15.11 139.29,15.11 137.75,16.65 135.37,16.65 135.02,17 128.75,17 125.84,19.91 124.5,19.91 v1(123.65,20.76)
  BOTTOM w0.102: v1(166.74,20.54) 166.64,20.45 UH4.J3
PCH_JTAG_TDI: length 83.2
  TOP w0.102: JXDP2.22 124.42,20.65 v1(124.28,20.79) ; v4(180.79,17.78) 180.47,17.45 v1(180.28,17.45)
  IN1 w0.084: v1(124.28,20.79) 124.77,20.3 125.75,20.3 128.84,17.21 135.11,17.21 135.45,16.86 137.83,16.86 139.38,15.32 139.61,15.32 140.18,14.74 155.25,14.74 161.12,8.87 164.32,8.87 165.37,9.91 165.37,10.6 166.67,11.9 166.67,15.38 166.35,15.69 166.35,18.44 165.18,19.62 165.18,20.82 v1(165.63,21.27)
  IN4 w0.084: v1(180.28,17.45) 179.77,16.94 177.72,16.94 177.25,17.41 174.85,17.41 173.9,18.36 169.52,18.36 169.45,18.29 167.92,18.29 166.07,20.14 166.07,20.83 v1(165.63,21.27)
  BOTTOM w0.102: UH4.K5 166.14,20.86 165.73,21.27 v1(165.63,21.27) ; v1(180.28,17.45) 180.28,15.87 179.46,15.05 RH45.1 RH49.1
PCH_JTAG_TDO: length 65.2
  TOP w0.102: JXDP2.20 123.42,19.65 v1(123,19.23) ; v1(167.72,12.49) v4(167.72,11.77)
  IN1 w0.084: v1(123,19.23) 123.47,19.7 125.76,19.7 128.67,16.79 134.93,16.79 135.28,16.44 137.66,16.44 139.21,14.89 139.43,14.89 140.01,14.32 154.78,14.32 160.86,8.23 166.11,8.23 167.72,9.85 v1(167.72,12.49)
  BOTTOM w0.102: UH4.H1 167.13,17.62 168.15,16.6 170.19,16.6 170.66,16.13 RH47.1 RH43.1 168.69,14.65 168.69,13.45 v1(167.72,12.49)
PCH_JTAG_TMS: length 84.3
  TOP w0.102: JXDP2.23 124.92,19.48 124.67,19.23 v1(123.64,19.23) ; v4(180.71,19.52) 180.71,19.03 v1(180.33,18.65)
  IN1 w0.084: v1(180.33,18.65) 179.91,18.23 178.9,18.23 177.81,19.32 177.81,19.62 176.84,20.59 175.71,20.59 174.91,21.38 170.39,21.38 169.62,22.16 168.44,22.16 v1(167.8,21.51) 167.8,21.09 168.08,20.81 168.08,17.78 168.78,17.07 168.78,10.61 166.19,8.02 160.77,8.02 155.69,13.1 148.94,13.1 148.45,12.62 146.83,12.62 146.14,13.32 140.71,13.32 139.34,14.68 139.12,14.68 137.57,16.23 135.17,16.23 134.82,16.58 128.58,16.58 125.93,19.23 v1(123.64,19.23)
  BOTTOM w0.102: RH48.1 RH44.1 178.63,18.03 179.71,18.03 v1(180.33,18.65) ; UH4.H7 167.78,21.5 167.8,21.52 v1(167.8,21.51)
PCH_PCIE_WAKE#: length 180.2
  TOP w0.102: v1(291.26,64.54) U51.A18
  IN2 w0.122: v3(172.47,20.66) 174.52,20.66 175.99,19.19 177.64,19.19 178.62,18.21 181.07,18.21 183.51,20.65 185.26,20.65 185.42,20.81 186.16,20.81 186.75,20.22 189.74,20.22 190.33,20.81 199.64,20.81 199.77,20.94 201.39,20.94 201.98,20.35 217.86,20.35 221.04,23.53 230.48,23.53 235.59,28.64 238.8,28.64 241.13,30.98 245.31,30.98 246.64,32.31 256.77,32.31 258,33.54 261.47,33.54 263.32,31.69 280.53,31.69 285.46,36.62 292.12,36.62 293.24,37.74 297.96,37.74 v1(298.57,37.13)
  IN3 w0.122: v1(291.26,64.54) 297.6,64.54 298.94,63.2 298.94,49.1 297.98,48.14 297.98,43.61 299.38,42.2 299.38,39.65 298.57,38.83 v1(298.57,37.13)
  BOTTOM w0.102: RH142.2 172.56,20.57 v3(172.47,20.66) 170.77,22.36 170.26,22.36 UH4.B9
PCH_PLTRST#: length 164
  TOP w0.102: v1(98.7,83.64) 96.91,81.85 v4(95.88,81.85) RC8.1
  IN3 w0.122: v1(169.34,20.64) 169.96,21.26 169.96,29.43 169.01,30.39 167.75,30.39 167.27,30.86 167.27,31.65 166.39,32.54 164.16,32.54 163.51,33.18 163.51,33.53 161.93,35.11 161.86,35.11 161.27,35.7 161.27,36.01 159.95,37.32 159.48,37.32 159.26,37.54 159.26,42.13 158.73,42.66 158.73,44.75 158.2,45.28 158.2,49.18 156.45,50.94 150.72,50.94 150.1,50.32 141.29,50.32 139.81,51.81 139.81,59.37 137.1,62.07 137.1,66.85 138.93,68.68 138.93,73.07 138.55,73.45 v1(138.55,79.63)
  IN4 w0.084: v1(169.34,20.64) 169.82,21.12 173.21,21.12 173.43,21.34 180.39,21.34 180.76,20.96 v1(180.76,20.13) ; v1(138.55,79.63) 138.12,79.19 137.58,79.19 136.8,79.98 136.8,80.5 134.99,82.31 132.99,82.31 130.82,80.13 127.65,80.13 127.01,80.77 107.52,80.77 103.58,84.71 99.75,84.71 98.7,83.67 v1(98.7,83.64)
  BOTTOM w0.102: UH4.C6 169.63,20.93 v1(169.34,20.64) ; UC1.2 136.82,71.97 136.6,72.19 136.6,74.18 138.19,75.78 138.19,77.86 138.55,78.22 v1(138.55,79.63) ; UH3.1 181.33,17.57 181.48,17.43 181.81,17.43 181.98,17.61 UH3.2 181.98,19.35 RH336.2 RH338.2 181.68,20.13 v1(180.76,20.13)
PCH_PLTRST#_BUF: length 13.8
  BOTTOM w0.102: RC4.2 RC10.1 140.56,72.97 140.64,73.05 140.64,74.85 140.51,74.98 139.53,74.98 139.4,75.11 139.4,77.84 139.27,77.97 138.7,77.97 138.58,77.84 v2(138.58,74.17) 138.58,72.76 138.72,72.62 UC1.4
PCH_PLTRST#_EC: length 341.8
  TOP w0.102: R704.2 288.66,44.87 288.17,45.36 286.71,45.36 285.52,44.16 v1(284.98,44.16) ; v1(84.3,5.35) 82.82,6.82 JSC1.5 ; v1(268,73.31) U46.B22 ; v1(284.72,61.63) 285.18,61.16 285.86,61.16 286.1,61.4 286.1,62.51 286.01,62.6 U51.B30 ; v1(266.48,32.71) 264.64,30.87 261.21,30.87 R703.1 260.77,30.49 259.78,31.48 256.53,31.48 v1(255.77,30.72) ; R1717.2 254.67,68.65 v1(256.69,68.65)
  IN1 w0.084: v1(284.72,61.63) 284.19,62.15 284.19,63.55 283.08,64.66 279.57,64.66 v1(277.31,66.93) 276.26,66.93 271.08,72.11 269.2,72.11 v1(268,73.31)
  IN2 w0.122: v1(268,73.31) 267.55,72.86 261.65,72.86 261.3,73.21 260.12,73.21 259.76,72.84 259.76,70.84 257.57,68.65 v1(256.69,68.65)
  IN3 w0.122: v1(284.98,44.16) 284.43,44.71 284.43,52.73 285.39,53.68 285.39,55.43 285.48,55.52 285.48,59.14 285.26,59.36 285.26,60.73 284.72,61.27 v1(284.72,61.63) ; v3(183.33,15.24) 183.33,14.13 179.12,9.93 174.59,9.93 174.33,9.66 165.79,9.66 164.73,10.72 159.82,10.72 159.49,11.06 154.01,11.06 153.55,10.6 150.77,10.6 150.57,10.41 147.4,10.41 146.74,11.06 140.86,11.06 140.18,11.74 132.13,11.74 130.32,13.55 127.29,13.55 126.44,14.4 116.76,14.4 115.54,13.19 110.59,13.19 109.62,14.16 105.36,14.16 104.77,13.56 99.55,13.56 91.34,5.35 v1(84.3,5.35) ; v1(254.57,23.47) 255.77,24.67 v1(255.77,30.72) 256.07,31.02 256.07,37.4 257.02,38.34 257.02,40.58 257.47,41.04 257.47,43.87 257.08,44.26 257.08,46.45 257.63,47.01 257.63,61.56 255.99,63.2 255.99,67.3 256.3,67.61 256.3,68.26 v1(256.69,68.65)
  IN4 w0.084: v3(183.33,15.24) 183.97,14.59 196.46,14.59 201.87,20.01 219.59,20.01 220.19,20.6 233.13,20.6 235.8,23.28 254.38,23.28 v1(254.57,23.47)
  BOTTOM w0.102: v3(183.33,15.24) 182.83,15.24 182.63,15.44 UH3.4 ; v1(277.31,66.93) 273.45,63.07 273.45,58.49 270.88,55.93 269.93,55.93 268.78,54.78 U37.16 U39.16 ; v1(266.48,32.71) 267.09,32.1 JMINI3.17
PCH_PLTRST#_R: length 27.5
  TOP w0.102: v5(130.85,56.6) 131.3,56.15 133.58,56.15 134.12,56.69 134.12,58.18 136,60.06 136,64.89 136.47,65.36 137.93,65.36 141.67,69.11 141.67,71.42 v4(141.51,71.59) 140.81,72.29 140.81,73.76 v1(140.05,74.52)
  BOTTOM w0.102: v5(130.85,56.6) 130.41,57.04 U1.D44 ; v1(140.05,74.52) RC10.2
PCH_PWRBTN#_XDP: length 7.4
  TOP w0.102: RH21.2 113.33,20.98 v3(113.51,20.98) ; JXDP2.11 118.92,20.59 v1(118.68,20.83)
  IN1 w0.084: v1(118.68,20.83) 118.17,20.32 114.17,20.32 v3(113.51,20.98)
PCH_PWRGD#: length 196.3
  TOP w0.102: Q50.1 282.88,67.84 282.69,67.65 v1(282.39,67.65) 281.97,68.07 R893.2
  IN4 w0.084: v1(282.39,67.65) 281.26,68.78 276.54,68.78 275.72,69.59 260.91,69.59 259.58,68.26 258.17,68.26 256.84,69.58 256.41,69.58 255.72,70.27 247.99,70.27 247.33,70.93 238.79,70.93 236.56,68.7 236.56,64.72 235.21,63.37 235.21,60.61 231.18,56.58 231.18,56.28 229.11,54.21 229.11,51.94 222.87,45.7 222.87,44.41 216.37,37.91 199.33,37.91 191.31,45.94 189.86,45.94 188.84,46.95 188.48,46.95 177.14,58.29 172.39,58.29 170.63,60.06 170.63,72.65 170.01,73.26 170.01,75.96 170.58,76.53 170.58,80.03 167.99,82.62 167.99,97.15 169.98,99.15 169.98,103.36 169.72,103.63 v1(166.49,103.63)
  BOTTOM w0.102: v2(282.95,67.78) 282.82,67.65 v1(282.39,67.65) ; R391.1 166.49,103.63 v1(166.49,103.63)
PCH_RI#: length 5.2
  BOTTOM w0.102: RH140.2 173.49,21.5 v2(172.7,22.28) 172.09,22.9 170.66,22.9 UH4.A10
PCH_RSMRST#: length 128.9
  TOP w0.102: v1(186.54,28.37) v2(185.76,28.37) ; U51.B47 283.85,56.35 v1(284.13,56.06) ; R892.2 v1(281.02,56.45)
  IN1 w0.084: v1(284.13,56.06) 283.83,56.06 283.06,55.3 281.75,55.3 281.02,56.03 v1(281.02,56.45)
  IN2 w0.122: v1(186.54,28.37) 186.82,28.37 187.85,29.4 192.61,29.4 194.77,27.24 199.21,27.24 200.02,28.05 229.02,28.05 238.39,37.41 246.12,37.41 247.52,38.82 253.19,38.82 254.11,37.9 270.6,37.9 272.27,39.56 278.7,39.56 279.72,40.59 v1(281.54,40.59)
  IN3 w0.122: v1(281.54,40.59) 281.21,40.59 280.24,41.56 280.24,42.19 279.82,42.61 279.82,44.67 278.99,45.5 278.99,47.55 279.78,48.34 279.78,55.87 R892.2 v1(281.02,56.45)
  BOTTOM w0.102: R1623.1 v1(186.54,28.37) 186.9,28.01 U7.1
PCH_RSMRST#_Q: length 116.2
  TOP w0.102: v1(119.74,22.46) RH24.1 ; v1(186.07,30.68) v4(186.84,30.68)
  IN1 w0.084: v1(119.74,22.46) 120.47,21.74 125.21,21.74 129.1,17.84 135.37,17.84 135.72,17.5 138.1,17.5 139.64,15.95 139.87,15.95 140.45,15.37 155.51,15.37 161.38,9.5 164.06,9.5 164.52,9.96 v1(164.52,10.26)
  IN2 w0.122: v1(186.07,30.68) 175.16,30.68 173.75,29.27 v1(172.62,29.27)
  IN3 w0.122: v1(186.07,30.68) 185.6,30.21 185.6,27.86 184.71,26.97 184.71,25.78 185.08,25.41 185.08,23.66 184.27,22.85 184.27,21.61 183.19,20.53 183.19,18.08 183.87,17.4 183.87,14.01 179.32,9.46 174.79,9.46 174.52,9.2 165.58,9.2 v1(164.52,10.26)
  BOTTOM w0.102: R1623.2 R1624.2 186.81,30.68 v1(186.07,30.68) ; RH113.2 174.31,30.22 RH145.2 173.35,29.29 172.64,29.29 v1(172.62,29.27) 172.62,29.29 171.65,28.31 170.68,28.31 170.19,28.8 169.96,28.8 169.65,28.48 UH4.C21
PCH_RTCRST#: length 40.7
  TOP w0.102: v1(190.77,26.92) v4(190.77,26.2)
  IN4 w0.084: v1(168.66,28.53) 170.96,28.53 171.2,28.29 173.07,28.29 173.36,28 174.97,28 178.36,24.61 182.97,24.61 184.14,25.78 189.63,25.78 v1(190.77,26.92)
  BOTTOM w0.102: CH4.2 189.29,37.85 189.34,37.9 RH22.2 189.83,37.67 192.03,35.47 192.03,35.14 192.73,34.44 192.73,32.31 192.37,31.95 CMOS1.2 192.03,31.94 192.03,29.66 190.77,28.41 v1(190.77,26.92) ; UH4.D20 168.95,28.24 v1(168.66,28.53)
PCH_RTCX1: length 9.1
  BOTTOM w0.102: UH4.A20 170.58,28.04 174.07,28.04 174.26,27.85 174.91,27.85 RH2.1 176.1,28.19 CH2.1 176.29,28.23 v2(177.25,29.19) YH1.1
PCH_RTCX2: length 6.9
  BOTTOM w0.102: RH286.2 175.34,27.36 RH2.2 175.22,27.24 174.29,27.24 v2(173.83,27.69) 172.29,27.69 172.28,27.68 170.4,27.68 170.09,27.99 UH4.C20
PCH_RTCX2_R: length 2.9
  BOTTOM w0.102: RH286.1 CH3.1 177.27,26.69 YH1.2
PCH_SDVO_CTRLCLK: length 152.1
  TOP w0.102: v1(164.66,37.16) 163.81,37.16 163.04,37.93 RH351.2
  IN2 w0.102: 163.55,41.97 163.11,41.53 163.11,40.17 163.01,40.07 163.01,39.53 162.92,39.44 162.92,38.03 163.56,37.39 164.43,37.39 v1(164.66,37.16)
  IN2 w0.122: v1(87.76,91.2) 87.55,91.42 87.55,91.58 89.2,93.23 98.51,93.23 101.81,96.53 107.69,96.53 108.18,97.02 114,97.02 114.86,97.88 132.45,97.88 134.18,96.15 139.09,96.15 141.62,93.62 145.81,93.62 149.2,90.22 153.26,90.22 158.78,84.7 158.78,81.96 158.3,81.48 158.3,70.45 159.83,68.91 159.83,52.23 159.01,51.41 159.01,48.02 163.68,43.36 163.68,42.1 163.55,41.97
  BOTTOM w0.102: UH4.P38 164.36,36.86 v1(164.66,37.16) ; Q120.1 98,89.19 98.18,89.37 98.56,89.37 99.15,88.77 99.15,87.38 v2(98.97,87.2) 98.67,86.89 91.39,86.89 87.57,90.71 87.57,91.01 v1(87.76,91.2)
PCH_SDVO_CTRLCLK_R: length 35
  IN1 w0.084: JHDMI1.15 79.08,103.39 80.22,103.39 80.64,102.97 80.64,102.44 80.09,101.89 80.09,101.55 78.12,99.59 78.12,98.45 82.98,93.59 85.99,93.59 86.23,93.83 86.23,94.16 v3(85.97,94.41)
  BOTTOM w0.102: v3(85.97,94.41) 86.21,94.65 86.21,95.23 86.66,95.68 88.17,95.68 93.73,90.12 94.98,90.12 R1153.1 95.57,90 97.77,90 98,90.23 Q120.6
PCH_SDVO_CTRLDATA: length 157.7
  TOP w0.102: v1(164.66,37.84) v2(164.01,37.84) 163.59,37.84 RH352.2
  IN2 w0.102: 163.35,41.34 163.35,40.05 163.24,39.93 163.24,39.44 163.15,39.35 163.15,38.12 163.66,37.62 164.44,37.62 v1(164.66,37.84)
  IN2 w0.122: 163.35,41.34 163.72,41.71 163.72,41.79 163.93,42 163.93,43.46 159.26,48.13 159.26,51.31 160.08,52.12 160.08,69.02 158.54,70.55 158.54,81.38 159.03,81.86 159.03,84.81 153.36,90.47 149.31,90.47 145.91,93.87 141.72,93.87 139.19,96.4 134.28,96.4 132.56,98.13 114.76,98.13 113.9,97.27 108.07,97.27 107.59,96.78 101.71,96.78 98.4,93.48 89.09,93.48 87.3,91.68 87.3,91.39 v1(87.1,91.2)
  BOTTOM w0.102: UH4.M39 164.97,37.52 v1(164.66,37.84) ; Q120.4 96.7,91.41 97.12,91.83 98.21,91.83 98.62,91.42 98.62,89.63 99.4,88.86 99.4,87.13 98.93,86.66 91.28,86.66 87.33,90.61 87.33,90.97 v1(87.1,91.2)
PCH_SDVO_CTRLDATA_R: length 31.7
  IN1 w0.084: v3(86.67,94.41) 86.44,94.18 86.44,93.74 86.07,93.38 82.89,93.38 77.91,98.36 77.91,99.68 79.88,101.64 79.88,101.89 JHDMI1.16
  BOTTOM w0.102: Q120.3 96.7,89.56 96.5,89.76 95.45,89.76 R1152.1 94.89,89.86 93.66,89.86 88.07,95.45 86.76,95.45 86.44,95.13 86.44,94.64 v3(86.67,94.41)
PCH_SMB_ALERT#: length 16.3
  TOP w0.102: v1(179.06,18.66) 178.3,17.9 v2(178.3,17.9)
  IN1 w0.084: v1(179.06,18.66) 176.93,20.8 175.79,20.8 174.95,21.64 171.04,21.64 169.66,23.02 169.66,23.66 169.32,24 168.41,24 v1(167.96,24.46)
  BOTTOM w0.102: v1(167.96,24.46) 168.31,24.1 UH4.E12 ; RH304.2 v1(179.06,18.66)
PCH_SPI_CLK: length 124.7
  TOP w0.102: v1(208.76,11.35) 209.88,11.35 210.3,11.77 210.3,14.27 208.74,15.83 208.74,17.99 207.37,19.36 202.71,19.36 201.05,21.03 v2(199.95,21.03) 199.13,21.03 R906.2
  IN2 w0.122: v1(208.76,11.35) 208.52,11.58 204.47,11.58 203.14,12.91 198.31,12.91 197.43,12.04 192.84,12.04 189.99,9.18 179.06,9.18 178.53,9.72 173.28,9.72 169.3,13.7 169.3,14.51 168.35,15.46 165.3,15.46 163.11,17.65 v1(162.69,17.65)
  IN3 w0.122: v1(208.36,39.75) 209.56,38.55 209.56,16.38 211.3,14.64 211.3,13.56 209.08,11.35 v1(208.76,11.35)
  BOTTOM w0.102: R899.2 v1(208.36,39.75) ; UH4.T3 163.17,19.15 163.51,18.8 163.51,18.08 163.09,17.65 v1(162.69,17.65) ; v1(208.76,11.35) 208.37,11.35 208.25,11.22 208.25,10.96 208.37,10.83 209.16,10.83 209.29,10.96 209.29,12.21 209.42,12.34 209.7,12.34 209.82,12.21 209.82,11.24 209.95,11.11 210.2,11.11 210.33,11.24 210.33,13.75 210.46,13.88 210.67,13.88 210.8,13.75 210.8,12.4 210.92,12.28 211.09,12.28 211.21,12.4 211.21,13.75 211.33,13.88 211.6,13.88 211.73,13.75 211.73,12.88 211.85,12.75 212.11,12.75 212.24,12.88 212.24,13.74 212.36,13.87 212.62,13.87 212.74,13.74 212.74,13.12 212.87,12.99 213.16,12.99 213.29,13.12 R897.2
PCH_SPI_CS0#: length 74.1
  IN2 w0.102: 174.55,23.36 173.44,23.36 173.08,23.72 170.94,23.72 169.64,25.02 162.43,25.02 161.98,24.57 161.27,24.57 v1(160.7,25.14)
  IN2 w0.122: v3(213.58,25.84) 213.58,24.66 213.37,24.45 212.95,24.45 212.83,24.57 212.83,25.01 212.71,25.13 212.46,25.13 212.34,25.01 212.34,24.57 212.22,24.45 211.98,24.45 211.85,24.57 211.85,25.27 211.73,25.4 211.49,25.4 211.37,25.27 211.37,24.57 211.24,24.45 211,24.45 210.88,24.57 210.88,25.24 210.75,25.37 210.52,25.37 210.39,25.24 210.39,24.57 210.27,24.45 210.03,24.45 209.9,24.58 209.9,25.19 209.77,25.32 209.56,25.32 209.43,25.19 209.43,24.58 209.3,24.45 208.98,24.45 208.86,24.57 208.86,25.16 208.73,25.28 208.5,25.28 208.37,25.16 208.37,24.57 208.25,24.45 208.01,24.45 207.88,24.57 207.88,25.02 207.76,25.14 207.52,25.14 207.4,25.02 207.4,24.57 207.27,24.45 207.03,24.45 206.91,24.57 206.91,25.02 206.79,25.14 206.54,25.14 206.42,25.02 206.42,24.57 206.3,24.45 205.9,24.45 205.78,24.57 205.78,24.97 205.65,25.09 205.29,25.09 205.17,24.97 205.17,24.57 205.04,24.45 204.68,24.45 204.56,24.57 204.56,24.97 204.44,25.09 204.07,25.09 203.95,24.97 203.95,24.57 203.83,24.45 203.37,24.45 203.24,24.58 203.24,24.89 203.12,25.02 200.64,25.02 200.51,24.89 200.51,24.31 200.39,24.18 200.08,24.18 199.95,24.31 199.95,24.89 199.83,25.02 194.91,25.02 194.78,24.89 194.78,24.26 194.66,24.14 194.29,24.14 194.17,24.26 194.17,24.84 194.05,24.97 193.68,24.97 193.56,24.84 193.56,24.26 193.44,24.14 185.91,24.14 184.51,22.74 180.16,22.74 179.22,21.81 176.42,21.81 174.87,23.36 174.55,23.36
  BOTTOM w0.102: v3(213.58,25.84) 213.12,26.3 R935.1 ; v1(160.7,25.14) 160.99,25.43 UH4.Y14
PCH_SPI_CS0_R#: length 21.2
  BOTTOM w0.102: JTAA1.11 204.55,21.5 206.1,19.95 213.72,19.95 214.13,20.36 214.13,25.94 212.86,27.21 R935.2 211.78,27.74 U52.1
PCH_SPI_CS1#: length 91.1
  TOP w0.102: v2(203.54,13.22) 203.76,13.45 v1(203.76,13.97)
  IN2 w0.122: v1(163.02,18.16) 163.19,17.99 164.97,17.99 165.49,17.47 165.88,17.47 166.27,17.08 167.31,17.08 167.8,16.59 169.32,16.59 174.54,11.37 181.43,11.37 182.62,10.18 187.25,10.18 190.36,13.29 197.28,13.29 197.89,13.91 203.7,13.91 v1(203.76,13.97)
  IN3 w0.122: v1(203.76,13.97) 204.36,14.56 205.3,14.56 205.42,14.69 205.42,14.93 205.3,15.05 203.46,15.05 203.33,15.18 203.33,15.41 203.46,15.54 206.55,15.54 206.63,15.62 206.63,15.95 206.55,16.03 203.46,16.03 203.33,16.15 203.33,16.6 203.46,16.73 206.52,16.73 206.65,16.85 206.65,18.04 206.52,18.17 203.38,18.17 203.26,18.3 203.26,18.53 203.38,18.66 206.49,18.66 206.62,18.79 206.62,19.02 206.49,19.15 203.38,19.15 203.26,19.27 203.26,19.51 203.38,19.63 206.48,19.63 206.61,19.76 206.61,20 206.48,20.12 203.4,20.12 203.27,20.25 203.27,20.51 203.4,20.63 206.32,20.63 206.52,20.84 v1(206.52,21.38)
  BOTTOM w0.102: v1(163.02,18.16) 163.17,18.31 UH4.T1 ; v1(206.52,21.38) 206.52,23.82 207.42,24.72 R936.1
PCH_SPI_CS1_R#: length 9.8
  BOTTOM w0.102: JTAA1.5 205.09,23 207.42,25.33 v2(207.56,25.33) 208.9,25.33 R936.2 208.98,24.2 208.23,24.2 208,23.96 U53.1
PCH_SPI_DIN: length 78.7
  TOP w0.102: v1(212.95,25.85) 212.95,23.21 209.97,20.24 v2(208.98,20.24) 204.84,20.24 R896.1 203.15,21.93 v1(202.33,21.93)
  IN2 w0.122: v1(201.2,11.78) 198.31,11.78 197.82,11.29 193.15,11.29 189.89,8.03 180.29,8.03 179.63,8.69 178.86,8.69 178.32,9.22 173.07,9.22 168.8,13.5 168.8,14.31 168.16,14.94 162.68,14.94 161.69,15.93 v1(161.69,17.12)
  IN3 w0.122: v1(201.2,11.78) 201.98,12.55 201.98,21.58 v1(202.33,21.93)
  BOTTOM w0.102: v1(212.95,25.85) 211.87,25.85 211.45,26.27 R894.1 211.02,26.26 R895.1 ; v1(161.69,17.12) 161.69,17.73 162.48,18.52 162.48,18.86 162.37,18.97 162.37,19.28 162.67,19.58 UH4.U3
PCH_SPI_DO: length 108.8
  TOP w0.102: R912.2 198.84,23.84 v2(199.67,23) 202.86,19.81 207.38,19.81 209.02,18.17 209.02,16.2 v1(210.84,14.39)
  IN2 w0.102: 167.51,17.59 167.51,17.59 166.57,18.52 163.73,18.52 161.85,20.4 v1(161.7,20.4)
  IN2 w0.122: v1(210.84,14.39) 210.52,14.7 210.52,14.92 210.38,15.06 209.58,15.06 209.46,14.94 209.46,14.03 209.34,13.9 209.1,13.9 208.98,14.03 208.98,14.94 208.85,15.06 208.61,15.06 208.49,14.94 208.49,14.03 208.37,13.9 208.12,13.9 208,14.03 208,14.94 207.88,15.06 207.63,15.06 207.51,14.94 207.51,14.03 207.39,13.9 207.15,13.9 207.02,14.03 207.02,14.94 206.9,15.06 206.66,15.06 206.54,14.94 206.54,14.03 206.41,13.9 206.17,13.9 206.05,14.03 206.05,14.94 205.93,15.06 198.34,15.06 197.07,13.79 190.12,13.79 187,10.68 182.9,10.68 181.71,11.87 174.75,11.87 169.51,17.1 167.99,17.1 167.51,17.59
  IN3 w0.122: v1(208.36,38.82) 209.3,37.88 209.3,15.94 210.84,14.4 v1(210.84,14.39)
  BOTTOM w0.102: R901.2 v1(208.36,38.82) ; v1(210.84,14.39) R900.2 ; UH4.V4 162.01,20.4 v1(161.7,20.4)
PCH_THRMTRIP#_R: length 13.8
  IN4 w0.084: v1(144.18,21.8) 144.56,22.18 144.56,22.63 145.47,23.54 146.63,23.54 147.2,22.97 150.61,22.97 151.12,22.46 v1(151.73,22.46)
  BOTTOM w0.102: v1(144.18,21.8) v2(142.68,21.8) 141.76,22.72 RH262.2 CH97.1 ; v1(151.73,22.46) 151.42,22.77 UH4.AY10
PCI_5048: length 7
  BOTTOM w0.102: v2(170.74,47.75) 170.44,47.44 170.44,47.1 170.26,46.92 170.26,46.17 RH160.1 169.79,45.18 167.13,42.52 UH4.H49
PCI_GNT3#: length 2.1
  TOP w0.102: RH333.1 169.25,41.33 v1(168.67,40.76) 168.67,40.42 v2(168.5,40.24)
  BOTTOM w0.102: v1(168.67,40.76) 168.61,40.7 UH4.F46
PCI_LOOPBACKOUT: length 10.1
  TOP w0.102: RH105.1 165.78,42.96 165.65,42.83 v2(165.26,42.83) 164.24,42.83 164.11,42.71 164.11,42.41 164.24,42.28 166.1,42.28 166.4,41.98 166.4,41.22 167.05,40.57 167.05,38.98 v1(166.65,38.58)
  BOTTOM w0.102: UH4.H40 166.65,38.29 v1(166.65,38.58)
PCI_MEC: length 12.7
  TOP w0.102: v1(167.58,39.72) 168.04,40.18 168.04,40.4 168.2,40.56 168.2,41.84 167.44,42.61 167.44,43.79 166.63,44.6 166.63,45.61 166.71,45.68 167.05,45.68 167.12,45.61 167.12,45.33 167.2,45.25 v2(167.34,45.25) 167.45,45.25 167.53,45.33 167.53,45.6 167.63,45.7 167.84,45.7 167.94,45.6 167.94,45.32 168.01,45.24 168.27,45.24 168.34,45.32 168.34,45.6 168.44,45.7 168.65,45.7 168.75,45.6 168.75,45.29 168.83,45.22 169.08,45.22 169.16,45.29 169.16,45.6 169.28,45.73 RH102.1
  BOTTOM w0.102: v1(167.58,39.72) 167.28,39.43 UH4.H43
PCI_PIRQA#: length 12.4
  TOP w0.102: v2(173.92,37.28) 173.92,37.37 v1(174.29,37.74)
  IN3 w0.102: v1(165.65,37.84) 165.99,37.49 165.99,37.22 166.32,36.9 168.75,36.9 168.95,36.7 170.92,36.7 171.51,37.28 172.57,37.28 173.47,38.19 173.84,38.19 v1(174.29,37.74)
  BOTTOM w0.102: UH4.K40 165.96,38.16 v1(165.65,37.84) ; v1(174.29,37.74) 174.85,38.3 RH324.2
PCI_PIRQB#: length 11.3
  IN3 w0.102: v1(173.64,37.71) 173.64,37 172.48,35.85 168.71,35.85 168.53,36.03 166.49,36.03 v1(166.08,36.44)
  BOTTOM w0.102: v1(173.64,37.71) 173.64,37.66 v2(174.06,37.24) 175.01,37.24 RH325.2 ; UH4.K38 166.41,36.77 v1(166.08,36.44)
PCI_PIRQC#: length 14.5
  TOP w0.102: RH326.2 178.15,35.44 178.15,36.66 176.8,38.01 v2(175.8,38.01) 175.66,38.15 172.92,38.15 172.71,37.94 169.12,37.94 168.89,37.72 167.07,37.72 v1(166.7,37.34)
  BOTTOM w0.102: UH4.H38 167.04,37 v1(166.7,37.34)
PCI_PIRQD#: length 9.5
  TOP w0.102: RH329.2 174.25,34.57 172.87,34.57 172.34,35.09 171.28,35.09 171.18,34.99 170.41,34.99 170.24,35.16 v2(170.24,35.48) 169.7,36.01 167.79,36.01 v1(167.36,36.44)
  BOTTOM w0.102: UH4.G38 167.68,36.75 v1(167.36,36.44)
PCI_REQ1#: length 9.2
  TOP w0.102: v1(174.3,38.82) 173.89,39.23 v2(173.89,39.35)
  IN4 w0.102: v1(174.3,38.82) 173.91,38.43 172.04,38.43 170.4,40.07 170.4,40.62 170.16,40.86 169.7,40.86 169.37,40.53 v1(169.37,40.31)
  BOTTOM w0.102: v1(169.37,40.31) 169.37,40.62 169.61,40.86 UH4.C46 ; RH327.2 174.73,39.25 v1(174.3,38.82)
PCI_TPM_TCM: length 11.5
  TOP w0.102: v2(166.11,39.48) 166.32,39.48 v1(166.61,39.19)
  IN3 w0.122: v1(166.61,39.19) 166.85,38.95 169.39,38.95 170.41,39.97 v1(170.41,42.8)
  BOTTOM w0.102: v1(166.61,39.19) 166.37,39.43 UH4.K43 ; v1(170.41,42.8) 170.33,42.89 170.33,45.28 RH311.2
PCIE_MCARD1_DET#: length 124.5
  IN3 w0.122: v1(250.16,26.35) 249.48,27.02 249.48,49.02 248.07,50.43 v1(248.07,53.78)
  IN4 w0.091: v1(250.16,26.35) 249.97,26.16 233.12,26.16 230.17,23.21 185.26,23.21 183.89,21.84 173.11,21.84 172.9,21.64 171.01,21.64 170.45,22.2 168.42,22.2 168.04,22.58 v1(168.04,22.59)
  BOTTOM w0.102: v1(168.04,22.59) 168.31,22.31 UH4.E8 ; JMINI2.37 248.2,57.78 248.84,57.15 R699.1 248.07,55.27 v1(248.07,53.78) 247.12,53.78 246.92,53.98 v2(244.85,53.98) 244.51,54.33 R698.2 R692.1
PCIE_MCARD2_DET#: length 141.9
  TOP w0.102: R697.2 282.73,40.77 282.73,31.96 280.76,29.99 280.76,28.9 v1(280.73,28.86)
  IN4 w0.091: v1(169.99,40.46) 169.99,38.94 171.16,37.77 172.54,37.77 175.2,35.1 177.54,35.1 178.54,34.1 178.54,33.84 183.37,29.02 192.27,29.02 195.98,25.3 199.59,25.3 200.75,24.15 229.68,24.15 232.69,27.15 246.56,27.15 247.22,27.81 256.35,27.81 256.91,27.25 262.96,27.25 264.01,26.2 265.14,26.2 269.84,30.9 273.79,30.9 275.37,29.32 280.27,29.32 v1(280.73,28.86)
  BOTTOM w0.102: UH4.C44 169.63,39.9 169.99,40.25 v1(169.99,40.46) ; v1(280.73,28.86) 281,29.14 v2(281,29.58) 281,30.04 R725.1
PCIE_MCARD2_DET#_R: length 3.9
  BOTTOM w0.102: R725.2 R695.2 282.82,32.41 v2(282.44,32.79) 282.2,33.03 JMINI1.37
PCIE_PRX_GLANTX_N7: length 203.2
  TOP w0.102: C459.2 280.21,83.19 280.01,83.19 v1(279.79,82.97)
  IN3 w0.122: v1(279.79,82.97) 279.58,83.18 279.09,83.18 277.51,81.6 277.51,78.96 276.09,77.54 276.09,61.3 276.43,60.96 276.43,52.16 277,51.6 277,50.34 275.43,48.77 275.43,45.15 274.93,44.65 274.93,43.33 276.99,41.27 276.99,35.86 275.83,34.69 275.45,34.69 v3(275.24,34.49)
  IN4 w0.091: v1(145.58,38.79) 145.81,39.03 146.04,39.03 146.28,39.27 146.28,41.91 151.21,46.85 158.56,46.85 158.98,46.43 160.21,46.43 160.65,45.99 166.13,45.99 166.38,45.74 169.81,45.74 170.2,45.35 179.66,45.35 183.29,41.72 183.29,40.28 188.17,35.4 191.54,35.4 193.28,33.65 194.2,33.65 197.45,30.4 219.2,30.4 220.57,31.78 230.74,31.78 234.5,35.54 257.95,35.54 258.78,34.71 275.02,34.71 v3(275.24,34.49)
  BOTTOM w0.102: UH4.BG40 147.41,37.89 147.11,38.19 147.11,38.19 146.97,38.34 145.37,38.34 145.13,38.58 145.13,38.81 145.23,38.91 145.46,38.91 v1(145.58,38.79)
PCIE_PRX_GLANTX_N7_C: length 2.7
  TOP w0.102: C459.1 281.82,83.22 v1(282.44,83.22) 282.73,83.22 282.93,83.02 283.19,83.02 283.28,82.93 U31.39
PCIE_PRX_GLANTX_P7: length 203.3
  TOP w0.102: v1(279.79,83.61) 279.99,83.41 280.21,83.41 C458.2
  IN3 w0.122: v1(279.79,83.61) 279.58,83.4 279,83.4 277.29,81.69 277.29,79.05 275.87,77.63 275.87,61.21 276.22,60.87 276.22,52.07 276.78,51.51 276.78,50.43 275.21,48.86 275.21,45.24 274.71,44.74 274.71,43.24 276.77,41.18 276.77,35.95 275.74,34.91 275.46,34.91 v1(275.24,35.13)
  IN4 w0.091: v3(145.58,39.43) 145.58,39.3 145.68,39.2 145.96,39.2 146.11,39.34 146.11,41.98 151.14,47.02 158.64,47.02 159.06,46.6 160.29,46.6 160.73,46.16 166.2,46.16 166.45,45.92 169.88,45.92 170.27,45.52 179.73,45.52 183.46,41.79 183.46,40.35 188.24,35.57 191.61,35.57 193.36,33.82 194.27,33.82 197.52,30.57 219.13,30.57 220.5,31.95 230.67,31.95 234.43,35.71 258.02,35.71 258.85,34.88 275,34.88 v1(275.24,35.13)
  BOTTOM w0.102: v3(145.58,39.43) 145.27,39.13 145.14,39.13 144.91,38.9 144.91,38.49 145.28,38.12 146.88,38.12 146.9,38.1 146.9,38.1 146.95,38.05 146.95,37.94 UH4.BJ40
PCIE_PRX_GLANTX_P7_C: length 2.7
  TOP w0.102: C458.1 281.76,83.45 282.81,83.45 283.02,83.24 283.19,83.24 283.28,83.33 U31.38
PCIE_PRX_MMITX_N6: length 178.2
  TOP w0.102: C571.1 274.65,12.42 274.35,12.42 v1(274.11,12.18)
  IN3 w0.122: v1(274.11,12.18) 274.11,12.29 274.03,12.38 273.35,12.38 272.32,13.41 272.32,24.34 273.39,25.41 273.39,35.39 273.89,35.9 273.89,37.03 273.77,37.15 v1(273.68,37.15)
  IN4 w0.091: v3(145.97,37.56) 145.51,37.09 145.19,37.09 144.8,37.48 144.8,41.34 150.95,47.49 158.83,47.49 159.25,47.07 160.48,47.07 160.92,46.63 166.4,46.63 166.64,46.39 170.07,46.39 170.47,45.99 172.91,45.99 173.3,46.39 174.39,46.39 174.78,45.99 180.04,45.99 189.99,36.04 191.83,36.04 193.48,34.39 194.49,34.39 197.75,31.13 219.01,31.13 220.3,32.42 230.36,32.42 234.43,36.49 258.26,36.49 259.04,37.28 264.99,37.28 265.66,37.95 274.03,37.95 274.15,37.83 274.15,37.58 273.72,37.15 v1(273.68,37.15)
  BOTTOM w0.102: v3(145.97,37.56) 145.97,37.41 146.06,37.32 146.21,37.32 146.38,37.14 146.65,37.14 146.86,37.35 146.96,37.35 147.17,37.14 147.17,37.03 147.14,37 147.04,36.9 UH4.BJ38
PCIE_PRX_MMITX_N6_C: length 2.8
  TOP w0.102: U38.7 277.85,12.6 277.71,12.74 277.52,12.74 277.21,12.43 v1(276.97,12.43) 276.18,12.43 C571.2
PCIE_PRX_MMITX_P6: length 178.2
  TOP w0.102: C569.1 274.58,12.63 274.29,12.63 v1(274.11,12.81)
  IN3 w0.122: v3(274.32,37.15) 274.11,36.94 274.11,35.81 273.6,35.3 273.6,25.32 272.53,24.25 272.53,13.5 273.44,12.6 273.89,12.6 v1(274.11,12.81)
  IN4 w0.091: v1(145.97,36.92) 145.12,36.92 144.63,37.41 144.63,41.42 150.87,47.67 158.9,47.67 159.32,47.25 160.55,47.25 160.99,46.81 166.47,46.81 166.71,46.56 170.15,46.56 170.54,46.17 172.84,46.17 173.23,46.56 174.46,46.56 174.85,46.17 180.11,46.17 190.06,36.22 191.9,36.22 193.55,34.57 194.56,34.57 197.83,31.3 218.94,31.3 220.23,32.59 230.29,32.59 234.36,36.67 258.19,36.67 258.97,37.45 264.92,37.45 265.59,38.12 274.1,38.12 274.32,37.9 v3(274.32,37.15)
  BOTTOM w0.102: v1(145.97,36.92) 146.45,36.92 146.77,36.6 147.05,36.6 147.35,36.9 UH4.BG38
PCIE_PRX_MMITX_P6_C: length 2.9
  TOP w0.102: C569.2 276.22,12.65 276.52,12.65 276.53,12.66 277.13,12.66 277.43,12.96 277.71,12.96 277.85,13.1 U38.6
PCIE_PRX_WANTX_N1: length 163.9
  IN4 w0.091: v1(148.78,35.51) 148.73,35.46 148.4,35.46 148.31,35.55 148.31,36.16 147.02,37.46 147.02,41.74 151.48,46.2 158.3,46.2 158.72,45.78 159.95,45.78 160.39,45.34 165.86,45.34 166.11,45.1 169.54,45.1 169.94,44.7 175.01,44.7 175.77,43.94 179.82,43.94 182.58,41.18 182.58,39.98 189.59,32.97 193.88,32.97 197.16,29.69 219.4,29.69 220.84,31.13 231.1,31.13 234.7,34.72 256.09,34.72 257.49,33.33 266.75,33.33 267.48,34.07 274.47,34.07 274.89,33.65 283.45,33.65 284.35,32.74 285.76,32.74 v3(285.97,32.53)
  BOTTOM w0.102: UH4.BG34 148.04,34.92 148.63,35.51 v1(148.78,35.51) ; v3(285.97,32.53) 286.14,32.7 287.4,32.7 287.68,32.98 287.68,33.35 287.8,33.47 JMINI1.23
PCIE_PRX_WANTX_P1: length 163.9
  IN4 w0.091: v3(147.93,35.42) 148.13,35.62 148.13,36.09 146.84,37.38 146.84,41.81 151.41,46.38 158.37,46.38 158.79,45.96 160.02,45.96 160.46,45.52 165.93,45.52 166.18,45.27 169.61,45.27 170.01,44.87 175.09,44.87 175.84,44.11 179.89,44.11 182.75,41.25 182.75,40.05 189.67,33.14 193.95,33.14 197.23,29.86 219.33,29.86 220.77,31.3 231.03,31.3 234.63,34.9 256.16,34.9 257.56,33.5 266.67,33.5 267.41,34.24 274.54,34.24 274.96,33.82 283.52,33.82 284.42,32.92 285.72,32.92 v1(285.97,33.17)
  BOTTOM w0.102: v1(285.97,33.17) 286.23,32.92 287.31,32.92 287.46,33.07 287.46,33.29 287.38,33.38 287.07,33.38 287,33.44 JMINI1.25 ; v3(147.93,35.42) 147.8,35.42 147.31,34.92 UH4.BJ34
PCIE_PRX_WLANTX_N2: length 156.6
  IN3 w0.122: v1(252.39,37.7) 252.59,37.9 252.91,37.9 253.32,38.32 253.32,53.83 252.84,54.31 252.84,55.79 v3(253.03,55.98)
  IN4 w0.091: v1(252.39,37.7) 252.19,37.91 234.84,37.91 231.6,34.67 220.91,34.67 219.91,33.66 219.91,32.95 218.79,31.84 198.05,31.84 194.75,35.14 193.7,35.14 192.14,36.7 190.35,36.7 180.4,46.64 175.05,46.64 174.57,47.11 173.09,47.11 172.64,46.66 171.21,46.66 170.3,47.58 169.58,47.58 169.24,47.91 164.99,47.91 164.35,47.28 161.19,47.28 160.75,47.72 159.52,47.72 159.1,48.14 150.68,48.14 144.16,41.62 144.16,36.29 146.04,34.41 147.49,34.41 148.18,35.1 149.03,35.1 149.24,34.89 149.24,34.73 149.46,34.51 v1(149.46,34.5)
  BOTTOM w0.102: v3(253.03,55.98) 252.87,56.14 252.8,56.21 252.8,56.4 253.46,57.06 253.46,57.33 253.8,57.67 JMINI2.23 ; v1(149.46,34.5) 149.11,34.85 UH4.BE34
PCIE_PRX_WLANTX_P2: length 156.6
  IN3 w0.122: v1(252.39,38.34) 252.62,38.12 252.82,38.12 253.11,38.41 253.11,53.74 252.62,54.22 252.62,55.75 v3(252.4,55.98)
  IN4 w0.091: v1(252.39,38.34) 252.13,38.08 234.77,38.08 231.53,34.84 220.84,34.84 219.73,33.74 219.73,33.14 218.61,32.01 198.12,32.01 194.82,35.31 193.77,35.31 192.22,36.87 190.42,36.87 180.48,46.81 175.12,46.81 174.65,47.28 173.02,47.28 172.57,46.83 171.29,46.83 170.37,47.75 169.65,47.75 169.31,48.09 164.91,48.09 164.28,47.45 161.26,47.45 160.82,47.89 159.59,47.89 159.17,48.31 150.61,48.31 143.99,41.69 143.99,36.22 145.97,34.24 147.56,34.24 148.25,34.93 148.96,34.93 149.07,34.81 149.07,34.57 148.99,34.5 v1(148.76,34.5)
  BOTTOM w0.102: JMINI2.25 253,57.63 253.24,57.39 253.24,57.15 252.58,56.49 252.58,56.16 v3(252.4,55.98) ; UH4.BF34 148.48,34.78 v1(148.76,34.5)
PCIE_PTX_GLANRX_N7: length 199.4
  TOP w0.102: C461.1 280.25,81.35 279.98,81.35 v3(279.76,81.13)
  IN3 w0.122: v3(279.76,81.13) 279.55,81.34 279.25,81.34 278.23,80.32 278.23,78.66 276.81,77.25 276.81,61.64 277.16,61.3 277.16,52.56 277.78,51.94 277.78,49.18 276.99,48.39 276.99,42.37 277.78,41.58 277.78,33.58 277.93,33.43 277.93,32.13 277.75,31.96 277.75,30.93 v1(277.99,30.69)
  IN4 w0.091: v1(277.99,30.69) 277.98,30.69 277.8,30.88 277.8,31.21 277.49,31.52 275.21,31.52 273.99,32.74 268.39,32.74 267.12,31.48 255.87,31.48 255.14,32.21 233.99,32.21 230.09,28.32 196.73,28.32 193.35,31.69 189.17,31.69 188.23,32.63 187.49,32.63 180.66,39.47 180.66,40.05 178.04,42.67 173,42.67 172.29,43.38 169.68,43.38 169.08,43.98 167.06,43.98 166.93,43.85 163.18,43.85 162.8,44.23 159.92,44.23 159.48,44.67 158.25,44.67 157.84,45.08 153.54,45.08 151.17,42.72 151.17,38.22 150.98,38.03 150.8,38.03 150.68,38.14 v1(150.68,38.49)
  BOTTOM w0.102: v1(150.68,38.49) 151.02,38.16 UH4.AY40
PCIE_PTX_GLANRX_N7_C: length 2.8
  TOP w0.102: U31.42 283.46,81.73 283.4,81.79 v1(282.59,81.79) 282.16,81.79 281.48,81.1 C461.2
PCIE_PTX_GLANRX_P7: length 199.4
  TOP w0.102: v1(279.76,81.77) 279.96,81.56 280.2,81.56 C460.1
  IN3 w0.122: v1(279.76,81.77) 279.55,81.56 279.16,81.56 278.01,80.41 278.01,78.75 276.6,77.34 276.6,61.55 276.94,61.21 276.94,52.47 277.56,51.85 277.56,49.27 276.77,48.48 276.77,42.28 277.56,41.49 277.56,33.49 277.71,33.34 277.71,32.22 277.54,32.05 277.54,30.88 v3(277.35,30.69)
  IN4 w0.091: v1(150.68,37.45) 150.68,37.77 150.77,37.85 151.05,37.85 151.34,38.15 151.34,42.65 153.61,44.91 157.76,44.91 158.18,44.49 159.41,44.49 159.85,44.05 162.73,44.05 163.11,43.67 167,43.67 167.14,43.81 169,43.81 169.61,43.2 172.21,43.2 172.92,42.49 177.97,42.49 180.49,39.98 180.49,39.39 187.42,32.46 188.16,32.46 189.1,31.52 193.28,31.52 196.65,28.15 230.17,28.15 234.06,32.04 255.07,32.04 255.8,31.31 267.2,31.31 268.46,32.57 273.92,32.57 275.14,31.35 277.42,31.35 277.63,31.14 277.63,30.97 v3(277.35,30.69)
  BOTTOM w0.102: v1(150.68,37.45) 150.68,37.81 150.6,37.89 UH4.BB40
PCIE_PTX_GLANRX_P7_C: length 2.7
  TOP w0.102: C460.2 281.71,81.7 281.77,81.7 282.09,82.01 283.36,82.01 283.47,82.13 U31.41
PCIE_PTX_MMIRX_N6: length 174.3
  TOP w0.102: v1(274.18,14.64) 274.37,14.45 274.54,14.45 C568.1
  IN3 w0.122: v1(274.18,14.64) 273.97,14.43 273.82,14.43 273.65,14.61 273.65,16 275.13,17.47 275.13,29.2 276.94,31.02 276.94,32.63 v3(277.16,32.85)
  IN4 w0.091: v1(152.83,35.41) 152.44,35.41 152.37,35.49 152.37,36.41 152,36.78 148.76,36.78 147.74,37.8 147.74,41.55 151.75,45.56 158.03,45.56 158.45,45.14 159.68,45.14 160.12,44.7 163.01,44.7 163.39,44.32 166.51,44.32 166.64,44.45 169.27,44.45 169.73,44 173.62,44 174.4,43.21 178.27,43.21 181.21,40.27 181.21,39.59 187.69,33.11 188.43,33.11 189.29,32.24 193.58,32.24 197.03,28.79 229.79,28.79 233.69,32.68 255.56,32.68 256.21,32.03 266.87,32.03 268.12,33.29 274.14,33.29 275.38,32.04 276.6,32.04 276.91,32.35 276.91,32.59 v3(277.16,32.85)
  BOTTOM w0.102: UH4.AU36 152.88,35.91 152.83,35.85 v1(152.83,35.41)
PCIE_PTX_MMIRX_N6_C: length 3
  TOP w0.102: C568.2 276.16,14.51 276.46,14.51 277.01,13.97 277.53,13.97 277.66,14.1 U38.4
PCIE_PTX_MMIRX_P6: length 174.3
  TOP w0.102: C567.1 274.63,14.24 274.63,14.23 274.4,14.23 v1(274.18,14.01)
  IN3 w0.122: v1(276.53,32.85) 276.73,32.65 276.73,31.11 274.91,29.29 274.91,17.56 273.43,16.09 273.43,14.52 273.73,14.22 273.97,14.22 v1(274.18,14.01)
  IN4 w0.091: v3(151.97,35.42) 152.19,35.64 152.19,36.34 151.92,36.61 148.69,36.61 147.57,37.73 147.57,41.62 151.68,45.73 158.1,45.73 158.52,45.31 159.75,45.31 160.19,44.87 163.08,44.87 163.47,44.49 166.44,44.49 166.57,44.63 169.34,44.63 169.8,44.17 173.69,44.17 174.47,43.39 178.34,43.39 181.38,40.35 181.38,39.66 187.76,33.28 188.5,33.28 189.37,32.41 193.65,32.41 197.1,28.97 229.72,28.97 233.61,32.86 255.63,32.86 256.28,32.2 266.79,32.2 268.05,33.46 274.21,33.46 275.46,32.22 276.52,32.22 276.73,32.43 276.73,32.64 v1(276.53,32.85)
  BOTTOM w0.102: UH4.AV36 152.31,35.76 v3(151.97,35.42)
PCIE_PTX_MMIRX_P6_C: length 3
  TOP w0.102: C567.2 276.2,14.3 276.37,14.3 276.93,13.74 v1(277.16,13.74) 277.51,13.74 277.65,13.6 U38.5
PCIE_PTX_WANRX_N1: length 153.8
  IN4 w0.091: v3(284.52,29.87) 284.31,30.08 284.31,30.43 283.86,30.88 281.08,30.88 280.18,29.98 275.69,29.98 274.12,31.55 268.73,31.55 266.74,29.56 264.39,29.56 263.7,30.25 255.6,30.25 254.33,31.51 241.39,31.51 239.81,29.93 232.72,29.93 229.9,27.11 196.92,27.11 193.05,30.98 188.98,30.98 187.96,31.99 187.12,31.99 180.24,38.87 179.63,38.87 177.39,41.11 175.48,41.11 174.67,41.91 171.61,41.91 171.14,42.39 169.71,42.39 169.2,42.89 167.54,42.89 166.76,42.12 162.4,42.12 162.19,42.33 156.34,42.33 156.09,42.07 153.79,42.07 153.14,41.43 153.14,37.55 153.26,37.43 153.26,34.34 153.1,34.18 152.81,34.18 152.63,34.36 v1(152.63,34.5)
  BOTTOM w0.102: UH4.AV32 152.31,34.18 v1(152.63,34.5) ; v3(284.52,29.87) 284.31,30.08 284.31,30.56 C597.1
PCIE_PTX_WANRX_N1_C: length 3
  BOTTOM w0.102: C597.2 284.3,32.18 v1(284.3,32.84) 284.3,33.21 284.6,33.52 284.6,34.55 JMINI1.31
PCIE_PTX_WANRX_P1: length 153.8
  IN4 w0.091: v3(283.88,29.87) 284.14,30.13 284.14,30.36 283.79,30.71 281.15,30.71 280.25,29.8 275.62,29.8 274.05,31.38 268.8,31.38 266.81,29.39 264.32,29.39 263.63,30.07 255.52,30.07 254.26,31.34 241.46,31.34 239.88,29.76 232.79,29.76 229.97,26.94 196.85,26.94 192.98,30.8 188.91,30.8 187.89,31.82 187.05,31.82 180.17,38.69 179.56,38.69 177.32,40.93 175.41,40.93 174.6,41.74 171.53,41.74 171.06,42.21 169.64,42.21 169.13,42.72 167.61,42.72 166.83,41.95 162.33,41.95 162.12,42.15 156.41,42.15 156.16,41.9 153.86,41.9 153.31,41.35 153.31,37.62 153.43,37.51 153.43,34.27 153.17,34.01 152.82,34.01 152.61,33.8 v1(152.61,33.46)
  BOTTOM w0.102: C599.1 284.09,30.58 284.09,30.08 v3(283.88,29.87) ; UH4.AU32 153,33.75 152.71,33.46 v1(152.61,33.46)
PCIE_PTX_WANRX_P1_C: length 3
  BOTTOM w0.102: C599.2 284.08,32.14 284.08,32.53 284.07,32.55 284.07,33.26 283.8,33.52 JMINI1.33
PCIE_PTX_WLANRX_N2: length 146
  IN3 w0.122: v1(251.67,29.56) 251.9,29.79 252.17,29.79 252.47,30.1 252.47,34.8 251.43,35.84 251.43,52.69 v1(251.66,52.92)
  IN4 w0.084: v3(150.69,33.44) 150.92,33.21 150.92,32.98 151.07,32.83 152.92,32.83 153.4,33.31 154.18,33.31 154.72,33.85 154.72,35.16 154.17,35.72 154.17,37.42 155.3,38.55 155.3,39.41 157.5,41.62 161.91,41.62 162.26,41.27 167.26,41.27 167.95,41.97 168.75,41.97 169.34,41.38 170.39,41.38 171.08,40.69 171.51,40.69 171.52,40.68 171.53,40.68
  IN4 w0.091: 171.53,40.68 174.65,40.68 175.46,39.87 175.46,37.85 176.55,36.76 179.71,36.76 184.7,31.76 184.7,30.44 185.08,30.07 192.7,30.07 196.48,26.29 230.34,26.29 232.91,28.86 240.35,28.86 242.18,30.69 250.31,30.69 250.66,30.34 250.66,29.85 250.94,29.56 v1(251.67,29.56)
  BOTTOM w0.102: C596.1 251.45,53.4 251.45,53.13 v1(251.66,52.92) ; v3(150.69,33.44) 150.69,33.76 150.51,33.93 UH4.BB32
PCIE_PTX_WLANRX_N2_C: length 4.8
  BOTTOM w0.102: C596.2 251.41,55.03 251.41,55.56 v1(251.14,55.84) 250.64,56.33 250.64,56.94 250.34,57.25 250.34,57.44 250.6,57.7 250.6,58.35 JMINI2.31
PCIE_PTX_WLANRX_P2: length 145.9
  IN3 w0.122: v3(251.03,52.92) 251.21,52.74 251.21,35.75 252.25,34.71 252.25,30.19 252.08,30.01 251.86,30.01 v1(251.67,30.2)
  IN4 w0.084: 171.53,40.85 171.51,40.85 171.51,40.85 171.15,40.85 170.46,41.54 169.41,41.54 168.82,42.13 167.88,42.13 167.19,41.44 162.32,41.44 161.98,41.78 157.44,41.78 155.14,39.48 155.14,38.62 154.01,37.49 154.01,35.65 154.56,35.1 154.56,33.92 154.12,33.47 153.33,33.47 152.85,32.99 151.14,32.99 151.08,33.05 151.08,33.41 151.25,33.58 151.37,33.58 v1(151.52,33.43)
  IN4 w0.091: 171.53,40.85 174.72,40.85 175.63,39.94 175.63,37.92 176.63,36.93 179.78,36.93 184.88,31.83 184.88,30.51 185.15,30.24 192.77,30.24 196.55,26.46 230.27,26.46 232.84,29.03 240.28,29.03 242.11,30.87 250.38,30.87 250.83,30.41 250.83,29.92 251.01,29.74 251.21,29.74 v1(251.67,30.2)
  BOTTOM w0.102: v1(151.52,33.43) 151.02,33.93 UH4.AY32 ; C598.1 251.24,53.4 251.24,53.13 v3(251.03,52.92)
PCIE_PTX_WLANRX_P2_C: length 4.8
  BOTTOM w0.102: C598.2 251.2,54.95 251.2,55.47 251.18,55.49 251.16,55.49 250.79,55.87 250.79,55.88 250.42,56.24 250.42,56.85 250.12,57.16 250.12,57.41 249.8,57.73 249.8,57.99 JMINI2.33
PCIE_WAKE#: length 76.9
  TOP w0.102: v2(298,37.61) 298,37.07 v1(298.57,36.5) ; R759.2 291.18,66.7 291.18,67.73 v1(291.23,67.78) ; U51.B19 291.51,62.42 v1(291.29,62.21)
  IN1 w0.084: v1(291.29,62.21) 290.75,62.76 290.75,65.8 291.23,66.28 v1(291.23,67.78)
  IN2 w0.122: v1(266.27,59.93) 266.91,60.56 270.93,60.56 276.82,66.45 278.26,66.45 278.58,66.77 288.75,66.77 289.16,67.18 290.63,67.18 v1(291.23,67.78)
  IN3 w0.122: v1(298.57,36.5) 298.12,36.94 298.12,38.74 299.13,39.75 299.13,42.09 297.73,43.49 297.73,48.24 298.69,49.2 298.69,60.5 298.17,61.02 297.08,61.02 295.09,63.01 292.1,63.01 v1(291.29,62.21)
  BOTTOM w0.102: JMINI2.1 265.8,59.74 265.99,59.93 v1(266.27,59.93) ; JMINI1.1 299.8,35.81 299.12,36.5 v1(298.57,36.5)
PCLK_80H: length 119.2
  TOP w0.102: v1(186.29,38.69) 184.45,38.69 183.23,39.91 183.23,43.01 181.17,45.07 179.55,45.07 v2(178.57,46.04) v1(176.75,47.86)
  IN1 w0.084: v1(266.02,34.27) 265.79,34.05 256.14,34.05 255.74,34.45 237.57,34.45 231.45,28.33 198.03,28.33 189.81,36.55 188.99,36.55 186.85,38.69 v1(186.29,38.69)
  BOTTOM w0.102: v1(176.75,47.86) 175.71,48.9 173.4,48.9 172.14,50.16 169.39,50.16 169.03,49.81 169.03,48.32 169.26,48.09 169.26,47.5 168.84,47.08 RH314.1 ; v1(266.02,34.27) 266.02,32.14 266.86,31.3 JMINI3.19
PECI_EC: length 195.9
  TOP w0.102: R863.2 273.75,46.84 v1(274.27,46.33) 274.29,46.33 v2(274.74,45.87)
  IN1 w0.084: v1(274.27,46.33) 273.01,47.58 268.79,47.58 265.59,44.38 235.52,44.38 231.42,40.28 225.39,40.28 220.08,34.97 198.51,34.97 193.06,40.42 193.06,40.74 190.62,43.19 190,43.19 187.91,45.27 183.76,45.27 181.95,47.09 173.68,47.09 169.52,51.25 169.52,52.87 168.14,54.24 168.14,61.46 168.43,61.76 168.43,75.45 167.81,76.07 167.81,77.01 166.03,78.79 v1(166.03,79.22)
  IN4 w0.084: v5(132.31,59.9) 133.6,59.9 136.4,62.71 143.39,62.71 144.25,61.85 149.79,61.85 150.1,61.54 152.2,61.54 155.66,65 155.66,65.78 157.98,68.11 159.67,68.11 166.03,74.47 v1(166.03,79.22)
  BOTTOM w0.102: v5(132.31,59.9) 132.31,59.8 131.79,59.28 U1.A48
PECI_EC_R: length 14.9
  TOP w0.102: U51.A48 282.25,54.6 281.99,54.33 281.48,54.33 280.26,55.56 276.99,55.56 v2(275.46,54.02) 274.08,52.65 274.08,48.48 R863.1
PEG_A_CLKRQ#: length 14.6
  IN4 w0.084: v1(164.84,23.29) 164.84,23.26 166.21,21.89 166.21,21.06 166.27,21 166.27,20.32 168.03,18.56 169.09,18.56 169.56,19.03 172.28,19.03 v1(172.54,18.77)
  BOTTOM w0.102: v1(164.84,23.29) 165.15,22.97 UH4.M10 ; RH80.2 174.53,18.66 v2(173.87,19.33) 173.1,19.33 v1(172.54,18.77)
PEG_B_CLKRQ#: length 16
  IN1 w0.084: v1(168.58,21.5) 169,21.92 169.42,21.92 170.22,21.12 174.37,21.12 175.18,20.32 176.81,20.32 177.59,19.54 177.59,19.24 179.13,17.7 v1(179.13,17.46)
  BOTTOM w0.102: RH98.2 178.93,15.93 v2(179.52,16.52) 179.52,17.07 v1(179.13,17.46) ; UH4.E6 168.31,21.23 v1(168.58,21.5)
PEG_COMP: length 9.3
  BOTTOM w0.102: RC1.2 130.29,32.86 130.49,33.06 130.49,35.18 129.08,36.59 U1.G3 129.08,37.36 U1.G4
  BOTTOM w0.305: U1.G1 129.11,36.09 130.01,35.18 130.01,33.92 129.95,33.86 RC1.2
PGOOD: length 4.4
  BOTTOM w0.203: PR726.1 149.89,81.05 149.46,81.48 148.99,81.48 v2(148.69,81.78) 148.08,82.38 148.05,82.38 147.39,83.04 PU700.19
PGOODG: length 22.8
  TOP w0.102: v1(140.98,84.46) v2(141.53,84.46)
  IN1 w0.254: v1(140.98,84.46) 140.98,85.71 141.95,86.69 145.09,86.69 146.42,88.02 151.14,88.02 152.49,86.66 152.49,84.03 150.78,82.32 v1(150.78,81.14)
  BOTTOM w0.203: v1(140.98,84.46) 141.15,84.64 PU700.36
  BOTTOM w0.254: PR708.1 v1(150.78,81.14)
PHASE1: length 10.2
  TOP w0.102: v1(146.25,80.12) v4(147.01,80.12)
  IN4 w1.016: 147.43,71.69 148.27,72.53 148.27,79.38 147.4,80.25 147.25,80.25
  vias: v1(146.25,80.76) v1(146.46,71.84) v1(146.46,71.21)
PHASE1G: length 17
  TOP w0.102: v1(139.79,83.33) v4(138.84,83.33)
  IN4 w1.016: 123.5,87 133.39,87 134.27,86.13 135.65,86.13 138.18,83.6
  vias: v1(121.14,89.98) v1(121.15,90.7) v1(121.66,92.45) v1(121.79,91.77) v1(121.79,91.06) v1(121.81,90.29) v1(121.82,89.51) v1(122.36,92.19) v1(122.43,88.99) v1(122.5,90.89) v1(122.5,90) v1(122.81,91.67) v1(123.04,89.42) v1(123.02,88.47) v1(123.07,90.43) v1(123.28,91.15) v1(123.87,90.68) v1(123.88,89.81) v1(123.88,88.96) v1(123.88,88.01) v1(140.43,83.33)
PLTRST_LAN#: length 180.2
  TOP w0.102: U31.36 284.71,84.96 v1(284.37,85.3) ; v2(287.62,22.58) 288.3,21.9 v1(288.51,21.9)
  IN1 w0.084: v1(183.86,19.53) 185.09,20.76 185.77,20.76 186.7,19.83 189.12,19.83 190.01,18.95 196.22,18.95 197.57,17.6 203.02,17.6 203.72,18.31 241.39,18.31 243.29,20.21 257.83,20.21 258.58,20.95 262.64,20.95 263.14,21.45 275.65,21.45 276.1,21.9 v1(288.51,21.9)
  IN3 w0.122: v1(284.37,85.3) 283.83,84.76 283.83,74.95 287.98,70.8 287.98,66.02 288.56,65.43 288.56,64.14 287.9,63.48 287.9,60.94 287.56,60.6 287.56,56.73 288.35,55.93 288.35,53.24 288.73,52.87 288.73,50.65 288.48,50.4 288.48,47.73 287.96,47.21 287.96,45.96 288.84,45.08 288.84,43.48 287.83,42.46 287.83,35.74 287.43,35.34 287.43,28.67 287.13,28.37 287.13,27 288.09,26.03 288.09,22.32 v1(288.51,21.9)
  BOTTOM w0.102: v1(183.86,19.53) 183.03,20.37 RH338.1
PLTRST_MMI#: length 110.4
  TOP w0.102: v1(281.23,10.47) 281.11,10.6 U38.13
  IN1 w0.084: v1(183.42,17.17) 184.04,16.55 190.25,16.55 190.76,16.04 192.11,16.04 193.2,14.95 197.33,14.95 197.52,15.14 213.64,15.14 214.06,15.55 242.15,15.55 242.46,15.24 244.17,15.24 245.46,16.53 246.98,16.53 248,17.55 260.37,17.55 261.51,16.41 268.23,16.41 269.63,17.8 277.08,17.8 278.71,16.18 278.71,11.96 279.6,11.07 280.64,11.07 v1(281.23,10.47)
  BOTTOM w0.102: RH336.1 183.76,18.49 v2(183.76,18.08) 183.76,17.51 v1(183.42,17.17)
PM_APWROK: length 173
  TOP w0.102: v1(297.52,58.16) 297.46,58.11 294.92,58.11 294.44,58.6 U51.A9
  IN2 w0.122: v1(179.54,8.12) 179.89,7.78 189.99,7.78 193.26,11.04 197.94,11.04 198.23,11.33 203.45,11.33 204.04,10.74 207.98,10.74 208.3,10.41 211.03,10.41 214.07,13.45 218.37,13.45 222.63,17.71 241.14,17.71 244.01,20.57 272.16,20.57 274.66,18.08 v1(291.19,18.08)
  IN3 w0.122: v1(291.19,18.08) 294.31,21.2 294.31,31.29 296.7,33.68 296.7,40.98 296.26,41.43 296.26,48.47 296.79,49.01 296.79,55.35 297.27,55.83 297.27,57.92 v1(297.52,58.16)
  BOTTOM w0.102: UH5.2 182.15,10.6 182.25,10.5 v2(182.25,9.99) 182.25,9.59 182.03,9.37 179.81,9.37 RH118.1 179.33,8.34 v1(179.54,8.12)
PM_APWROK_R: length 31.4
  TOP w0.102: v4(165.8,9.61) 165.81,9.62 v1(165.81,10.28)
  IN1 w0.084: v1(165.41,23.55) 165.78,23.92 166.29,23.92 166.65,23.56 166.65,22.01 166.17,21.52 166.17,19.62 166.6,19.18 166.6,15.82 166.92,15.5 166.92,11.39 v1(165.81,10.28)
  BOTTOM w0.102: v1(165.81,10.28) 166.5,9.6 174.23,9.6 174.58,9.95 UH5.4 178.56,9.36 178.41,9.22 RH118.2 ; v1(165.41,23.55) 165.41,23.4 UH4.L10
PM_DRAM_PWRGD: length 172.3
  TOP w0.102: v1(106.43,86.61) 106.43,89.96 106.16,90.23 103.7,90.23 101.69,92.24 v2(101.69,94.12) 101.69,94.61 99.34,96.96 97.71,96.96 v1(96.97,97.7)
  IN3 w0.122: v1(171.51,24.56) 171.52,24.58 171.52,26.14 170.41,27.25 170.41,32.1 169.61,32.9 167.71,32.9 166.73,33.87 163.8,33.87 163.32,34.36 163.32,35.26 162.88,35.69 162.88,37.51 161.26,39.14 161.26,42.16 162.16,43.06 162.16,44.69 159.14,47.71 159.14,51.36 160.5,52.72 160.5,71.79 158.72,73.57 158.72,81.25 159.37,81.9 159.37,91.36 160.29,92.28 v1(160.29,92.28)
  IN4 w0.084: v1(96.97,97.7) 98.21,98.94 102.34,98.94 106.35,102.95 113.65,102.95 114.9,104.19 133.71,104.19 136.46,101.44 137.27,101.44 138.13,100.59 149.01,100.59 150.08,99.52 152.67,99.52 159.92,92.27 160.28,92.27 v1(160.29,92.28)
  BOTTOM w0.102: UC2.2 106.37,84.4 106.24,84.53 106.11,84.53 105.99,84.66 105.99,84.87 106.11,85 106.42,85 106.55,85.13 106.55,85.35 106.42,85.48 106.24,85.48 106.11,85.61 RC18.2 106.11,86.29 v1(106.43,86.61) ; UH4.B13 170.12,24.56 v1(171.51,24.56)
PM_DRAM_PWRGD_CPU: length 32.4
  TOP w0.102: RC28.2 109.87,82.88 v4(110.33,82.42) 111.09,81.66 111.09,79.56 113.19,77.47 113.19,73.35 109.24,69.4 109.24,59.14 v1(107.83,57.73)
  BOTTOM w0.102: U1.BE45 109.59,57.64 109.2,57.25 108.31,57.25 v1(107.83,57.73)
PM_LANPHY_ENABLE: length 171.2
  TOP w0.102: v1(287.37,35.97) 287.37,35.96 287.77,35.56 v2(287.83,35.56) ; R555.1 v1(282.15,70.39)
  IN2 w0.102: v1(169.1,20.08) 170.42,20.08 170.84,20.51 171.66,20.51 172.13,20.04 174.55,20.04
  IN2 w0.122: v1(287.37,35.97) 286.81,35.42 284.71,35.42 280.73,31.44 263.22,31.44 261.42,33.23 258.05,33.23 256.74,31.92 246.61,31.92 245.42,30.73 241.24,30.73 238.9,28.39 235.69,28.39 230.58,23.28 221.14,23.28 217.96,20.1 201.88,20.1 201.29,20.69 199.87,20.69 199.74,20.56 190.43,20.56 189.84,19.97 187.63,19.97 186.23,18.57 181.82,18.57 181.22,17.96 178.51,17.96 177.54,18.94 175.74,18.94 174.64,20.04 174.55,20.04
  IN3 w0.122: v1(287.37,35.97) 287.53,36.13 287.53,42.52 288.57,43.56 288.57,44.97 287.71,45.83 287.71,47.31 288.23,47.83 288.23,50.5 288.48,50.75 288.48,52.76 288.1,53.14 288.1,55.49 287.14,56.45 287.14,58.66 286.11,59.69 286.11,63.38 287.08,64.35 287.08,65.29 285.74,66.62 283.37,66.62 282.95,67.04 282.95,69.59 v1(282.15,70.39)
  BOTTOM w0.102: v1(169.1,20.08) 169.62,20.08 UH4.C4
