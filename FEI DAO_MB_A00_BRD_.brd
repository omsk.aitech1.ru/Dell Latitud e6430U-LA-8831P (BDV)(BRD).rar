# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D_SERIRQ: length 12.7
  TOP w0.102: R780.2 278.67,75.65 v2(278.21,75.19) 276.84,73.82 271.48,73.82 270.55,72.9 270.18,72.9 270.02,73.06 U46.A20
DAT_DDC_CRT: length 250.8
  TOP w0.102: R1644.2 8.63,74.24 JCRT1.12
  IN3 w0.122: v1(163.87,91.12) 163.6,90.84 163.6,89.56 163.42,89.38 163.42,88.31 162.93,87.83 162.93,74.8 165.05,72.69 165.05,67.94 165.59,67.4 165.59,66.41 165.3,66.13 165.3,61.84 164.94,61.48 164.94,59.79 165.74,58.99 165.74,55.48 168.71,52.51 168.71,51.88 169.55,51.03 169.55,46.34 172.96,42.93 178.21,42.93 180.72,40.41 180.72,37.34 180.33,36.94 178.61,36.94 177.83,37.72 v3(177.83,38.1)
  IN4 w0.084: JCRT1.12 7.5,74 10.62,77.12 12.93,77.12 13.12,77.31 21.28,77.31 21.73,76.86 24.79,76.86 27.82,79.89 27.82,81.94 29.99,84.11 39.63,84.11 42.61,87.09 64.69,87.09 68.15,90.56 71.73,90.56 73.06,91.88 76.4,91.88 77.53,90.75 80.58,90.75 81.82,91.98 87.85,91.98 94.71,98.85 95.55,98.85 96.08,99.37 102.16,99.37 106.21,103.41 113.46,103.41 114.67,104.62 133.89,104.62 136.64,101.87 137.45,101.87 138.3,101.01 149.19,101.01 150.26,99.95 152.85,99.95 160.05,92.75 162.25,92.75 v1(163.87,91.12)
  BOTTOM w0.102: QH6.3 177.83,37.03 v3(177.83,38.1)
DAT_KBD: length 13
  TOP w0.102: v1(277.65,59.97) 277.14,59.46 v2(277.07,59.46) 275.49,59.46 275.23,59.73 R846.2 ; U51.B41 283.66,59.35 284,59 v1(284.23,59)
  IN1 w0.084: v1(277.65,59.97) 277.84,59.78 282.57,59.78 283.36,59 v1(284.23,59)
DAT_MSE: length 7.8
  TOP w0.102: U51.B42 283.7,58.85 284.04,58.51 284.37,58.51 v3(284.87,59) ; v1(281.11,60.21) 281.11,60.74 280.89,60.96 R852.2
  IN1 w0.084: v3(284.87,59) 284.43,59.43 283.62,59.43 282.42,60.64 281.53,60.64 v1(281.11,60.21)
DAT_TP_SIO: length 79.1
  TOP w0.102: v1(284.79,59.95) 284.36,59.51 283.98,59.51 283.64,59.85 U51.B40 ; L54.2 224.12,30.76 C752.1 R903.2 226.14,31.32 v2(226.73,31.9) 226.73,32.53 v1(225.96,33.3)
  IN2 w0.122: v1(225.96,33.3) 225.98,33.28 227.06,33.28 241.43,47.65 241.43,48.16 242.94,49.67 252.94,49.67 255.14,51.86 257.7,51.86 258.63,50.94 263.16,50.94 264.11,51.89 270.53,51.89 272.18,53.55 276.02,53.55 279.47,56.99 279.47,57.59 281.34,59.46 284.3,59.46 v1(284.79,59.95)
DBC_ENABLE: length 149.1
  TOP w0.102: v1(167.98,37.31) 168.39,36.9 170.29,36.9 RH273.1 170.95,37.56 v2(172.05,37.56) 172.32,37.56 172.89,36.99 RH269.2
  IN2 w0.102: 166.6,43.37 166.63,43.34 166.63,42.36 165.16,40.89 165.16,39.39 165.38,39.16 165.83,39.16 166.17,38.82 166.17,38.14 166.43,37.88 166.97,37.88 167.55,37.31 v1(167.98,37.31)
  IN2 w0.122: v1(100.68,96.91) 101.93,98.16 107.56,98.16 108.78,99.37 133.07,99.37 134.8,97.65 141,97.65 141.65,98.29 146.35,98.29 148.75,95.89 154.71,95.89 157.93,92.68 157.93,88.86 161.28,85.51 161.28,73.18 161.68,72.78 161.68,57.92 163.16,56.44 163.16,53.25 164.62,51.79 164.62,49.79 166.76,47.66 166.76,43.52 166.6,43.37
  BOTTOM w0.102: v1(100.68,96.91) 99.76,95.99 97.37,95.99 95.88,97.48 95.88,104.88 97.6,106.6 JLVDS1.28 ; UH4.D40 168.36,37.31 v1(167.98,37.31)
DC_TEST_A59_C59: length 0.7
  BOTTOM w0.102: U1.A59 U1.C59
DC_TEST_A61_C61: length 0.7
  BOTTOM w0.102: U1.A61 U1.C61
DC_TEST_BE1_BG1: length 0.7
  BOTTOM w0.102: U1.BE1 U1.BG1
DC_TEST_BE3_BG3: length 0.7
  BOTTOM w0.102: U1.BE3 U1.BG3
DC_TEST_BE59_BE61: length 0.7
  BOTTOM w0.102: U1.BE61 U1.BE59
DC_TEST_BG59_BG61: length 0.7
  BOTTOM w0.102: U1.BG61 U1.BG59
DC_TEST_C4_D3: length 0.7
  BOTTOM w0.102: U1.C4 130.59,36.84 U1.D3
DDR3_DRAMRST#: length 87.6
  TOP w0.102: RD4.2 RD3.2 73.56,21.25 73.56,20.09 73.9,19.75 v2(74.83,19.75) v1(75.81,19.75) ; RC48.2 134.12,21.22 134.11,21.22 QC2.1 134.11,19.31 134.55,18.87 v1(134.55,16.14)
  IN3 w0.122: v1(134.55,16.14) 133.76,16.14 131.86,18.04 109.24,18.04 107.56,19.73 96.92,19.73 96.28,19.08 96.28,16.52 91.75,12 87.9,12 84.84,8.95 79.21,8.95 78.63,9.52 77.52,9.52 76.98,10.07 76.98,18.58 v1(75.81,19.75)
DDR3_DRAMRST#_CPU: length 49.9
  TOP w0.102: QC2.3 136.01,21.31 RC48.1 135.57,22.75 v1(135.79,22.98) 135.8,22.98 v2(136.66,23.84) 137.27,24.45 137.27,25.24 RC50.1
  IN4 w0.084: v1(135.79,22.98) 135.54,22.72 131.26,22.72 128.73,25.24 128.73,26.77 127.84,27.66 125.56,27.66 124.74,28.48 124.74,29.8 122.97,31.57 122.97,35.82 121.8,36.99 121.8,43.15 121.56,43.39 121.56,48.42 120.21,49.77 115.19,49.77 v1(114.8,50.16)
  BOTTOM w0.102: v1(114.8,50.16) 114.44,50.53 U1.AT30
DDR3_DRAMRST#_R: length 48.9
  TOP w0.102: v1(66.69,23.09) 67.66,22.12 v2(68.38,22.12) RD4.1
  BOTTOM w0.102: 65.48,27.95 65.51,27.95 65.94,27.52 65.94,23.84 v1(66.69,23.09) ; 65.48,27.95 JDIMM2.30 ; 65.48,27.95 66.05,28.51 66.05,43.15 66.73,43.84 70.72,43.84 73.51,41.04 73.51,31.5 74.06,30.95 75.4,30.95 75.41,30.95 JDIMM1.30
DDR_A_BS0: length 54.2
  IN4 w0.084: 101.87,54.76 102.82,54.76 103.89,53.69 107.17,53.69 v1(107.27,53.79)
  IN4 w0.132: v3(70.45,57.26) 70.45,56.92 70.35,56.82 69.25,56.82 69.14,56.72 69.14,55.34 69.25,55.24 69.6,55.24 69.7,55.34 69.7,56.23 69.8,56.33 70.13,56.33 70.24,56.23 70.24,55.38 70.34,55.28 70.67,55.28 70.77,55.38 70.77,56.26 70.87,56.36 71.19,56.36 71.29,56.26 71.29,55.48 71.39,55.38 71.75,55.38 71.86,55.48 71.86,56.64 71.96,56.74 75.61,56.74 76.12,56.23 77.08,56.23 77.63,55.68 79.62,55.68 80.17,56.23 91.79,56.23 93.26,54.76 101.87,54.76
  BOTTOM w0.102: v1(107.27,53.79) 107.68,54.2 108.76,54.2 108.94,54.02 110.31,54.02 U1.BD37
  BOTTOM w0.17: JDIMM1.109 69.12,57.05 69.39,56.79 69.98,56.79 v3(70.45,57.26)
DDR_A_BS1: length 50.8
  IN4 w0.132: v1(105.97,54.1) 106.18,54.1 106.3,54.22 106.3,54.83 106.18,54.96 104.19,54.96 103.59,55.56 93.59,55.56 92.05,57.1 91.15,57.1 91.03,57.23 91.03,57.81 90.9,57.94 90.61,57.94 90.48,57.81 90.48,57.22 90.35,57.1 90.08,57.1 89.95,57.22 89.95,57.81 89.82,57.94 89.55,57.94 89.42,57.81 89.42,57.22 89.3,57.1 89.02,57.1 88.89,57.22 88.89,57.81 88.77,57.94 88.49,57.94 88.37,57.81 88.37,57.22 88.24,57.1 87.96,57.1 87.84,57.22 87.84,57.81 87.71,57.94 87.44,57.94 87.31,57.81 87.31,57.22 87.18,57.1 86.91,57.1 86.78,57.22 86.78,57.81 86.65,57.94 86.38,57.94 86.25,57.81 86.25,57.22 86.13,57.1 85.85,57.1 85.72,57.22 85.72,57.81 85.6,57.94 85.32,57.94 85.2,57.81 85.2,57.22 85.07,57.1 84.79,57.1 84.67,57.22 84.67,57.81 84.54,57.94 84.27,57.94 84.14,57.81 84.14,57.22 84.01,57.1 83.74,57.1 83.61,57.22 83.61,57.81 83.48,57.94 83.21,57.94 83.08,57.81 83.08,57.22 82.96,57.1 82.68,57.1 82.55,57.22 82.55,57.81 82.43,57.94 82.15,57.94 82.03,57.81 82.03,57.22 81.9,57.1 81.62,57.1 81.5,57.22 81.5,57.81 81.37,57.94 80.36,57.94 80.23,57.81 v3(80.23,57.26)
  BOTTOM w0.102: U1.BF36 106.93,53.13 v1(105.97,54.1)
  BOTTOM w0.165: 77.51,56.75 77.64,56.62 77.64,56.45 77.77,56.32 78.05,56.32 78.17,56.45 78.17,56.67 78.3,56.8 78.58,56.8 78.71,56.67 78.71,56.57 78.83,56.45 79.1,56.45 79.23,56.57 79.23,56.67 79.35,56.8 79.77,56.8 v3(80.23,57.26)
  BOTTOM w0.17: JDIMM1.108 77.51,56.75
DDR_A_BS2: length 53
  IN4 w0.084: 107.81,47.4 108.52,48.12 109.31,48.12 110.79,49.6 112.04,49.6 v1(112.48,49.16)
  IN4 w0.132: v3(71.98,46.9) 72.47,46.41 73.03,46.41 73.58,45.87 76.26,45.87 76.4,45.74 76.4,44.86 76.5,44.76 76.82,44.76 76.92,44.86 76.92,45.74 77.06,45.87 77.32,45.87 77.45,45.74 77.45,45.11 77.55,45 77.88,45 77.98,45.11 77.98,45.79 78.08,45.9 78.41,45.9 78.51,45.79 78.51,45.01 78.61,44.91 78.94,44.91 79.04,45.01 79.04,45.74 79.17,45.87 79.43,45.87 79.57,45.74 79.57,45.67 79.7,45.54 94.19,45.54 94.77,46.11 98.78,46.11 100.07,47.4 107.81,47.4
  BOTTOM w0.102: v1(112.48,49.16) 112.14,49.5 U1.BA28
  BOTTOM w0.17: v3(71.98,46.9) 70.83,48.05 JDIMM1.79
DDR_A_CAS#: length 50.7
  IN4 w0.084: v1(106,55.73) 105.61,56.13 102.27,56.13 102.04,56.36 101.87,56.36
  IN4 w0.132: v3(70.45,59.54) 70.45,59.86 70.33,59.99 68.94,59.99 68.81,59.86 68.81,59.22 68.94,59.1 70.08,59.1 70.21,58.97 70.21,57.84 70.34,57.71 70.6,57.71 70.73,57.84 70.73,58.97 70.85,59.1 76.48,59.1 76.83,58.74 91.54,58.74 93.92,56.36 101.87,56.36
  BOTTOM w0.102: v1(106,55.73) 106.73,55.73 107.6,54.86 109.31,54.86 109.62,54.55 U1.BE39
  BOTTOM w0.165: 69.9,58.99 v3(70.45,59.54)
  BOTTOM w0.17: 69.9,58.99 69.76,58.85 JDIMM1.115
DDR_A_D0: length 63.3
  IN4 w0.084: v3(71.13,24.23) 71.56,23.81 74.34,23.81 76.73,21.42 83.75,21.42 89.19,26.86 104.26,26.86 106.78,29.38 116.21,29.38 118.81,31.97 118.81,36.39 119.13,36.71 119.13,37.81 v1(118.91,38.03)
  BOTTOM w0.102: U1.AG6 119.23,38.36 v1(118.91,38.03) ; v3(71.13,24.23) 70.35,23.45 JDIMM1.5
DDR_A_D1: length 63.1
  IN4 w0.084: v1(117.92,38.03) 117.83,37.95 117.83,36.6 117.25,36.01 117.25,31.78 115.71,30.24 106.42,30.24 103.9,27.72 88.83,27.72 87.42,26.3 85.36,26.3 84.4,25.35 84.4,23.85 83.95,23.4 81.38,23.4 81.26,23.27 81.26,23.04 81.13,22.92 78.16,22.92 78.03,23.04 78.03,24.16 77.91,24.29 72.52,24.29 72.4,24.42 72.4,24.77 72.27,24.9 69.78,24.9 69.61,24.73 v3(69.61,24.23)
  BOTTOM w0.102: U1.AJ6 118.24,38.36 v1(117.92,38.03) ; JDIMM1.7 69.43,24.05 v3(69.61,24.23)
DDR_A_D2: length 66
  IN4 w0.084: v3(69.61,25.88) 69.61,27.1 69.74,27.22 69.96,27.22 70.09,27.1 70.09,26.6 70.19,26.5 70.33,26.5 70.43,26.6 70.43,27.13 70.51,27.21 70.68,27.21 70.76,27.13 70.76,26.61 70.86,26.51 71,26.51 71.1,26.61 71.1,27.13 71.18,27.21 71.35,27.21 71.43,27.13 71.43,26.61 71.53,26.51 71.67,26.51 71.77,26.61 71.77,27.13 71.85,27.21 76.92,27.21 77.84,26.3 82.32,26.3 84.35,28.33 86.58,28.33 87.99,29.74 98.28,29.74 99.51,30.97 103.75,30.97 106.2,33.42 111.13,33.42 111.25,33.3 111.25,32.6 111.38,32.48 113.22,32.48 113.34,32.6 113.34,35.73 113.97,36.36 115,36.36 116.11,37.47 116.11,40.72 v1(115.39,41.44)
  BOTTOM w0.102: JDIMM1.15 69.04,26.45 v3(69.61,25.88) ; v1(115.39,41.44) 115.49,41.44 U1.AP11
DDR_A_D3: length 62.4
  IN4 w0.084: v3(71.13,25.88) 71.13,25.5 71.26,25.37 72.57,25.37 72.7,25.24 72.7,24.7 72.83,24.58 73.07,24.58 73.2,24.7 73.2,25.62 73.32,25.75 73.53,25.75 73.65,25.62 73.65,24.7 73.78,24.58 74.02,24.58 74.15,24.7 74.15,25.57 74.27,25.7 74.47,25.7 74.59,25.57 74.59,24.7 74.72,24.58 76.18,24.58 76.18,24.58 81.82,24.58 84.71,27.47 86.94,27.47 88.35,28.88 98.64,28.88 99.87,30.11 104.11,30.11 105.6,31.61 114,31.61 114.88,32.48 114.88,34.98 116.93,37.03 v1(116.93,37.98)
  BOTTOM w0.102: v1(116.93,37.98) 117.25,38.31 U1.AL6 ; JDIMM1.17 69.96,27.05 v3(71.13,25.88)
DDR_A_D4: length 63.2
  IN4 w0.084: v1(117.92,39.99) 118.51,39.4 118.51,37.69 118.22,37.39 118.22,36.84 118.52,36.53 118.52,32.09 116.09,29.66 106.66,29.66 104.14,27.15 89.07,27.15 87.65,25.73 87.19,25.73 87.06,25.6 87.06,25.19 86.94,25.07 86.78,25.07 86.66,25.19 86.66,25.6 86.53,25.73 86.37,25.73 86.24,25.6 86.24,24.68 86.11,24.56 85.11,24.56 84.98,24.43 84.98,24.27 85.11,24.14 85.64,24.14 85.76,24.02 85.76,23.85 85.64,23.73 85.11,23.73 84.98,23.6 84.98,23.07 84.73,22.82 83.83,22.82 83.7,22.69 83.7,21.83 83.57,21.7 76.88,21.7 76.75,21.83 76.75,22 76.88,22.13 v3(78.19,22.13)
  BOTTOM w0.102: v1(117.92,39.99) 118.23,40.31 U1.AJ10 ; v3(78.19,22.13) 78.19,22.35 77.39,23.15 JDIMM1.4
DDR_A_D5: length 63.8
  IN4 w0.084: v1(117.92,39.34) 118.32,38.93 118.32,37.77 118.02,37.47 118.02,36.35 117.54,35.87 117.54,31.67 115.82,29.95 106.54,29.95 104.02,27.43 88.95,27.43 87.54,26.02 85.48,26.02 85.35,25.89 85.35,25 85.22,24.87 84.82,24.87 84.69,24.75 84.69,23.34 84.46,23.11 83.52,23.11 83.38,22.96 83.38,22.08 83.29,21.99 83.12,21.99 83.04,22.08 83.04,23.01 82.94,23.11 82.8,23.11 82.71,23.01 82.71,22.08 82.62,21.99 82.45,21.99 82.37,22.08 82.37,23.01 82.27,23.11 82.13,23.11 82.03,23.01 82.03,22.08 81.95,21.99 81.78,21.99 81.7,22.08 81.7,22.75 81.6,22.84 81.46,22.84 81.36,22.75 81.36,22.08 81.28,21.99 81.11,21.99 81.03,22.08 81.03,22.5 80.9,22.63 79.84,22.63 79.71,22.5 v3(79.71,22.13)
  BOTTOM w0.102: U1.AJ8 118.24,39.66 v1(117.92,39.34) ; v3(79.71,22.13) 79.94,22.13 80.06,22.25 80.06,22.68 79.94,22.8 78.46,22.8 77.51,23.75 JDIMM1.6
DDR_A_D6: length 64
  IN4 w0.084: v1(116.93,39.29) 116.3,38.67 116.3,37.31 115.12,36.13 114.03,36.13 113.63,35.73 113.63,32.42 113.4,32.19 111.18,32.19 110.97,32.41 110.97,33.01 110.84,33.14 106.32,33.14 103.87,30.69 99.63,30.69 98.4,29.45 88.11,29.45 86.7,28.04 84.47,28.04 82.42,25.99 77.08,25.99 76.95,26.12 76.95,26.77 76.85,26.87 76.65,26.87 76.52,26.74 76.52,25.93 76.4,25.81 76.24,25.81 76.12,25.93 76.12,26.81 76,26.93 75.82,26.93 75.7,26.8 75.7,25.97 75.57,25.84 75.43,25.84 75.3,25.97 75.3,26.8 75.18,26.93 75.01,26.93 74.88,26.8 74.88,25.44 75.01,25.32 v3(78.19,25.32)
  BOTTOM w0.102: JDIMM1.16 77.38,26.75 78.19,25.94 v3(78.19,25.32) ; v1(116.93,39.29) 117.25,39.61 U1.AL8
DDR_A_D7: length 63.6
  IN4 w0.084: v1(116.93,38.63) 116.51,38.22 116.51,36.98 114.58,35.06 114.58,34.06 113.92,33.39 113.92,32.02 113.79,31.89 110.78,31.89 110.65,32.02 110.65,32.75 110.57,32.84 110.4,32.84 110.31,32.75 110.31,31.98 110.23,31.9 110.06,31.9 109.98,31.98 109.98,32.75 109.9,32.84 109.73,32.84 109.64,32.75 109.64,31.98 109.56,31.9 109.39,31.9 109.31,31.98 109.31,32.75 109.22,32.84 109.06,32.84 108.97,32.75 108.97,31.98 108.89,31.9 108.72,31.9 108.64,31.98 108.64,32.75 108.55,32.84 108.39,32.84 108.3,32.75 108.3,31.98 108.22,31.9 108.05,31.9 107.97,31.98 107.97,32.75 107.88,32.84 107.72,32.84 107.63,32.75 107.63,31.98 107.55,31.9 107.38,31.9 107.3,31.98 107.3,32.75 107.21,32.84 107.05,32.84 106.96,32.75 106.96,32 106.85,31.89 106.7,31.89 106.6,32 106.6,32.63 106.48,32.74 106.33,32.74 106.22,32.63 106.22,32.03 106.09,31.9 105.48,31.9 103.99,30.4 99.75,30.4 98.52,29.17 88.23,29.17 86.82,27.76 84.59,27.76 82.51,25.68 81.81,25.68 81.72,25.59 81.72,24.97 81.64,24.89 81.47,24.89 81.39,24.97 81.39,25.59 81.3,25.68 81.14,25.68 81.05,25.59 81.05,24.97 80.97,24.89 79.84,24.89 79.71,25.01 v3(79.71,25.32)
  BOTTOM w0.102: v3(79.71,25.32) 79.71,25.74 79.3,26.15 78.43,26.15 77.23,27.35 JDIMM1.18 ; U1.AL7 117.25,38.96 v1(116.93,38.63)
DDR_A_D8: length 57
  IN4 w0.084: v1(115.51,40.69) 115.91,40.28 115.91,37.67 114.83,36.58 113.94,36.58 112.22,34.87 112.22,34.33 111.92,34.02 110.29,34.02 110.2,33.93 106.01,33.93 103.54,31.46 99.31,31.46 98.08,30.23 86.55,30.23 85.87,29.55 84.88,29.55 82.13,26.8 78.02,26.8 77.12,27.7 70.33,27.7 v3(69.61,28.42)
  BOTTOM w0.102: U1.AR11 115.22,40.98 v1(115.51,40.69) ; v3(69.61,28.42) 69.44,28.25 JDIMM1.21
DDR_A_D9: length 53.1
  IN4 w0.084: v3(71.13,28.42) 71.13,28.42 71.56,27.99 77.24,27.99 78.11,27.12 82.04,27.12 84.76,29.84 85.76,29.84 86.43,30.52 97.96,30.52 99.19,31.75 103.43,31.75 105.87,34.2 109.91,34.2 111.7,35.99 113.04,35.99 114.51,37.46 114.91,37.46 v1(115.51,38.06)
  BOTTOM w0.102: U1.AP6 115.84,38.39 v1(115.51,38.06) ; JDIMM1.23 69.27,28.85 69.27,28.85 70.7,28.85 v3(71.13,28.42)
DDR_A_D10: length 53.3
  IN4 w0.084: v1(113.46,37.99) 112.56,37.09 111.32,37.09 110.83,36.6 109.87,36.6 109.25,35.97 105.51,35.97 104.68,35.15 103.94,35.15 102.29,33.5 91.28,33.5 91.15,33.38 91.15,32.36 91.04,32.25 90.89,32.25 90.78,32.36 90.78,33.39 90.67,33.5 90.51,33.5 90.39,33.39 90.39,32.38 90.27,32.25 84.7,32.25 82,29.56 78.06,29.56 76.91,30.7 70.22,30.7 v3(69.61,31.31)
  BOTTOM w0.102: v3(69.61,31.31) 69.69,31.31 69.15,31.85 JDIMM1.33 ; U1.AU6 113.79,38.33 v1(113.46,37.99)
DDR_A_D11: length 54.7
  IN4 w0.084: v1(113.05,39.24) 113.05,38.75 112.67,38.37 112.67,38.09 112.31,37.73 111.05,37.73 110.53,37.2 109.69,37.2 109.18,36.69 105.21,36.69 104.46,35.94 103.49,35.94 101.92,34.36 85.59,34.36 82.31,31.08 74.22,31.08 74.1,31.21 74.1,31.67 73.98,31.78 73.81,31.78 73.69,31.67 73.69,31.21 73.56,31.08 73.37,31.08 73.25,31.21 73.25,31.66 73.12,31.78 72.93,31.78 72.8,31.66 72.8,31.16 72.67,31.03 72.51,31.03 72.38,31.16 72.38,31.69 72.26,31.82 71.26,31.82 71.13,31.69 v3(71.13,31.31)
  BOTTOM w0.102: v3(71.13,31.31) 71.13,31.62 71.26,31.74 71.58,31.74 71.71,31.87 71.71,32.32 71.58,32.45 JDIMM1.35 ; U1.AV9 113.05,39.35 v1(113.05,39.24)
DDR_A_D12: length 53.6
  IN4 w0.084: v3(77.99,27.86) 78.42,28.29 82.4,28.29 85.2,31.09 91.76,31.09 91.89,31.22 91.89,31.46 92,31.57 92.17,31.57 92.28,31.46 92.28,31.2 92.39,31.09 92.54,31.09 92.65,31.2 92.65,32.22 92.76,32.33 92.92,32.33 93.03,32.22 93.03,31.18 93.12,31.09 93.28,31.09 93.37,31.18 93.37,32.24 93.47,32.34 93.61,32.34 93.7,32.24 93.7,31.18 93.79,31.09 93.96,31.09 94.04,31.18 94.04,32.24 94.14,32.34 94.28,32.34 94.37,32.24 94.37,31.2 94.48,31.1 94.63,31.1 94.73,31.2 94.73,32.23 94.85,32.34 95.02,32.34 95.13,32.23 95.13,31.2 95.24,31.09 95.39,31.09 95.5,31.2 95.5,32.22 95.62,32.34 103.21,32.34 106.23,35.37 109.66,35.37 110.16,35.87 110.88,35.87 111.44,36.43 112.96,36.43 114.56,38.04 v1(114.56,38.04)
  BOTTOM w0.102: v1(114.56,38.04) 114.9,38.38 U1.AR6 ; v3(77.99,27.86) 77.99,28.01 77.44,28.55 JDIMM1.22
DDR_A_D13: length 54
  IN4 w0.084: v3(79.51,27.86) 79.94,27.42 81.94,27.42 85.32,30.81 95.81,30.81 95.9,30.89 95.9,31.95 95.98,32.04 96.15,32.04 96.23,31.95 96.23,30.89 96.32,30.81 96.48,30.81 96.57,30.89 96.57,31.95 96.65,32.04 96.82,32.04 96.9,31.95 96.9,30.89 96.99,30.81 97.15,30.81 97.24,30.89 97.24,31.95 97.32,32.04 97.49,32.04 97.57,31.95 97.57,30.89 97.66,30.81 97.83,30.81 97.91,30.89 97.91,31.95 97.99,32.04 103.31,32.04 106.36,35.09 109.68,35.09 110.24,35.65 110.92,35.65 111.46,36.19 112.98,36.19 114.44,37.64 114.73,37.64 115.11,38.03 115.11,38.9 115.51,39.3 v1(115.51,39.37)
  BOTTOM w0.102: v1(115.51,39.37) 115.83,39.69 U1.AP8 ; JDIMM1.24 78.55,29.15 79.33,29.15 79.47,29.01 79.47,27.93 79.48,27.92 79.48,27.87 79.51,27.84 v3(79.51,27.86)
DDR_A_D14: length 53.3
  IN4 w0.084: v1(114.05,41.32) 114.05,40.99 114.15,40.89 114.15,39.97 113.71,39.54 113.71,38.84 113.06,38.18 113.06,37.94 112.42,37.31 111.26,37.31 110.74,36.79 109.8,36.79 109.23,36.22 105.4,36.22 104.6,35.42 103.8,35.42 102.17,33.79 90.19,33.79 90.11,33.71 90.11,32.63 90.02,32.55 89.86,32.55 89.77,32.63 89.77,33.71 89.69,33.79 89.52,33.79 89.44,33.71 89.44,32.65 89.33,32.54 89.17,32.54 89.06,32.65 89.06,33.68 88.94,33.79 88.78,33.79 88.67,33.68 88.67,32.67 88.54,32.54 84.58,32.54 81.88,29.85 78.37,29.85 v3(77.95,30.27)
  BOTTOM w0.102: v3(77.95,30.27) 77.95,30.66 78.07,30.79 78.74,30.79 78.87,30.92 78.87,31.87 78.74,32 77.61,32 77.45,32.15 JDIMM1.34 ; U1.AT13 114.05,41.47 v1(114.05,41.32)
DDR_A_D15: length 55.9
  IN4 w0.084: v1(113.4,41.32) 113.96,40.77 113.96,40.05 113.52,39.61 113.52,38.93 112.87,38.27 112.87,38.02 112.36,37.51 111.18,37.51 110.68,37.01 109.76,37.01 109.2,36.44 105.3,36.44 104.55,35.7 103.67,35.7 102.05,34.08 88.51,34.08 88.38,33.95 88.38,32.94 88.27,32.83 88.11,32.83 87.99,32.94 87.99,33.97 87.88,34.08 87.73,34.08 87.63,33.97 87.63,32.92 87.54,32.84 87.37,32.84 87.29,32.92 87.29,33.99 87.21,34.08 87.04,34.08 86.95,33.99 86.95,32.92 86.87,32.84 86.7,32.84 86.62,32.92 86.62,33.99 86.54,34.08 86.37,34.08 86.28,33.99 86.28,32.92 86.2,32.84 86.03,32.84 85.95,32.92 85.95,33.99 85.87,34.08 85.71,34.08 85.58,33.95 85.58,32.95 85.45,32.83 84.46,32.83 82.42,30.79 80,30.79 v3(79.47,30.27)
  BOTTOM w0.102: JDIMM1.36 77.29,32.75 77.74,32.3 78.96,32.3 79.46,31.81 79.46,30.28 v3(79.47,30.27) ; v1(113.4,41.32) 113.4,41.47 U1.AU13
DDR_A_D16: length 50.5
  IN4 w0.084: v1(110.65,38.29) 110.39,38.29 109.03,36.94 105.1,36.94 104.32,36.16 103.03,36.16 101.72,34.86 85.39,34.86 82.6,32.07 74.38,32.07 74.03,32.43 71.61,32.43 71.44,32.6 71.44,33.22 71.32,33.34 71.16,33.34 71.04,33.22 71.04,32.53 70.91,32.41 70.72,32.41 70.59,32.53 70.59,33.3 70.46,33.43 70.27,33.43 70.15,33.3 70.15,32.55 70.02,32.42 69.82,32.42 69.69,32.55 v3(69.69,33.85)
  BOTTOM w0.102: v1(110.65,38.29) 111.07,38.71 U1.BC7 ; JDIMM1.39 69.49,33.65 v3(69.69,33.85)
DDR_A_D17: length 51.2
  IN4 w0.084: v1(111.6,38.22) 111.6,38.33 111.21,38.72 110.51,38.72 108.98,37.19 103.65,37.19 101.6,35.14 84.43,35.14 84.31,35.02 84.31,34.23 84.18,34.11 84,34.11 83.88,34.23 83.88,35.02 83.75,35.14 83.56,35.14 83.43,35.02 83.43,33.3 82.48,32.36 74.5,32.36 74.15,32.71 72.35,32.71 v3(71.22,33.85)
  BOTTOM w0.102: JDIMM1.41 69.47,34.25 69.63,34.41 71.29,34.41 71.42,34.28 71.42,33.98 71.29,33.85 v3(71.22,33.85) ; U1.BB7 111.76,38.37 v1(111.6,38.22)
DDR_A_D18: length 53.3
  IN4 w0.084: v3(69.69,37.11) 69.69,38.38 69.82,38.5 70.03,38.5 70.15,38.38 70.15,37.79 70.24,37.7 70.4,37.7 70.49,37.79 70.49,38.43 70.57,38.51 70.74,38.51 70.82,38.43 70.82,37.79 70.91,37.7 71.08,37.7 71.16,37.79 71.16,38.43 71.24,38.51 71.46,38.51 71.55,38.43 71.55,37.77 71.63,37.69 71.8,37.69 71.88,37.77 71.88,38.43 71.97,38.51 73.5,38.51 75.56,36.46 81.03,36.46 82.31,37.74 93.22,37.74 94.38,38.9 100.97,38.9 102.35,40.27 105.44,40.27 105.53,40.18 106.94,40.18 107.45,40.69 109.08,40.69 109.46,41.07 111.27,41.07 111.46,40.88 111.71,40.88 v1(112.13,41.3)
  BOTTOM w0.102: U1.BA13 112.13,41.58 v1(112.13,41.3) ; v3(69.69,37.11) 69.55,37.25 JDIMM1.51
DDR_A_D19: length 51.5
  IN4 w0.084: v3(71.22,37.11) 71.73,36.6 73.3,36.6 73.42,36.47 73.42,34.84 73.55,34.72 73.78,34.72 73.91,34.84 73.91,36.48 74.03,36.61 74.24,36.61 74.37,36.48 74.37,34.84 74.5,34.72 80.51,34.72 82.67,36.88 97.77,36.88 98.93,38.04 101.5,38.04 102.45,38.99 108.63,38.99 109.92,40.29 v1(110.93,40.29)
  BOTTOM w0.102: v1(110.93,40.29) 111.37,40.72 U1.BB11 ; v3(71.22,37.11) 70.48,37.85 JDIMM1.53
DDR_A_D20: length 52.1
  IN4 w0.084: v1(111.78,39.23) 110.48,39.23 109.67,38.43 103.53,38.43 101.98,36.88 100.72,36.88 100.59,36.75 100.59,35.84 100.46,35.72 100.27,35.72 100.14,35.84 100.14,36.75 100.02,36.88 99.83,36.88 99.7,36.75 99.7,35.83 99.59,35.72 99.43,35.72 99.32,35.83 99.32,36.36 99.2,36.48 99.02,36.48 98.9,36.36 98.9,35.84 98.77,35.72 83.15,35.72 80.98,33.55 75.29,33.55 75.16,33.42 75.16,32.93 75.29,32.81 v3(77.95,32.81)
  BOTTOM w0.102: U1.BA7 112.21,38.71 111.78,39.14 v1(111.78,39.23) ; v3(77.95,32.81) 77.95,33.12 78.07,33.24 78.91,33.24 79.04,33.37 79.04,34.12 78.91,34.25 77.75,34.25 77.46,33.95 JDIMM1.40
DDR_A_D21: length 51.7
  IN4 w0.084: v3(79.47,32.81) 79.9,33.24 81.23,33.24 81.36,33.12 81.36,32.77 81.49,32.65 81.68,32.65 81.79,32.76 81.79,33.95 81.89,34.05 82.03,34.05 82.13,33.95 82.13,32.74 82.23,32.65 82.36,32.65 82.46,32.74 82.46,34.62 82.56,34.72 82.7,34.72 82.8,34.62 82.8,33.56 82.9,33.46 83.04,33.46 83.14,33.56 83.14,35.3 83.27,35.43 100.75,35.43 100.88,35.56 100.88,36.47 101,36.59 101.17,36.59 101.29,36.47 101.29,35.65 101.41,35.53 101.58,35.53 101.71,35.65 101.71,36.46 101.83,36.59 102.1,36.59 103.52,38.01 104.38,38.01 104.77,37.61 109.13,37.61 110.43,38.91 111.34,38.91 111.64,38.62 112.44,38.62 112.57,38.74 112.57,39.1 112.44,39.23 v1(112.4,39.23)
  BOTTOM w0.102: JDIMM1.42 79.52,34.55 79.65,34.42 79.65,32.94 79.52,32.81 v3(79.47,32.81) ; v1(112.4,39.23) 112.1,39.54 U1.BA9
DDR_A_D22: length 50.7
  IN4 w0.084: v1(111.6,40.24) 111.56,40.24 111.11,40.69 110.06,40.69 108.55,39.18 102.07,39.18 101.21,38.32 98.81,38.32 97.66,37.16 82.55,37.16 80.39,35 75.38,35 75.25,35.13 75.25,36.04 75.38,36.17 75.56,36.17 75.68,36.04 75.68,35.47 75.76,35.39 75.93,35.39 76.02,35.47 76.02,36.08 76.1,36.17 76.27,36.17 76.35,36.08 76.35,35.47 76.44,35.39 76.6,35.39 76.69,35.47 76.69,36.08 76.77,36.17 76.94,36.17 77.02,36.08 77.02,35.47 77.11,35.39 77.27,35.39 77.36,35.47 77.36,36.08 77.44,36.17 77.82,36.17 77.95,36.04 v3(77.95,35.54)
  BOTTOM w0.102: v1(111.6,40.24) 111.45,40.08 U1.BB9 ; JDIMM1.50 77.82,36.95 77.95,36.82 v3(77.95,35.54)
DDR_A_D23: length 51.7
  IN4 w0.084: v1(112.75,41.29) 112.15,40.69 111.38,40.69 111.19,40.88 109.53,40.88 109.16,40.51 107.52,40.51 107.01,40 105.44,40 105.35,40.09 102.57,40.09 101.09,38.61 97.78,38.61 97.66,38.48 97.66,37.57 97.54,37.45 97.37,37.45 97.25,37.57 97.25,38.48 97.12,38.61 96.96,38.61 96.88,38.53 96.88,37.54 96.79,37.46 96.63,37.46 96.54,37.54 96.54,38.51 96.44,38.61 96.31,38.61 96.21,38.51 96.21,37.54 96.12,37.46 95.96,37.46 95.87,37.54 95.87,38.51 95.77,38.61 95.64,38.61 95.54,38.51 95.54,37.54 95.45,37.46 95.29,37.46 95.2,37.54 95.2,38.51 95.1,38.61 94.95,38.61 94.85,38.51 94.85,37.56 94.74,37.45 94.58,37.45 94.47,37.56 94.47,38.12 94.36,38.24 94.2,38.24 94.09,38.12 94.09,37.58 93.96,37.45 82.43,37.45 81.13,36.15 80.08,36.15 v3(79.47,35.54)
  BOTTOM w0.102: v3(79.47,35.54) 79.47,37.42 79.34,37.55 JDIMM1.52 ; v1(112.75,41.29) 112.75,41.61 U1.AY13
DDR_A_D24: length 51.6
  IN4 w0.084: v3(69.69,39.65) 70.22,40.18 74.23,40.18 74.36,40.05 74.36,39.88 74.45,39.79 74.59,39.79 74.69,39.88 74.69,40.05 74.82,40.18 75.04,40.18 75.15,40.07 75.15,38.48 76.3,37.32 80.77,37.32 82.02,38.57 92.96,38.57 94.06,39.67 100.65,39.67 102.21,41.24 108.44,41.24 109.22,42.01 112.85,42.01 v1(113.75,42.91)
  BOTTOM w0.102: U1.AV14 113.47,42.64 v1(113.75,42.91) ; v3(69.69,39.65) 69.09,39.05 JDIMM1.57
DDR_A_D25: length 51.5
  IN4 w0.084: v1(115.24,42.9) 114.76,42.43 113.57,42.43 112.96,41.82 109.31,41.82 108.52,41.04 102.42,41.04 100.77,39.39 94.18,39.39 93.04,38.25 82.13,38.25 80.92,37.04 76.18,37.04 73.99,39.23 71.64,39.23 v3(71.22,39.65)
  BOTTOM w0.102: JDIMM1.59 69.08,39.65 69.51,40.08 70.78,40.08 v3(71.22,39.65) ; v1(115.24,42.9) 115.42,42.72 U1.AR14
DDR_A_D26: length 50.1
  IN4 w0.084: v1(113.07,44.8) 112.97,44.8 112.54,44.37 103.43,44.37 102.83,43.76 101.44,43.76 99.67,41.99 73.64,41.99 73.51,41.86 73.51,41.07 73.39,40.94 73.14,40.94 73.02,41.07 73.02,41.79 72.89,41.92 72.65,41.92 72.52,41.79 72.52,40.99 72.4,40.86 70.17,40.86 v3(69.69,41.34)
  BOTTOM w0.102: U1.AY17 112.74,44.47 v1(113.07,44.8) ; v3(69.69,41.34) 69.69,41.75 69.39,42.05 JDIMM1.67
DDR_A_D27: length 50
  IN4 w0.084: v1(115.02,44.79) 114.61,45.2 111.87,45.2 111.31,44.65 103.26,44.65 102.67,44.07 101.34,44.07 99.55,42.27 71.7,42.27 71.22,41.79 v3(71.22,41.34)
  BOTTOM w0.102: v3(71.22,41.34) 69.91,42.65 JDIMM1.69 ; U1.AR19 115.34,45.12 v1(115.02,44.79)
DDR_A_D28: length 50.4
  IN4 w0.084: v3(77.95,38.08) 75.96,38.08 75.83,38.2 75.83,39.3 75.9,39.38 76.19,39.38 76.27,39.3 76.27,38.57 76.34,38.49 76.6,38.49 76.67,38.57 76.67,39.31 76.75,39.39 77.03,39.39 77.11,39.31 77.11,38.57 77.18,38.49 77.45,38.49 77.53,38.57 77.53,39.34 77.6,39.42 77.83,39.42 77.9,39.34 77.9,38.63 77.98,38.55 78.24,38.55 78.31,38.63 78.31,39.19 78.39,39.26 78.57,39.26 78.65,39.19 78.65,38.58 78.73,38.5 78.91,38.5 78.98,38.58 78.98,38.68 79.06,38.75 79.24,38.75 79.32,38.68 79.32,38.56 79.38,38.5 81.09,38.5 81.74,39.15 89.87,39.15 90,39.28 90,40.12 90.13,40.25 100.41,40.25 102.56,42.4 111.74,42.4 v1(112.27,42.93)
  BOTTOM w0.102: v1(112.27,42.93) 112.27,42.53 U1.BA14 ; JDIMM1.56 77.86,38.75 77.95,38.67 v3(77.95,38.08)
DDR_A_D29: length 51.2
  IN4 w0.084: v3(114.45,42.86) 114,43.32 112.87,43.32 112.68,43.13 112.68,42.75 112.15,42.21 102.78,42.21 100.53,39.96 93.1,39.96 93.02,39.88 93.02,39.12 92.92,39.02 92.78,39.02 92.68,39.12 92.68,39.88 92.6,39.96 92.43,39.96 92.35,39.88 92.35,38.97 92.26,38.88 92.1,38.88 92.01,38.97 92.01,39.88 91.93,39.96 91.76,39.96 91.68,39.88 91.68,38.97 91.59,38.88 91.43,38.88 91.34,38.97 91.34,39.88 91.26,39.96 91.09,39.96 91.01,39.88 91.01,38.97 90.92,38.88 90.75,38.88 90.67,38.97 90.67,39.88 90.59,39.96 90.41,39.96 90.29,39.83 90.29,38.98 90.16,38.86 81.87,38.86 80.63,37.61 79.94,37.61 v1(79.47,38.08)
  BOTTOM w0.102: U1.AU14 114.45,42.76 v3(114.45,42.86) ; v1(79.47,38.08) 79.47,38.2 79.6,38.32 79.77,38.32 79.9,38.45 79.9,38.67 79.77,38.8 78.47,38.8 77.92,39.35 JDIMM1.58
DDR_A_D30: length 50.2
  IN4 w0.084: v3(77.95,41.28) 77.43,41.28 77.34,41.36 77.34,41.61 77.26,41.69 77.09,41.69 77.01,41.61 77.01,41.36 76.92,41.28 76.73,41.28 76.6,41.41 76.6,41.62 76.52,41.7 76.26,41.7 76.18,41.62 76.18,41.22 76.1,41.14 75.76,41.14 75.68,41.22 75.68,41.62 75.61,41.7 75.32,41.7 75.24,41.62 75.24,40.53 75.53,40.24 75.53,39.8 75.61,39.72 75.78,39.72 75.86,39.8 75.86,39.96 75.94,40.04 76.12,40.04 76.2,39.96 76.2,39.8 76.28,39.72 76.45,39.72 76.53,39.8 76.53,39.93 76.61,40.01 76.79,40.01 76.87,39.93 76.87,39.8 76.95,39.72 77.12,39.72 77.2,39.8 77.2,39.93 77.28,40 77.46,40 77.54,39.93 77.54,39.8 77.62,39.72 77.79,39.72 77.87,39.8 77.87,40.09 77.96,40.18 81.1,40.18 81.65,40.73 83.4,40.73 84.08,41.41 99.91,41.41 101.63,43.14 108.62,43.14 109.24,43.76 110.54,43.76 v1(111.1,43.21)
  BOTTOM w0.102: v3(77.95,41.28) 77.95,41.68 78.07,41.8 78.51,41.8 78.64,41.93 78.64,42.22 78.51,42.35 JDIMM1.68 ; U1.BB14 111.52,42.79 v1(111.1,43.21)
DDR_A_D31: length 51.1
  IN4 w0.084: v3(111.12,43.84) 110.82,44.14 103.7,44.14 102.99,43.43 101.52,43.43 99.79,41.7 83.42,41.7 83.34,41.62 83.34,41.15 83.24,41.06 83.1,41.06 83.01,41.15 83.01,41.62 82.92,41.7 82.75,41.7 82.67,41.62 82.67,41.15 82.57,41.06 82.43,41.06 82.33,41.15 82.33,41.62 82.25,41.7 82.08,41.7 82,41.62 82,41.13 81.9,41.03 81.76,41.03 81.66,41.13 81.66,41.62 81.58,41.7 81.41,41.7 81.33,41.62 81.33,41.13 81.23,41.03 81.09,41.03 80.99,41.13 80.99,41.62 80.91,41.7 80.74,41.7 80.66,41.62 80.66,40.69 80.43,40.46 75.8,40.46 75.68,40.58 75.68,40.74 75.8,40.86 79.39,40.86 79.47,40.93 v1(79.47,41.28)
  BOTTOM w0.102: JDIMM1.70 77.45,42.95 77.74,42.66 78.64,42.66 79.47,41.83 v1(79.47,41.28) ; v3(111.12,43.84) 111.44,44.17 U1.BB17
DDR_A_D32: length 55.3
  IN4 w0.084: v3(71.24,64.45) 70.99,64.45 70.88,64.35 70.88,64.12 70.99,64.02 72.44,64.02 72.53,64.1 72.53,64.32 72.63,64.42 72.76,64.42 72.86,64.32 72.86,64.1 72.95,64.02 73.11,64.02 73.2,64.1 73.2,64.55 73.3,64.65 73.43,64.65 73.53,64.55 73.53,64.1 73.62,64.02 73.78,64.02 73.87,64.1 73.87,65.46 73.97,65.55 74.11,65.55 74.2,65.46 74.2,64.1 74.29,64.02 80.4,64.02 81.67,65.29 84.67,65.29 85.16,64.81 91.91,64.81 96.13,60.58 102.01,60.58 102.5,60.08 103.53,60.08 104.1,59.52 104.36,59.52 104.93,58.95 106.08,58.95 106.7,58.33 108.9,58.33 109.5,57.73 110.3,57.73 111.37,56.66 112.01,56.66 112.19,56.85 v1(112.19,57.07)
  BOTTOM w0.102: JDIMM1.129 69.22,63.05 69.98,63.81 70.88,63.81 71.24,64.17 v3(71.24,64.45) ; v1(112.19,57.07) 112.19,57.21 U1.BA45
DDR_A_D33: length 53
  IN4 w0.084: v3(69.71,64.45) 70.43,63.73 80.52,63.73 81.74,64.95 84.6,64.95 85.04,64.52 91.67,64.52 95.89,60.29 101.88,60.29 102.35,59.83 103.51,59.83 104.01,59.33 104.28,59.33 104.87,58.75 105.02,58.75 105.63,58.13 108.84,58.13 109.42,57.55 110.22,57.55 111.3,56.47 115.02,56.47 v1(115.55,56.99)
  BOTTOM w0.102: U1.AR43 115.17,56.62 v1(115.55,56.99) ; JDIMM1.131 69.21,63.65 69.71,64.15 v3(69.71,64.45)
DDR_A_D34: length 55
  IN4 w0.084: v3(71.23,67.18) 72.28,68.24 73.16,68.24 73.25,68.15 73.25,67.11 73.33,67.03 73.5,67.03 73.58,67.11 73.58,68.15 73.67,68.24 73.83,68.24 73.92,68.15 73.92,67.11 74,67.03 74.17,67.03 74.25,67.11 74.25,68.15 74.34,68.24 92.15,68.24 97.21,63.18 102.44,63.18 102.81,62.81 105.23,62.81 105.68,62.36 106,62.36 106.59,61.77 106.59,61.41 106.83,61.18 108.49,61.18 108.98,60.69 109.76,59.91 110.4,59.91 110.7,59.61 112.87,59.61 v1(113.47,59)
  BOTTOM w0.102: v3(71.23,67.18) 70.7,66.65 JDIMM1.141 ; U1.AW48 113.14,59.33 v1(113.47,59)
DDR_A_D35: length 54
  IN4 w0.084: v1(110.97,58.73) 110.89,58.65 109.91,58.65 108.87,59.68 108.87,59.98 108.47,60.39 106.81,60.39 106.19,61.01 103.61,61.01 102.31,62.32 96.85,62.32 92.62,66.54 85.88,66.54 85.39,67.02 80.76,67.02 80.48,66.74 69.3,66.74 69.17,66.87 69.17,68.08 69.3,68.21 71.31,68.21 71.44,68.08 71.44,67.82 71.31,67.7 69.83,67.7 69.7,67.57 v3(69.7,67.18)
  BOTTOM w0.102: v3(69.7,67.18) 69.64,67.25 JDIMM1.143 ; U1.BC48 111.19,58.95 v1(110.97,58.73)
DDR_A_D36: length 53.3
  IN4 w0.084: v3(111.57,57.07) 111.68,57.07 111.82,57.22 111.82,57.57 111.72,57.68 110.62,57.68 110.38,57.92 109.58,57.92 108.94,58.56 106.81,58.56 106.23,59.14 105.02,59.14 104.91,59.24 104.91,60.17 104.81,60.28 104.65,60.28 104.55,60.17 104.55,59.8 104.45,59.7 104.27,59.7 104.17,59.8 104.17,60.17 104.07,60.28 102.71,60.28 102.11,60.87 96.25,60.87 92.02,65.09 85.27,65.09 84.79,65.57 81.45,65.57 81.14,65.27 75.56,65.27 75.46,65.17 75.46,64.84 75.56,64.74 77.64,64.74 77.77,64.88 79.72,64.88 79.82,64.77 79.82,64.55 79.72,64.45 v1(79.47,64.45)
  BOTTOM w0.102: U1.BC45 111.19,57.12 111.29,57.02 111.51,57.02 v3(111.57,57.07) ; v1(79.47,64.45) 79.69,64.45 79.82,64.33 79.82,63.3 79.69,63.18 77.57,63.18 77.4,63.35 JDIMM1.130
DDR_A_D37: length 54
  IN4 w0.084: v1(115.42,57.99) 115.43,57.99 115.55,57.86 115.55,57.68 115.43,57.56 112.62,57.56 112.32,57.87 110.69,57.87 110.46,58.1 109.66,58.1 109.01,58.75 107.11,58.75 106.4,59.46 106.4,59.96 105.89,60.46 102.97,60.46 102.27,61.16 96.37,61.16 92.14,65.38 85.39,65.38 84.91,65.86 81.3,65.86 81,65.55 75.27,65.55 75.17,65.45 75.17,64.55 75.27,64.45 v1(77.95,64.45)
  BOTTOM w0.102: JDIMM1.132 77.45,63.95 77.89,63.51 79.11,63.51 79.24,63.63 79.24,63.89 79.11,64.02 78.15,64.02 77.95,64.22 v1(77.95,64.45) ; v1(115.42,57.99) 115.09,57.66 U1.AR45
DDR_A_D38: length 53.7
  IN4 w0.084: v3(114.77,58.98) 114.2,58.41 113.5,58.41 112.49,59.42 110.63,59.42 110.33,59.72 109.68,59.72 108.4,60.99 106.75,60.99 106.41,61.33 106.41,61.69 105.93,62.17 105.6,62.17 105.15,62.62 102.6,62.62 102.33,62.89 97.09,62.89 92.03,67.95 77.36,67.95 77.26,67.85 77.26,67.5 77.17,67.41 77.01,67.41 76.92,67.5 76.92,67.85 76.82,67.95 76.69,67.95 76.59,67.85 76.59,67.5 76.5,67.41 76.34,67.41 76.25,67.5 76.25,67.85 76.15,67.95 76.02,67.95 75.92,67.85 75.92,67.5 75.83,67.41 75.67,67.41 75.58,67.5 75.58,67.85 75.48,67.95 75.3,67.95 75.19,67.85 75.19,67.18 75.3,67.08 77.91,67.08 v1(78.01,67.17)
  BOTTOM w0.102: v3(114.77,58.98) 114.44,59.3 U1.AT48 ; v1(78.01,67.17) 78.25,67.17 78.35,67.07 78.35,66.45 78.25,66.35 JDIMM1.140
DDR_A_D39: length 54.5
  IN4 w0.084: v3(79.53,67.17) 79.28,67.17 79.19,67.26 79.19,67.52 79.27,67.59 86.05,67.59 86.13,67.51 86.13,66.91 86.22,66.83 86.39,66.83 86.47,66.91 86.47,67.57 86.57,67.66 86.71,67.66 86.8,67.57 86.8,66.91 86.89,66.83 87.06,66.83 87.14,66.91 87.14,67.57 87.24,67.66 87.38,67.66 87.48,67.57 87.48,66.91 87.56,66.83 87.73,66.83 87.81,66.91 87.81,67.57 87.91,67.66 88.05,67.66 88.15,67.57 88.15,66.91 88.23,66.83 88.4,66.83 88.48,66.91 88.48,67.57 88.58,67.66 88.72,67.66 88.82,67.57 88.82,66.91 88.9,66.83 89.07,66.83 89.15,66.91 89.15,67.57 89.25,67.66 89.39,67.66 89.49,67.57 89.49,66.91 89.57,66.83 89.74,66.83 89.82,66.91 89.82,67.57 89.92,67.66 90.06,67.66 90.16,67.57 90.16,66.91 90.24,66.83 90.41,66.83 90.49,66.91 90.49,67.57 90.59,67.66 90.73,67.66 90.83,67.57 90.83,66.91 90.91,66.83 91.08,66.83 91.16,66.91 91.16,67.56 91.26,67.66 91.42,67.66 91.52,67.56 91.52,66.93 91.62,66.83 92.74,66.83 96.97,62.6 102.36,62.6 102.53,62.43 105.06,62.43 105.5,61.99 105.85,61.99 106.22,61.62 106.22,61.25 106.86,60.61 108.51,60.61 109.06,60.06 109.06,59.76 109.53,59.29 109.71,59.29 109.93,59.5 110.21,59.5 110.48,59.23 112.17,59.23 112.29,59.11 v1(112.29,58.9)
  BOTTOM w0.102: v3(79.53,67.17) 79.53,67.48 79.38,67.63 77.81,67.63 77.53,67.35 77.53,67.17 77.3,66.95 JDIMM1.142 ; v1(112.29,58.9) 112.29,59.2 U1.AY48
DDR_A_D40: length 50.1
  IN4 w0.084: v1(111.84,60.39) 111.84,60.7 111.53,61.01 110.63,61.01 110.22,61.42 109.83,61.42 108.15,63.1 106.02,63.1 105.57,63.55 103.12,63.55 102.14,64.53 98.35,64.53 93.27,69.61 84.69,69.61 84.59,69.71 84.59,70.33 84.49,70.43 71.92,70.43 v3(71.24,69.75)
  BOTTOM w0.102: v3(71.24,69.75) 71.24,69.07 70.62,68.45 JDIMM1.147 ; U1.BA49 112.17,60.06 v1(111.84,60.39)
DDR_A_D41: length 54.3
  IN4 w0.084: v1(113.3,60.45) 113.3,60.23 112.87,59.8 110.78,59.8 110.48,60.1 109.84,60.1 109.12,60.82 109.12,61.34 107.91,62.54 105.76,62.54 105.31,62.99 102.89,62.99 102.21,63.67 97.41,63.67 92.33,68.75 71.87,68.75 71.77,68.85 71.77,69.23 71.66,69.33 71.53,69.33 71.43,69.23 71.43,68.85 71.33,68.75 71.2,68.75 71.1,68.85 71.1,69.23 70.99,69.33 70.86,69.33 70.76,69.23 70.76,68.85 70.66,68.75 70.53,68.75 70.42,68.85 70.42,69.23 70.32,69.33 70.19,69.33 70.09,69.23 70.09,68.85 69.99,68.75 69.82,68.75 69.72,68.85 v3(69.72,69.75)
  BOTTOM w0.102: v1(113.3,60.45) 113.47,60.28 U1.AV49 ; v3(69.72,69.75) 69.72,69.47 69.29,69.05 JDIMM1.149
DDR_A_D42: length 51.2
  IN4 w0.084: v3(69.72,71.29) 70.25,71.82 75.71,71.82 77.38,73.49 78.67,73.49 79,73.82 92.6,73.82 99.72,66.7 102.13,66.7 102.3,66.53 106.83,66.53 108.84,64.52 108.84,64.18 110.08,62.94 111.22,62.94 111.74,62.42 v1(111.74,62.37)
  BOTTOM w0.102: JDIMM1.157 69.56,71.45 v3(69.72,71.29) ; U1.BB51 111.77,61.29 111.77,62.35 v1(111.74,62.37)
DDR_A_D43: length 52
  IN4 w0.084: v1(113.19,62.19) 112.79,62.19 112.29,61.7 110.71,61.7 110.44,61.97 110.06,61.97 108.28,63.75 108.28,64.3 106.91,65.66 101.94,65.66 101.79,65.81 98.83,65.81 92.5,72.13 78.87,72.13 77.49,70.76 71.77,70.76 v3(71.24,71.29)
  BOTTOM w0.102: v3(71.24,71.29) 71.33,71.38 71.33,71.95 71.23,72.05 70.27,72.05 JDIMM1.159 ; v1(113.19,62.19) 112.95,61.95 U1.AY53
DDR_A_D44: length 50.9
  IN4 w0.084: v3(111.21,60.49) 109.98,60.49 109.5,60.98 109.5,61.49 108.07,62.92 105.93,62.92 105.49,63.36 103.04,63.36 102.16,64.24 97.78,64.24 92.7,69.32 84.33,69.32 84.23,69.42 84.23,70.04 84.13,70.14 83.98,70.14 83.88,70.04 83.88,69.42 83.78,69.32 83.64,69.32 83.54,69.42 83.54,70.04 83.44,70.14 83.3,70.14 83.2,70.04 83.2,69.4 83.12,69.32 82.95,69.32 82.87,69.4 82.87,70.06 82.79,70.14 82.62,70.14 82.53,70.06 82.53,69.4 82.45,69.32 82.28,69.32 82.2,69.4 82.2,70.06 82.11,70.14 81.95,70.14 81.86,70.06 81.86,69.4 81.78,69.32 81.61,69.32 81.53,69.4 81.53,70.06 81.44,70.14 81.28,70.14 81.19,70.06 81.19,69.4 81.11,69.32 80.94,69.32 80.86,69.4 80.86,70.06 80.77,70.14 79.22,70.14 79.12,70.04 79.12,69.81 79.22,69.71 v1(79.47,69.71)
  BOTTOM w0.102: v3(111.21,60.49) 111.16,60.49 111.03,60.36 111.03,59.97 111.16,59.84 111.39,59.84 U1.BB49 ; JDIMM1.146 79.68,68.15 79.81,68.28 79.81,69.37 v1(79.47,69.71)
DDR_A_D45: length 51.1
  IN4 w0.084: v1(77.95,69.71) 77.95,70.04 77.84,70.14 75.43,70.14 75.33,70.04 75.33,69.13 75.43,69.03 92.45,69.03 97.53,63.95 102.18,63.95 102.96,63.18 105.41,63.18 105.85,62.73 107.99,62.73 109.31,61.41 109.31,60.9 109.91,60.29 110.56,60.29 110.86,59.99 112.69,59.99 112.9,60.2 112.9,60.67 113.09,60.86 114.16,60.86 v3(114.57,60.45)
  BOTTOM w0.102: v3(114.57,60.45) 114.12,60 U1.AU49 ; JDIMM1.148 77.64,68.75 77.95,69.06 v1(77.95,69.71)
DDR_A_D46: length 51.6
  IN4 w0.084: v1(112.39,62.37) 111.96,61.94 110.74,61.94 110.62,62.05 110.52,62.15 110.13,62.15 108.47,63.82 108.47,64.37 106.88,65.95 102.02,65.95 101.86,66.11 99.5,66.11 92.93,72.68 87.52,72.68 87.43,72.76 87.43,73.13 87.35,73.21 87.18,73.21 87.1,73.13 87.1,72.76 87.01,72.68 86.85,72.68 86.76,72.76 86.76,73.13 86.68,73.21 86.51,73.21 86.43,73.13 86.43,72.76 86.34,72.68 86.18,72.68 86.09,72.76 86.09,73.13 86.01,73.21 85.84,73.21 85.76,73.13 85.76,72.76 85.67,72.68 85.51,72.68 85.42,72.76 85.42,73.13 85.34,73.21 85.17,73.21 85.09,73.13 85.09,72.76 85,72.68 84.83,72.68 84.75,72.76 84.75,73.13 84.67,73.21 84.5,73.21 84.42,73.13 84.42,72.76 84.33,72.68 84.16,72.68 84.08,72.76 84.08,73.13 84,73.21 83.83,73.21 83.74,73.13 83.74,72.76 83.66,72.68 83.49,72.68 83.41,72.76 83.41,73.13 83.33,73.21 83.16,73.21 83.07,73.13 83.07,72.76 82.99,72.68 82.82,72.68 82.74,72.76 82.74,73.13 82.66,73.21 82.49,73.21 82.4,73.13 82.4,72.76 82.32,72.68 82.15,72.68 82.07,72.76 82.07,73.13 81.98,73.21 81.82,73.21 81.73,73.13 81.73,72.76 81.65,72.68 81.48,72.68 81.4,72.76 81.4,73.13 81.31,73.21 81.15,73.21 81.06,73.13 81.06,72.76 80.98,72.68 80.81,72.68 80.73,72.76 80.73,73.13 80.64,73.21 80.1,73.21 v3(79.47,72.58)
  BOTTOM w0.102: v1(112.39,62.37) 112.39,62.24 U1.BA53 ; v3(79.47,72.58) 79.51,72.58 79.63,72.45 79.63,72.19 79.51,72.07 78.29,72.07 77.97,71.75 JDIMM1.158
DDR_A_D47: length 49.7
  IN4 w0.084: v3(111.05,62.54) 111.04,62.54 110.01,62.54 108.66,63.89 108.66,64.44 106.86,66.24 102.19,66.24 102.03,66.4 99.61,66.4 93.05,72.97 92.59,72.97 92.49,73.07 92.49,73.43 92.38,73.53 92.22,73.53 92.12,73.43 92.12,73.05 92.03,72.97 91.87,72.97 91.78,73.05 91.78,73.41 91.68,73.51 91.55,73.51 91.45,73.41 91.45,73.05 91.36,72.97 91.2,72.97 91.11,73.05 91.11,73.41 91.01,73.51 90.88,73.51 90.78,73.41 90.78,73.05 90.69,72.97 90.52,72.97 90.44,73.05 90.44,73.41 90.34,73.51 90.21,73.51 90.11,73.41 90.11,73.05 90.02,72.97 89.85,72.97 89.77,73.05 89.77,73.41 89.67,73.51 89.54,73.51 89.44,73.41 89.44,73.05 89.35,72.97 89.18,72.97 89.1,73.05 89.1,73.41 89,73.51 88.87,73.51 88.76,73.41 88.76,73.05 88.68,72.97 88.51,72.97 88.43,73.05 88.43,73.41 88.33,73.51 88.2,73.51 88.09,73.41 88.09,73.05 88.01,72.97 87.84,72.97 87.76,73.05 87.76,73.41 87.66,73.51 80,73.51 79.69,73.21 77.5,73.21 77.4,73.1 77.4,71.95 77.5,71.85 77.84,71.85 77.95,71.95 v1(77.95,72.58)
  BOTTOM w0.102: v1(77.95,72.58) 77.72,72.35 JDIMM1.160 ; U1.BB55 v3(111.05,62.54)
DDR_A_D48: length 51.6
  IN4 w0.084: v3(69.69,73.83) 70.15,73.37 75.6,73.37 77.78,75.55 92.37,75.55 100.15,67.78 102.38,67.78 103.08,67.08 108.18,67.08 109.09,66.18 109.41,65.85 109.41,64.39 110.3,63.51 111.94,63.51 v1(111.96,63.53)
  BOTTOM w0.102: JDIMM1.163 69.11,73.25 v3(69.69,73.83) ; U1.BA55 111.96,63.07 v1(111.96,63.53)
DDR_A_D49: length 54.7
  IN4 w0.084: v3(71.22,73.83) 71.22,74.86 71.32,74.96 71.58,74.96 71.67,74.88 71.67,74.34 71.75,74.25 71.92,74.25 72,74.34 72,74.88 72.09,74.96 76.6,74.96 77.49,75.86 92.48,75.86 100.27,68.07 102.41,68.07 103.21,67.27 108.26,67.27 108.75,66.77 109.6,65.93 109.6,64.47 110.26,63.81 111.52,63.81 111.66,63.95 113.14,63.95 v1(113.27,63.82)
  BOTTOM w0.102: v3(71.22,73.83) 71.21,73.83 70.72,74.33 69.55,74.33 69.07,73.85 JDIMM1.165 ; U1.AV56 113.67,63.42 v1(113.27,63.82)
DDR_A_D50: length 56.8
  IN4 w0.084: v3(71.22,77.27) 71.66,76.83 76.82,76.83 77.09,77.1 94.79,77.1 104.08,67.82 108.64,67.82 111.17,65.29 112.92,65.29 114.06,64.14 114.43,64.14 114.67,63.9 114.67,60.93 115.18,60.42 v1(115.18,60.4)
  BOTTOM w0.102: U1.AP50 115.47,60.11 v1(115.18,60.4) ; JDIMM1.175 69.43,76.85 69.49,76.79 70.73,76.79 v3(71.22,77.27)
DDR_A_D51: length 56.3
  IN4 w0.084: v1(115.26,62.38) 114.86,62.78 114.86,63.98 114.51,64.33 114.14,64.33 112.97,65.5 112.71,65.5 110.81,67.39 109.38,67.39 108.77,68 104.3,68 94.89,77.41 72.69,77.41 72.4,77.7 69.18,77.7 69.05,77.58 69.05,77.4 69.18,77.27 v3(69.69,77.27)
  BOTTOM w0.102: v3(69.69,77.27) 69.62,77.27 69.44,77.45 JDIMM1.177 ; U1.AP53 115.58,62.06 v1(115.26,62.38)
DDR_A_D52: length 54.9
  IN4 w0.084: v3(79.47,75.12) 79.47,74.7 79.57,74.6 80.55,74.6 80.66,74.7 80.66,75.16 80.76,75.27 87.86,75.27 87.94,75.18 87.94,74.68 88.02,74.6 88.19,74.6 88.28,74.68 88.28,75.18 88.36,75.27 88.53,75.27 88.61,75.18 88.61,74.68 88.7,74.6 88.86,74.6 88.95,74.68 88.95,75.18 89.03,75.27 89.2,75.27 89.28,75.18 89.28,74.68 89.37,74.6 89.53,74.6 89.62,74.68 89.62,75.18 89.7,75.27 89.87,75.27 89.95,75.18 89.95,74.68 90.04,74.6 90.2,74.6 90.29,74.68 90.29,75.18 90.37,75.27 90.54,75.27 90.62,75.18 90.62,74.68 90.71,74.6 90.87,74.6 90.96,74.68 90.96,75.18 91.04,75.27 91.21,75.27 91.29,75.18 91.29,74.68 91.38,74.6 91.54,74.6 91.63,74.68 91.63,75.18 91.71,75.27 91.88,75.27 91.96,75.18 91.96,74.68 92.05,74.6 92.92,74.6 100.03,67.49 102.23,67.49 102.83,66.9 108.1,66.9 109.22,65.78 109.22,64.32 110.22,63.32 111.5,63.32 111.87,62.96 112.65,62.96 112.83,62.78 114.01,62.78 114.26,62.53 v1(114.26,62.44)
  BOTTOM w0.102: v3(79.47,75.12) 79.94,74.65 79.94,73.96 79.56,73.58 77.49,73.58 77.46,73.55 JDIMM1.164 ; v1(114.26,62.44) 113.94,62.12 U1.AV54
DDR_A_D53: length 55.1
  IN4 w0.084: v1(77.95,75.12) 78.76,74.31 82.44,74.31 82.52,74.39 82.52,74.89 82.61,74.98 82.77,74.98 82.86,74.89 82.86,74.39 82.94,74.31 83.11,74.31 83.19,74.39 83.19,74.89 83.28,74.98 83.44,74.98 83.53,74.89 83.53,74.39 83.61,74.31 83.78,74.31 83.86,74.39 83.86,74.89 83.95,74.98 84.12,74.98 84.2,74.89 84.2,74.39 84.28,74.31 84.45,74.31 84.53,74.39 84.53,74.89 84.62,74.98 84.79,74.98 84.87,74.89 84.87,74.39 84.95,74.31 85.12,74.31 85.21,74.39 85.21,74.89 85.29,74.98 85.46,74.98 85.54,74.89 85.54,74.39 85.62,74.31 85.79,74.31 85.88,74.39 85.88,74.89 85.96,74.98 86.13,74.98 86.21,74.89 86.21,74.39 86.29,74.31 86.46,74.31 86.55,74.39 86.55,74.89 86.63,74.98 86.8,74.98 86.88,74.89 86.88,74.39 86.97,74.31 87.13,74.31 87.22,74.39 87.22,74.89 87.3,74.98 87.47,74.98 87.55,74.89 87.55,74.39 87.64,74.31 92.81,74.31 99.91,67.21 102.13,67.21 102.62,66.71 108.03,66.71 109.03,65.7 109.03,64.25 110.15,63.13 111.36,63.13 111.73,62.77 112.58,62.77 112.76,62.59 113.36,62.59 113.59,62.36 113.59,62.16 113.87,61.89 114.14,61.89 v1(114.23,61.8)
  BOTTOM w0.102: v1(114.23,61.8) 114.55,62.12 U1.AT54 ; JDIMM1.166 77.91,74.15 78.03,74.28 78.03,75.03 v1(77.95,75.12)
DDR_A_D54: length 54.6
  IN4 w0.084: v3(79.49,77.84) 79.49,78.45 79.59,78.55 80.78,78.55 80.88,78.45 80.88,77.78 80.96,77.69 81.13,77.69 81.21,77.78 81.21,78.45 81.3,78.53 81.46,78.53 81.55,78.45 81.55,77.78 81.63,77.69 81.8,77.69 81.88,77.78 81.88,78.45 81.97,78.53 82.14,78.53 82.22,78.45 82.22,77.78 82.3,77.69 82.47,77.69 82.55,77.78 82.55,78.45 82.64,78.53 82.81,78.53 82.89,78.45 82.89,77.78 82.97,77.69 83.14,77.69 83.22,77.78 83.22,78.45 83.31,78.53 83.48,78.53 83.56,78.45 83.56,77.78 83.64,77.69 95.01,77.69 104.52,68.19 108.92,68.19 109.44,67.66 110.81,67.66 112.78,65.69 113.05,65.69 113.56,65.17 114.57,65.17 115.26,64.49 v1(115.26,63.69)
  BOTTOM w0.102: v3(79.49,77.84) 79.76,77.56 79.76,76.68 79.63,76.55 JDIMM1.174 ; v1(115.26,63.69) 115.58,63.36 U1.AP56
DDR_A_D55: length 56.2
  IN4 w0.084: v1(77.96,77.84) 78.96,78.84 83.94,78.84 84.02,78.75 84.02,78.06 84.1,77.98 84.27,77.98 84.36,78.06 84.36,78.75 84.44,78.84 84.61,78.84 84.69,78.75 84.69,78.06 84.78,77.98 84.94,77.98 85.03,78.06 85.03,78.75 85.11,78.84 85.28,78.84 85.36,78.75 85.36,78.06 85.45,77.98 85.61,77.98 85.7,78.06 85.7,78.75 85.78,78.84 85.95,78.84 86.03,78.75 86.03,78.06 86.12,77.98 86.28,77.98 86.37,78.06 86.37,78.75 86.45,78.84 94.28,78.84 104.74,68.37 109.19,68.37 109.64,67.92 110.82,67.92 112.86,65.88 113.12,65.88 113.64,65.35 114.65,65.35 115.45,64.56 115.45,64.07 115.66,63.86 115.66,61.66 115.53,61.53 115.32,61.53 115.19,61.66 v3(115.19,61.73)
  BOTTOM w0.102: JDIMM1.176 77.71,77.15 77.96,77.41 v1(77.96,77.84) ; v3(115.19,61.73) 115.36,61.73 U1.AP52
DDR_A_D56: length 65.7
  IN4 w0.084: v3(71.22,79.83) 71.66,79.38 72.74,79.38 72.84,79.28 72.84,78.6 72.93,78.52 73.08,78.52 73.18,78.62 73.18,79.2 73.28,79.3 73.41,79.3 73.51,79.2 73.51,78.62 73.61,78.52 73.75,78.52 73.85,78.62 73.85,79.2 73.95,79.3 74.08,79.3 74.18,79.2 74.18,78.62 74.29,78.52 74.42,78.52 74.52,78.62 74.52,79.2 74.62,79.3 74.75,79.3 74.85,79.2 74.85,78.62 74.96,78.52 75.09,78.52 75.19,78.62 75.19,79.2 75.29,79.3 75.42,79.3 75.52,79.2 75.52,78.62 75.63,78.52 75.76,78.52 75.86,78.62 75.86,79.2 75.96,79.3 76.09,79.3 76.2,79.2 76.2,78.62 76.3,78.52 76.45,78.52 76.53,78.6 76.53,79.55 76.63,79.65 95.84,79.65 106.36,69.13 112.02,69.13 112.97,68.19 113.34,68.19 113.71,67.81 113.71,66.82 115.83,64.7 115.83,64.23 116.65,63.41 v1(116.65,63.37)
  BOTTOM w0.102: JDIMM1.181 70.04,78.65 v3(71.22,79.83) ; U1.AN57 116.33,63.69 v1(116.65,63.37)
DDR_A_D57: length 67.7
  IN4 w0.084: v1(116.71,61.42) 115.85,62.28 115.85,63.94 115.64,64.15 115.64,64.63 113.53,66.74 113.53,67.73 113.26,68 112.89,68 111.95,68.95 104.86,68.95 94.46,79.34 78.75,79.34 77.6,78.19 72.52,78.19 72.42,78.3 72.42,79.01 72.33,79.09 72.17,79.09 72.08,79.01 72.08,78.29 71.98,78.19 71.85,78.19 71.75,78.29 71.75,79.01 71.66,79.09 71.5,79.09 71.41,79.01 71.41,78.29 71.31,78.19 71.17,78.19 71.08,78.29 71.08,79.01 70.99,79.09 70.82,79.09 70.74,79.01 70.74,78.29 70.64,78.19 70.5,78.19 70.41,78.29 70.41,79.01 70.32,79.09 70.15,79.09 70.07,79.01 70.07,78.3 69.97,78.19 69.79,78.19 69.69,78.3 v3(69.69,79.83)
  BOTTOM w0.102: v3(69.69,79.83) 69.83,79.83 69.93,79.73 69.93,79.35 69.83,79.25 JDIMM1.183 ; U1.AN53 116.39,61.74 v1(116.71,61.42)
DDR_A_D58: length 65.4
  IN4 w0.084: v3(71.22,82.93) 71.52,83.24 71.52,83.83 71.65,83.95 94.8,83.95 106.63,72.13 110.15,72.13 111.05,73.03 115.31,73.03 118.32,70.02 118.32,66.02 119.23,65.11 119.23,64.1 v1(119.47,63.87)
  BOTTOM w0.102: v3(71.22,82.93) 71.22,82.55 70.32,81.65 JDIMM1.191 ; U1.AG56 119.07,63.48 v1(119.47,63.87)
DDR_A_D59: length 68.3
  IN4 w0.084: v3(69.69,82.93) 71.01,84.25 94.91,84.25 106.75,72.41 110.03,72.41 110.93,73.31 115.43,73.31 118.65,70.1 118.65,66.02 119.44,65.23 119.44,64.62 119.86,64.2 119.86,63.52 119.61,63.27 119.61,62.31 120.13,61.8 v1(120.14,61.8)
  BOTTOM w0.102: U1.AG53 119.07,62.1 119.38,61.8 v1(120.14,61.8) ; JDIMM1.193 69.17,82.25 69.69,82.77 v3(69.69,82.93)
DDR_A_D60: length 67.3
  IN4 w0.084: v3(116.67,62.72) 116.92,62.72 117.05,62.85 117.05,63.8 116.92,63.92 116.4,63.92 116.08,64.25 116.08,64.72 113.9,66.89 113.9,67.89 113.41,68.37 113.05,68.37 112.1,69.32 108.82,69.32 108.03,70.11 105.79,70.11 95.94,79.95 90.79,79.95 90.71,80.04 90.71,80.47 90.63,80.55 90.46,80.55 90.38,80.47 90.38,80.04 90.29,79.95 90.12,79.95 90.04,80.04 90.04,80.47 89.96,80.55 89.79,80.55 89.71,80.47 89.71,80.04 89.62,79.95 89.45,79.95 89.37,80.04 89.37,80.47 89.29,80.55 89.12,80.55 89.03,80.47 89.03,80.04 88.95,79.95 88.78,79.95 88.7,80.04 88.7,80.47 88.62,80.55 88.45,80.55 88.36,80.47 88.36,80.04 88.28,79.95 88.11,79.95 88.03,80.04 88.03,80.47 87.94,80.55 87.78,80.55 87.69,80.47 87.69,80.04 87.61,79.95 87.44,79.95 87.36,80.04 87.36,80.47 87.27,80.55 87.11,80.55 87.02,80.47 87.02,80.04 86.94,79.95 86.77,79.95 86.69,80.04 86.69,80.47 86.6,80.55 86.44,80.55 86.35,80.47 86.35,80.04 86.27,79.95 86.1,79.95 86.02,80.04 86.02,80.47 85.93,80.55 85.77,80.55 85.68,80.47 85.68,80.04 85.6,79.95 85.43,79.95 85.35,80.04 85.35,80.47 85.26,80.55 85.1,80.55 85.01,80.47 85.01,80.04 84.93,79.95 84.76,79.95 84.68,80.04 84.68,80.47 84.59,80.55 84.42,80.55 84.34,80.47 84.34,80.04 84.26,79.95 84.09,79.95 84.01,80.04 84.01,80.47 83.92,80.55 83.75,80.55 83.67,80.47 83.67,80.04 83.59,79.95 83.42,79.95 83.33,80.04 83.33,80.47 83.25,80.55 83.08,80.55 83,80.47 83,80.04 82.92,79.95 82.75,79.95 82.66,80.04 82.66,80.47 82.58,80.55 82.41,80.55 82.33,80.47 82.33,80.04 82.25,79.95 82.08,79.95 81.99,80.04 81.99,80.47 81.91,80.55 81.74,80.55 81.66,80.47 81.66,80.04 81.57,79.95 81.41,79.95 81.32,80.04 81.32,80.47 81.24,80.55 81.07,80.55 80.99,80.47 80.99,80.04 80.9,79.95 79.76,79.95 79.64,80.08 v1(79.64,80.38)
  BOTTOM w0.102: v3(116.67,62.72) 116.35,63.04 U1.AN55 ; JDIMM1.180 78.09,78.35 78.48,78.73 79.51,78.73 79.64,78.86 v1(79.64,80.38)
DDR_A_D61: length 69.1
  IN4 w0.084: v1(78.11,80.38) 78.36,80.38 78.46,80.28 78.46,80.04 78.36,79.94 75.83,79.94 75.7,80.06 75.7,80.71 75.83,80.84 91.11,80.84 91.19,80.76 91.19,80.32 91.28,80.24 91.44,80.24 91.53,80.32 91.53,80.76 91.61,80.84 91.78,80.84 91.86,80.76 91.86,80.32 91.95,80.24 92.11,80.24 92.2,80.32 92.2,80.76 92.28,80.84 92.45,80.84 92.53,80.76 92.53,80.32 92.62,80.24 92.78,80.24 92.87,80.32 92.87,80.76 92.95,80.84 93.12,80.84 93.2,80.76 93.2,80.32 93.29,80.24 93.45,80.24 93.54,80.32 93.54,80.76 93.62,80.84 93.79,80.84 93.87,80.76 93.87,80.32 93.96,80.24 94.13,80.24 94.21,80.32 94.21,80.76 94.29,80.84 94.46,80.84 94.54,80.76 94.54,80.32 94.63,80.24 94.8,80.24 94.88,80.32 94.88,80.74 94.98,80.84 95.15,80.84 95.26,80.74 95.26,80.34 95.36,80.24 96.06,80.24 105.91,70.39 111.49,70.39 111.64,70.54 111.64,71.16 111.77,71.29 113.86,71.29 115.5,69.66 115.5,66.35 117.24,64.62 117.24,62.72 117.12,62.6 117.12,61.17 v1(116.71,60.76)
  BOTTOM w0.102: v1(116.71,60.76) 116.38,61.09 U1.AN52 ; v1(78.11,80.38) 78.11,80.31 78.11,79.7 77.36,78.95 JDIMM1.182
