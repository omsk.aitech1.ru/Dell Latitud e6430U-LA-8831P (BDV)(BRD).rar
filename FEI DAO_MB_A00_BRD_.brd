# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Nets (continued)
MSATA_PTX_DRX_P0_C: C618.1 UH4.AP5
MSCLK: JDEG2.6 JMINI2.19 R847.2 U51.B43
MSDATA: JDEG2.7 JMINI2.14 R706.2 R850.2 R869.1 U51.A40
NB_LAN_TX0+: JLOM1.1 TR1.13
NB_LAN_TX0-: JLOM1.2 TR1.14
NB_LAN_TX1+: JLOM1.3 TR1.17
NB_LAN_TX1-: JLOM1.6 TR1.18
NB_LAN_TX2+: JLOM1.4 TR1.19
NB_LAN_TX2-: JLOM1.5 TR1.20
NB_LAN_TX3+: JLOM1.7 TR1.23
NB_LAN_TX3-: JLOM1.8 TR1.24
NB_PSID: PD7.2 PJPDC1.1 PL4.2
NC: JCRT1.11 T144.1(TP-1)
NC_P: C554.1 U37.14 U39.14
NTC: PH702.1 PR727.1 PU700.10
NTCG: PH701.1 PR715.1 PU700.4
P1_SW: PL702.3 PR755.2
P1_VO: PL702.2 PR757.1
PANEL_BKEN_EC: D69.2 U46.A35
PANEL_BKEN_PCH: D67.2 UH4.J47
PANEL_HDD_LED: JLVDS1.5 Q81.3
PBAT_PRES#: PR6.2 PR8.2 U46.B40
PBAT_SMBCLK: PR7.2 R820.2 U51.A56
PBAT_SMBDAT: PR9.2 R818.2 U51.B59
PBATT+_C: PBATT1.1 PC4.1 PC5.1 PL2.1
PCH_ALW_ON: PR25.1 R737.1 R880.2 U51.A23
PCH_AZ_BITCLK: RH25.2 UH4.N34
PCH_AZ_CODEC_BITCLK: CH101.1 R1076.1 RH25.1 U72.6
PCH_AZ_CODEC_RST#: RH27.1 U72.11
PCH_AZ_CODEC_SDIN0: R1096.1 UH4.E34
PCH_AZ_CODEC_SDOUT: R1077.1 RH29.1 U72.5
PCH_AZ_CODEC_SYNC: RH26.1 U72.10
PCH_AZ_RST#: RH27.2 UH4.K34
PCH_AZ_SDIN0_R: R1096.2 U72.8
PCH_AZ_SDOUT: RH29.2 RH50.2 RH287.2 UH4.A36
PCH_AZ_SYNC: QH7.1 RH66.2 UH4.L34
PCH_AZ_SYNC_Q: QH7.3 RH26.2 RH31.2
PCH_BATLOW#: RH139.2 UH4.E10
PCH_CL_CLK1: JMINI2.45 UH4.M7
PCH_CL_DATA1: JMINI2.47 UH4.T11
PCH_CL_RST1#: R707.1 UH4.P10
PCH_CRT_DDC_CLK: QH6.1 RH317.2 UH4.T39
PCH_CRT_DDC_DAT: QH6.4 RH316.2 UH4.M40
PCH_DPWROK: R802.1 RH113.1 UH4.E22
PCH_GPIO3: RH332.2 UH4.G40
PCH_GPIO6: RH165.2 UH4.H36
PCH_GPIO7: RH178.2 UH4.E38
PCH_GPIO15: RH354.2 UH4.G2
PCH_GPIO22: RH181.1 UH4.T5
PCH_GPIO33: RH355.2 UH4.C36
PCH_GPIO36: RH171.1 RH174.1 UH4.V8
PCH_GPIO37: RH172.1 RH173.1 UH4.M5
PCH_GPIO45: RH101.2 UH4.T13
PCH_GPIO46: RH103.2 UH4.K12
PCH_GPIO48: RH166.2 UH4.V13
PCH_GPIO69: RH260.1 UH4.B41
PCH_GPIO74: RH301.2 UH4.C13
PCH_INTVRMEN: RH38.2 UH4.C17
PCH_JTAG_TCK: JXDP2.26 RH59.1 UH4.J3
PCH_JTAG_TDI: JXDP2.22 RH45.1 RH49.1 UH4.K5
PCH_JTAG_TDO: JXDP2.20 RH43.1 RH47.1 UH4.H1
PCH_JTAG_TMS: JXDP2.23 RH44.1 RH48.1 UH4.H7
PCH_PCIE_WAKE#: RH142.2 U51.A18 UH4.B9
PCH_PLTRST#: RC8.1 RH336.2 RH338.2 UC1.2 UH3.1 UH3.2 UH4.C6
PCH_PLTRST#_BUF: RC4.2 RC10.1 UC1.4
PCH_PLTRST#_EC: JMINI3.17 JSC1.5 R703.1 R704.2 R1717.2 U37.16 U39.16 U46.B22 U51.B30 UH3.4
PCH_PLTRST#_R: RC10.2 U1.D44
PCH_PWRBTN#_XDP: JXDP2.11 RH21.2
PCH_PWRGD#: Q50.1 R391.1 R893.2
PCH_RI#: RH140.2 UH4.A10
PCH_RSMRST#: R892.2 R1623.1 U7.1 U51.B47
PCH_RSMRST#_Q: R1623.2 R1624.2 RH24.1 RH113.2 RH145.2 UH4.C21
PCH_RTCRST#: CH4.2 CMOS1.2 RH22.2 UH4.D20
PCH_RTCX1: CH2.1 RH2.1 UH4.A20 YH1.1
PCH_RTCX2: RH2.2 RH286.2 UH4.C20
PCH_RTCX2_R: CH3.1 RH286.1 YH1.2
PCH_SDVO_CTRLCLK: Q120.1 RH351.2 UH4.P38
PCH_SDVO_CTRLCLK_R: JHDMI1.15 Q120.6 R1153.1
PCH_SDVO_CTRLDATA: Q120.4 RH352.2 UH4.M39
PCH_SDVO_CTRLDATA_R: JHDMI1.16 Q120.3 R1152.1
PCH_SMB_ALERT#: RH304.2 UH4.E12
PCH_SPI_CLK: R897.2 R899.2 R906.2 UH4.T3
PCH_SPI_CS0#: R935.1 UH4.Y14
PCH_SPI_CS0_R#: JTAA1.11 R935.2 U52.1
PCH_SPI_CS1#: R936.1 UH4.T1
PCH_SPI_CS1_R#: JTAA1.5 R936.2 U53.1
PCH_SPI_DIN: R894.1 R895.1 R896.1 UH4.U3
PCH_SPI_DO: R900.2 R901.2 R912.2 UH4.V4
PCH_THRMTRIP#_R: CH97.1 RH262.2 UH4.AY10
PCI_5048: RH160.1 UH4.H49
PCI_GNT3#: RH333.1 UH4.F46
PCI_LOOPBACKOUT: RH105.1 UH4.H40
PCI_MEC: RH102.1 UH4.H43
PCI_PIRQA#: RH324.2 UH4.K40
PCI_PIRQB#: RH325.2 UH4.K38
PCI_PIRQC#: RH326.2 UH4.H38
PCI_PIRQD#: RH329.2 UH4.G38
PCI_REQ1#: RH327.2 UH4.C46
PCI_TPM_TCM: RH311.2 UH4.K43
PCIE_MCARD1_DET#: JMINI2.37 R692.1 R698.2 R699.1 UH4.E8
PCIE_MCARD2_DET#: R697.2 R725.1 UH4.C44
PCIE_MCARD2_DET#_R: JMINI1.37 R695.2 R725.2
PCIE_PRX_GLANTX_N7: C459.2 UH4.BG40
PCIE_PRX_GLANTX_N7_C: C459.1 U31.39
PCIE_PRX_GLANTX_P7: C458.2 UH4.BJ40
PCIE_PRX_GLANTX_P7_C: C458.1 U31.38
PCIE_PRX_MMITX_N6: C571.1 UH4.BJ38
PCIE_PRX_MMITX_N6_C: C571.2 U38.7
PCIE_PRX_MMITX_P6: C569.1 UH4.BG38
PCIE_PRX_MMITX_P6_C: C569.2 U38.6
PCIE_PRX_WANTX_N1: JMINI1.23 UH4.BG34
PCIE_PRX_WANTX_P1: JMINI1.25 UH4.BJ34
PCIE_PRX_WLANTX_N2: JMINI2.23 UH4.BE34
PCIE_PRX_WLANTX_P2: JMINI2.25 UH4.BF34
PCIE_PTX_GLANRX_N7: C461.1 UH4.AY40
PCIE_PTX_GLANRX_N7_C: C461.2 U31.42
PCIE_PTX_GLANRX_P7: C460.1 UH4.BB40
PCIE_PTX_GLANRX_P7_C: C460.2 U31.41
PCIE_PTX_MMIRX_N6: C568.1 UH4.AU36
PCIE_PTX_MMIRX_N6_C: C568.2 U38.4
PCIE_PTX_MMIRX_P6: C567.1 UH4.AV36
PCIE_PTX_MMIRX_P6_C: C567.2 U38.5
PCIE_PTX_WANRX_N1: C597.1 UH4.AV32
PCIE_PTX_WANRX_N1_C: C597.2 JMINI1.31
PCIE_PTX_WANRX_P1: C599.1 UH4.AU32
PCIE_PTX_WANRX_P1_C: C599.2 JMINI1.33
PCIE_PTX_WLANRX_N2: C596.1 UH4.BB32
PCIE_PTX_WLANRX_N2_C: C596.2 JMINI2.31
PCIE_PTX_WLANRX_P2: C598.1 UH4.AY32
PCIE_PTX_WLANRX_P2_C: C598.2 JMINI2.33
PCIE_WAKE#: JMINI1.1 JMINI2.1 R759.2 U51.B19
PCLK_80H: JMINI3.19 RH314.1
PECI_EC: R863.2 U1.A48
PECI_EC_R: R863.1 U51.A48
PEG_A_CLKRQ#: RH80.2 UH4.M10
PEG_B_CLKRQ#: RH98.2 UH4.E6
PEG_COMP: RC1.2 U1.G1 U1.G3 U1.G4
PGOOD: PR726.1 PU700.19
PGOODG: PR708.1 PU700.36
PHASE1: PC742.2 PC745.1 PL702.4 PQ704.1 PQ704.2 PQ704.3 PQ706.5 PU700.22
PHASE1G: PC750.2 PC751.1 PL704.4 PQ708.1 PQ708.2 PQ708.3 PQ710.5 PQ711.5 PU700.33
PLTRST_LAN#: RH338.1 U31.36
PLTRST_MMI#: RH336.1 U38.13
PM_APWROK: RH118.1 U51.A9 UH5.2
PM_APWROK_R: RH118.2 UH4.L10 UH5.4
PM_DRAM_PWRGD: RC18.2 UC2.2 UH4.B13
PM_DRAM_PWRGD_CPU: RC28.2 U1.BE45
PM_LANPHY_ENABLE: R555.1 UH4.C4
POWER_SW#_MB: C721.1 C759.1 D23.3 JLED1.8 PWRSW1.1 R811.2 SW1.2 SW1.4
POWER_SW_IN#: C722.1 R810.2 R811.1 U9.20 U51.B67
PP: R656.1 U37.7 U39.7
PROCHOT#_EC: Q47.2 R812.2 R1179.2 R1180.1 U51.A46
PROCHOT_GATE: PU1302.2 R761.2 U46.A50
PS_ID: PR12.1 PR13.2 U51.A55
PSID_DISABLE#: PR17.2 U46.A37
PWM3: PR714.1 PU700.24
PWR_SRC_ON: C297.2 Q21.3 R422.2 R423.1
PWRSHARE_EN: Q48.2 R784.2 U2.1
PWRSHARE_EN#: Q48.1 R816.1 U75.5
R: C1205.1 JCRT1.1 L99.2
RBIAS_CPY: RH112.2 UH4.BH21
RBIAS_SATA3: RH46.1 UH4.AH1
RED_CRT: C1202.1 D83.2 L99.1 R1641.1 RH133.2 UH4.T49
REGCTL_PNP10: L29.1 U31.7
REM_DIODE1_N_4022: C266.1 C270.2 Q12.3 U9.23
REM_DIODE1_P_4022: C266.2 C270.1 Q12.1 Q12.2 U9.24
REM_DIODE2_N_4022: C271.2 C272.2 C277.2 Q13.1 Q13.2 Q14.3 U9.26
REM_DIODE2_P_4022: C271.1 C272.1 C277.1 Q13.3 Q14.1 Q14.2 U9.27
RES_BIAS: R562.1 U31.12
RESET_OUT#: Q50.2 R843.2 RH321.1 U51.B39 UH4.L22
REXT: R752.2 R1595.2 U44.20
RF_+V1.05S_VCCPP: PR505.1 PU500.5
RF_+V1.05SP: PR405.1 PU400.5
RSMRST#: R1622.1 U4.3 U7.2
RSMRST#_XDP: JXDP2.17 RH24.2 RH284.1
RUN_ON: PR303.1 PR409.1 R744.1 R786.2 U46.A11
RUN_ON_CPU1.5VS3: CC136.1 QC3.4 QC4.3 QC5.2 RC72.2 RC143.1
RUN_ON_CPU1.5VS3#: Q71.2 Q72.2 QC1.2 QC4.5 QC4.6 RC74.2
RUN_ON_ENABLE#: Q45.2 Q52.5 Q52.6 Q56.2 Q62.2 Q64.2 Q67.2 Q68.2 Q69.2 Q70.2 R909.2
RUNPWROK: Q45.1 R799.2 U46.A4 U51.B26 UC2.1
RUNPWROK_AND: RC12.2 RC28.1 RC64.2 UC2.4
S5_1.5V: PC255.1 PR206.2 PR232.2 PU200.8
SATA3_COMP: RH42.1 UH4.AB12 UH4.AB13
SATA_ACT#: Q74.4 UH4.P3
SATA_COMP: RH40.1 UH4.Y10 UH4.Y11
SATA_LED: JLED1.3 R1731.2
SATA_PRX_DTX_N4: C1238.2 JESA1.9
SATA_PRX_DTX_N4_B: R1722.1 R1723.2
SATA_PRX_DTX_P4: C1239.2 JESA1.10
SATA_PRX_DTX_P4_B: R1724.1 R1725.2
SATA_PTX_DRX_N4: C1237.2 JESA1.7
SATA_PTX_DRX_N4_B: R1720.1 R1721.2
SATA_PTX_DRX_P4: C1236.2 JESA1.6
SATA_PTX_DRX_P4_B: R1718.1 R1719.2
SB#: Q53.2 R1626.1 U2.8
SCLK: PR716.2 PR730.1 PU700.5
SD/MMCCD#: JSD1.2 U38.12
SD/MMCCLK: JSD1.8 R676.2 RE678.1
SD/MMCCLK_R: R676.1 U38.18
SD/MMCCMD: JSD1.12 R674.2
SD/MMCCMD_R: R674.1 U38.19
SD/MMCDAT0: JSD1.4 R665.2
SD/MMCDAT0_R: R665.1 U38.29
SD/MMCDAT1: JSD1.3 R663.2
SD/MMCDAT1_R: R663.1 U38.28
SD/MMCDAT2: JSD1.15 R664.2
SD/MMCDAT2_R: R664.1 U38.26
SD/MMCDAT3: JSD1.14 R668.2
SD/MMCDAT3_R: R668.1 U38.24
SD/MMCDAT4: JSD1.13 R669.2
SD/MMCDAT4_R: R669.1 U38.23
SD/MMCDAT5: JSD1.11 R670.2
SD/MMCDAT5_R: R670.1 U38.22
SD/MMCDAT6: JSD1.7 R672.2
SD/MMCDAT6_R: R672.1 U38.21
SD/MMCDAT7: JSD1.5 R673.2
SD/MMCDAT7_R: R673.1 U38.20
SDA: PR719.2 PR737.1 PU700.7
SDWP: JSD1.1 U38.30
SEL: Q53.1 R1613.2 R1614.1 U2.4
SIO_14M: RH313.2 UH4.F47
SIO_A20GATE: RH158.2 U51.A45 UH4.P4
SIO_EXT_SCI#: RH263.1 U51.A33 UH4.T7
SIO_EXT_SMI#: RH348.1 U51.A6 UH4.C14
SIO_EXT_WAKE#: R797.1 RH177.1 UH4.C10
SIO_PWRBTN#: RC6.1 RH21.1 RH41.2 U51.B58 UH4.E20
SIO_RCIN#: RH203.2 U51.A27 UH4.P5
SIO_SLP_A#: PR403.1 Q57.2 T61.1(TP-1) U46.B63 UH4.G10 UH5.1
SIO_SLP_LAN#: Q35.2 U46.A5 UH4.K14
SIO_SLP_S3#: PR306.1 PR307.1 PR408.1 R735.1 RC82.1 T60.1(TP-1) U46.B65 UH4.F4
SIO_SLP_S4#: PR232.1 T59.1(TP-1) U46.A61 UH4.H4
SIO_SLP_S5#: T58.1(TP-1) U51.B16 UH4.D10
SIO_SLP_SUS#: R750.1 T62.1(TP-1) U46.B6 UH4.G16
SLICE_BAT_ON: R791.2 U46.A31
SLICE_BAT_PRES#: R760.2 U46.B33
SLP_ME_CSW_DEV#: RH53.1 U46.B58 UH4.P8
SM_RCOMP0: RC42.1 U1.BF44
SM_RCOMP1: RC43.1 U1.BE43
SM_RCOMP2: RC45.1 U1.BG43
SML1_SMBCLK: RH298.1 U51.B6 UH4.E14
SML1_SMBDATA: RH299.1 U51.A5 UH4.M16
SNUB_1.5V: PC275.2 PR203.1
SNUB_1.8VSP: PC305.1 PR301.2
SNUB_3V: PC112.1 PR109.2
SNUB_5V: PC113.1 PR110.2
SP_TPM_LPC_EN: D91.1 R772.2 R1662.1 U46.B56
SP_TPM_LPC_EN_R: D91.2 R1662.2 R1663.2 U37.28 U39.28
SPI_CLK32: R897.1 U53.6
SPI_CLK64: R899.1 U52.6
SPI_CLK_TAA: JTAA1.8 R906.1
SPI_DIN32: R895.2 U53.2
SPI_DIN64: R894.2 U52.2
SPI_DIN_TAA: JTAA1.9 R896.2
SPI_DO32: R900.1 U53.5
SPI_DO64: R901.1 U52.5
SPI_DO_TAA: JTAA1.4 R912.1
SPI_HOLD#: R891.2 U52.7 U53.7
SPI_WP#_SEL: R898.1 U46.A12
SPI_WP#_SEL_R: R890.2 R898.2 U52.3 U53.3
SPKR: R1119.2 RH35.2 UH4.T10
SRTCRST#: CH5.2 ME1.2 RH23.2 UH4.G22
SUS_ON: R878.2 U46.B60
SUS_STAT#/LPCPD#: T56.1(TP-1) UH4.G8
SUSACK#: RH114.1 U46.A58
SUSACK#_R: RH114.2 RH323.2 UH4.C12
SUSCLK: T57.1(TP-1) UH4.N14
SW_1.5V: PC275.1 PC278.1 PL200.2 PQ200.1 PQ200.2 PQ200.3 PQ210.5 PU200.16
SW_+V1.05S_VCCPP: PC504.2 PL500.1 PQ500.1 PQ500.2 PQ500.3 PQ501.5 PR504.1 PU500.8
SW_+V1.05SP: PC404.2 PL400.1 PQ400.1 PQ400.2 PQ400.3 PQ405.5 PR404.1 PU400.8
SYS_LED_MASK#: Q80.2 R775.2 U46.B48 U58.1
SYS_PWROK: RC9.1 RH321.2 U46.B57 UH4.P12
SYS_PWROK_XDP: JXDP1.13 RC9.2 RC124.2
SYSTEM_ID: C742.1 R871.1 U51.A10
TCM_BA0: R658.2 R660.1 U37.9 U39.9
TCM_BA1: R657.2 R659.1 U37.3 U39.3
TEMP_ALERT#: R738.2 RH266.1 UH4.V3
TEMP_ALERT#_R: R738.1 U46.B11
TEST1: U37.12 U39.12
TEST2: U37.6 U39.6
THERM_STP#: PR116.1 R390.1 U9.19
THERMATRIP2#: C278.1 Q16.1 R395.2 U9.17
TMDSB_CON_CLK: C1217.1 JHDMI1.10 L19.2 L117.2
TMDSB_CON_CLK#: C1216.1 JHDMI1.12 L19.3 L116.2
TMDSB_CON_N0: C1219.1 JHDMI1.9 L20.3 L118.2
TMDSB_CON_N1: C1221.1 JHDMI1.6 L21.3 L120.2
TMDSB_CON_N2: C1223.1 JHDMI1.3 L22.3 L122.2
TMDSB_CON_P0: C1218.1 JHDMI1.7 L20.2 L119.2
TMDSB_CON_P1: C1220.1 JHDMI1.4 L21.2 L121.2
TMDSB_CON_P2: C1222.1 JHDMI1.1 L22.2 L123.2
TMDSB_PCH_CLK: C352.2 UH4.AV49
TMDSB_PCH_CLK#: C353.2 UH4.AV47
TMDSB_PCH_CLK#_C: C353.1 L19.4 L116.1 R455.1
TMDSB_PCH_CLK_C: C352.1 L19.1 L117.1 R456.1
TMDSB_PCH_N0: C351.2 UH4.AU48
TMDSB_PCH_N0_C: C351.1 L20.4 L118.1 R453.1
TMDSB_PCH_N1: C347.2 UH4.AV45
TMDSB_PCH_N1_C: C347.1 L21.4 L120.1 R449.1
TMDSB_PCH_N2: C349.2 UH4.AV42
TMDSB_PCH_N2_C: C349.1 L22.4 L122.1 R450.1
TMDSB_PCH_P0: C350.2 UH4.AU47
TMDSB_PCH_P0_C: C350.1 L20.1 L119.1 R454.1
TMDSB_PCH_P1: C346.2 UH4.AV46
TMDSB_PCH_P1_C: C346.1 L21.1 L121.1 R448.1
TMDSB_PCH_P2: C348.2 UH4.AV40
TMDSB_PCH_P2_C: C348.1 L22.1 L123.1 R452.1
TP_CLK: C749.1 D37.2 JTP1.3 L55.1
TP_DATA: C750.1 D37.3 JTP1.4 L54.1
TP_DC_TEST_A4: T121.1(TP-1) U1.A4
TP_DC_TEST_A58: T119.1(TP-1) U1.A58
TP_DC_TEST_BD1: T124.1(TP-1) U1.BD1
TP_DC_TEST_BD61: T122.1(TP-1) U1.BD61
TP_DC_TEST_BG4: T123.1(TP-1) U1.BG4
TP_DC_TEST_BG58: T132.1(TP-1) U1.BG58
TP_DC_TEST_D1: T118.1(TP-1) U1.D1
TP_DC_TEST_D61: T120.1(TP-1) U1.D61
TP_LAN_JTAG_TCK: R546.2 U31.35
TP_LAN_JTAG_TDI: T142.1(TP-1) U31.32
TP_LAN_JTAG_TDO: T143.1(TP-1) U31.34
TP_LAN_JTAG_TMS: R545.2 U31.33
TP_VCC_DIESENSE: T128.1(TP-1) U1.F48
TPM_ID0: RH267.1 RH270.2 UH4.N2
TPM_ID1: RH268.2 RH271.1 UH4.M3
TRIP_+V1.05S_VCCPP: PR501.2 PU500.2
TRIP_+V1.05SP: PR402.2 PU400.2
UG_3V: PQ100.4 PU100.10
UG_5V: PQ101.4 PU100.21
UG_+V1.05S_VCCPP: PQ500.4 PU500.9
UG_+V1.05SP: PQ400.4 PU400.9
UGATE1: PQ704.4 PU700.21
UGATE1G: PQ708.4 PU700.32
UIM_CLK: C628.1 JMINI1.12 JSIM1.3 U40.3
UIM_DATA: C631.1 JMINI1.10 JSIM1.7 U40.4
UIM_RESET: C629.1 JMINI1.14 JSIM1.2 U40.1
UIM_VPP: C630.1 JMINI1.16 JSIM1.6 U40.6
USB3RN1: L95.1 R1605.1 UH4.BE28
USB3RN1_D-: D78.1 D78.10 JUSB1.5 L95.2 R1605.2
USB3RN2: L114.1 R1704.1 UH4.BC30
USB3RN2_D-: D89.5 D89.6 JUSB3.5 L114.2 R1704.2
USB3RN3: L112.1 R1682.1 UH4.BE32
USB3RN3_D-: D88.5 D88.6 JESA1.12 L112.2 R1682.2
USB3RP1: L95.4 R1604.1 UH4.BC28
USB3RP1_D+: D78.2 D78.9 JUSB1.6 L95.3 R1604.2
USB3RP2: L114.4 R1702.1 UH4.BE30
USB3RP2_D+: D89.4 D89.7 JUSB3.6 L114.3 R1702.2
USB3RP3: L112.4 R1683.1 UH4.BF32
USB3RP3_D+: D88.4 D88.7 JESA1.13 L112.3 R1683.2
USB3T_N2: C1243.1 L115.1 R1703.1
USB3T_N3: C1234.1 L110.1 R1678.1
USB3T_P2: C1242.1 L115.4 R1706.1
USB3T_P3: C1235.1 L110.4 R1681.1
USB3TN1: C412.2 UH4.AV26
USB3TN1_C: C412.1 L96.1 R1606.1
USB3TN1_D-: D78.4 D78.7 JUSB1.8 L96.2 R1606.2
USB3TN2: C1243.2 UH4.BB26
USB3TN2_D-: D89.2 D89.9 JUSB3.8 L115.2 R1703.2
USB3TN3: C1234.2 UH4.AU28
USB3TN3_D-: D88.2 D88.9 JESA1.15 L110.2 R1678.2
USB3TP1: C413.2 UH4.AU26
USB3TP1_C: C413.1 L96.4 R1603.1
USB3TP1_D+: D78.5 D78.6 JUSB1.9 L96.3 R1603.2
USB3TP2: C1242.2 UH4.AY26
USB3TP2_D+: D89.1 D89.10 JUSB3.9 L115.3 R1706.2
USB3TP3: C1235.2 UH4.AV28
USB3TP3_D+: D88.1 D88.10 JESA1.16 L110.3 R1681.2
USB30_SMI#: RH357.1 UH4.N32
USB_MCARD1_DET#: JMINI2.40 R698.1 R701.1 UH4.K4
USB_MCARD2_DET#: JMINI1.40 R694.2 R697.1 UH4.A40
USB_MCARD3_DET#: C627.1 JMINI3.40 R708.1 R712.2
USB_OC0#: RH350.1 U48.5 U75.6 UH4.A14
USB_OC1#: RH341.1 U75.10 UH4.K20
USB_OC2#: RH349.1 UH4.B17
USB_OC3#: RH343.1 UH4.C16
USB_OC4#: RH345.1 UH4.L16
USB_OC5#: RH346.1 UH4.A16
USB_OC6#: RH347.1 UH4.D14
USB_PWR_SHR_EN#: R776.2 R1626.2 U46.B2
USB_PWR_SHR_VBUS_EN: R778.2 R784.1 U46.B50
USB_SIDE_EN#: R768.2 U46.A33 U48.4
USBP0+: U2.6 UH4.A24
USBP0-: U2.7 UH4.C24
USBP0_D+: L51.4 R736.1 U2.3
USBP0_D-: L51.1 R740.1 U2.2
USBP0_R_D+: D72.2 JUSB1.3 L51.3 R736.2
USBP0_R_D-: D72.3 JUSB1.2 L51.2 R740.2
USBP1+: L113.1 R1707.1 UH4.B25
USBP1-: L113.4 R1705.1 UH4.C25
USBP1_R_D+: D90.2 JUSB3.3 L113.2 R1707.2
USBP1_R_D-: D90.3 JUSB3.2 L113.3 R1705.2
USBP2+: L111.4 R1680.1 UH4.A26
USBP2-: L111.1 R1679.1 UH4.C26
USBP2_D+: D87.2 JESA1.3 L111.3 R1680.2
USBP2_D-: D87.3 JESA1.2 L111.2 R1679.2
USBP4+: JMINI2.38 UH4.D28
USBP4-: JMINI2.36 UH4.E28
USBP5+: JMINI1.38 UH4.A28
USBP5-: JMINI1.36 UH4.C28
USBP7+: JSC1.1 UH4.M28
USBP7-: JSC1.2 UH4.N28
USBP11+: JBT1.12 UH4.K32
USBP11-: JBT1.11 UH4.L32
USBP12+: L10.4 R427.1 UH4.E32
USBP12-: L10.1 R428.1 UH4.G32
USBP12_D+: JLVDS1.35 L10.3 R427.2
USBP12_D-: JLVDS1.36 L10.2 R428.2
USBP13+: L52.1 R742.1 UH4.A32
USBP13-: L52.4 R741.1 UH4.C32
USBP13_R_D+: D73.2 JFP1.3 L52.2 R742.2
USBP13_R_D-: D73.3 JFP1.4 L52.3 R741.2
USBRBIAS: RH151.1 UH4.B33 UH4.C33
USH_DET#: RH164.1 UH4.A42
USH_PWR_ON: T117.1(TP-1) U46.A18
USH_PWR_STATE#: R1627.1 U46.A34
USH_SMBCLK: R591.1 U51.A50
USH_SMBDAT: R592.1 U51.B53
VAXG_VAL_SENSE: RC69.1 RC122.2 U1.H45
VCI_IN1#: R1156.2 U51.A63
VCI_IN3#: R813.2 U51.A1
VCP2: R387.1 U9.31
VFB: PR1328.1 PU1300.15 PU1300.16
VGA_ID: R800.2 R803.1 U46.B59
VIDALERT_N: PR718.1 RC60.2 RC61.2
VIDSCLK: PR716.1 U1.B43
VIDSOUT: PR719.1 RC63.2 U1.C44
VLDOIN_1.5V: PJP204.2 PU200.19
VOL_DOWN: R887.1 R1197.2
VOL_MUTE: R884.2 R1169.2
VOL_UP: R886.2 R1118.2
VR_EN: PR722.2 PR723.2 PU700.9
VR_HOT#: PR721.2 PU700.8
VSB_N_001: PC9.2 PQ4.2 PR19.2 PR20.2
VSB_N_002: PC17.1 PQ6.2 PR25.2
VSB_N_003: PQ6.1 PR20.1
VSET_4021: C282.1 R406.1 U9.28
VSUM+: PC738.1 PC739.1 PC740.1 PR746.1 PR747.1 PR755.1 PU700.14
VSUM-: PC738.2 PC739.2 PC743.1 PH703.2 PR724.1 PR747.2 PR750.2 PR754.1 PR757.2
VSUMG+: PC707.1 PC708.1 PC709.1 PR707.1 PR709.1 PR758.1 PU700.1
VSUMG-: PC707.2 PC708.2 PC711.1 PH700.2 PR709.2 PR710.1 PR711.1 PR729.1 PR759.2
VSYNC: RH124.2 UH4.M49
VSYNC_BUF: R1670.1 RH124.1 U74.2
VSYNC_CRT: L103.1 R1670.2 U74.4
VTT_SENSE: PR508.2 RC98.2 U1.AN16
VTT_SENSE_FB: PC510.2 PR507.1 PR508.1
WIGI_RADIO_DIS#: D92.1 R1726.1 R1728.2 U46.A1
WIGI_RADIO_DIS#_R: D92.2 JMINI2.32 R1726.2
WIMAX_LED#: JMINI2.42 Q124.4 R705.1 R706.1
WIRELESS_LED#: Q77.1 Q78.1 Q78.3 Q124.3 Q124.6 Q126.1 R937.2 U46.A47
WIRELESS_ON#/OFF: JSNIF1.2 R766.2 U46.B13
WLAN_LAN_DISB#: U15.4 U46.A64
WLAN_LED: JLED1.6 R1732.2
WLAN_LED#: JMINI2.44 Q124.1 R718.1
WLAN_RADIO_DIS#: D31.1 R693.1 U46.A48
WLAN_RADIO_DIS#_R: D31.2 JMINI2.20 R693.2
WWAN_RADIO_DIS#: JMINI1.20 R774.2 U46.A53
WWAN_SMBCLK: JMINI1.30 R1157.1 R1159.2
WWAN_SMBDAT: JMINI1.32 R1158.1 R1160.2
XDP_DBRESET#: JXDP1.18 JXDP2.18 RC19.2 RC26.1 UH4.K3
XDP_DBRESET#_R: RC26.2 U1.K58
XDP_HOOK2: JXDP1.12 RC7.2
XDP_PRDY#: JXDP1.2 U1.N53
XDP_PREQ#: JXDP1.1 RC32.2 U1.N55
XDP_RST#_R: JXDP1.17 RC8.2
XDP_TCLK: JXDP1.26 RC40.2 U1.L56
XDP_TDI: JXDP1.22 RC23.2
XDP_TDI_R: RC23.1 RC29.2 U1.M60
XDP_TDO: JXDP1.20 RC24.2 RC35.2
XDP_TDO_R: RC24.1 U1.L59
XDP_TMS: JXDP1.23 RC27.2 U1.L55
XDP_TRST#: JXDP1.21 RC41.2 U1.J58
XTAL25_IN: RH99.1 RH309.2 UH4.V47
XTAL25_OUT: CH18.2 RH99.2 UH4.V49 YH2.3
XTALI: C471.2 U31.10 Y3.3
XTALO: R1144.2 U31.9
Z2805: R1111.1 TR1.22
Z2806: R1113.1 TR1.16
Z2807: R1112.1 TR1.21
Z2808: R1114.1 TR1.15
Z4012: PD4.2 PR1.2
Z4304: PBATT1.2 PD5.2 PR7.1
Z4305: PBATT1.3 PD5.3 PR9.1
Z4306: PBATT1.4 PD6.3 PR8.1
ZODD_WAKE#: R771.1 U46.A59
N17119947: R797.2 U46.B49
N17205875: C747.1 R885.2
N17404646: C713.1 R795.2
N17405164: C712.1 R794.2
N17481292: JMINI2.22 R1717.1
N17556679: Q51.2 R737.2 R750.2
N17561673: Q26.2 R458.2
N18070155: R765.1 U46.B66
N18141816: JDIMM1.197 RD8.2
N18141908: JDIMM1.201 RD9.2
N18979703: T110.1(TP-1) U1.G48
N19217453: Q35.5 Q35.6 R565.2
N19291438: CH19.2 RH309.1 YH2.1
N20242522: CE757.1 RE678.2
N24959979: R941.1 U51.B27
N24963144: R942.1 U51.B28
N25181996: T104.1(TP-1) UH4.K10
N25312880: R403.1 U9.14
N25856953: CH96.1 RH360.2 UH4.AG33
N25909465: R1669.1 U73.1 U74.1
N26057763: C632.1 Q38.3 Q39.3 R714.2 R1620.1
N26067861: C644.1 Q40.3 Q41.3 R722.2 R1625.1
N26117328: Q19.2 Q19.5 Q20.1 R414.2
N26124934: C293.1 Q18.3 Q19.3 R412.2 R1632.1
N26158006: C289.1 R1630.2 U4.1
N26158260: R1624.1 U7.4
N27100114: Q52.2 R735.2 R744.2
N28286485: Q80.6 Q81.2
N28286498: Q81.1 R938.1
N28286535: D59.1 Q74.3
N28286543: D59.2 D62.2 Q74.1 Q80.1 R932.2
N28286560: Q74.6 Q75.2
N29179028: R802.2 U46.B18
N29324689: C962.2 U72.35
N30881388: R1677.1 U75.7
N31208812: D82.2 JHP1.6 R1652.1
N31233980: JMINI1.22 R704.1
N31465762: RC140.1 U1.BC22
N31485972: R804.1 U46.B19
N31665312: JMINI2.5 R702.2
N31665315: JMINI2.3 R700.2
N31665339: JMINI2.49 R707.2
N31835662: PBATT1.6 PD6.2
N31913039: PC740.2 PR724.2
N31914733: PC709.2 PR729.2
N32001476: R1594.2 U44.10
N32001574: R747.2 U44.7
N32110637: PR236.2 PU200.7
N32114800: PC1334.2 PC1335.1 PR1331.1 PU1300.17
N32114872: PQ1307.3 PQ1307.6 PR1339.1
N32182108: R877.1 U51.B4
N32182111: R874.1 U51.A3
N32182140: T125.1(TP-1) U46.B52
N32182143: T126.1(TP-1) U46.A49
N32182367: T130.1(TP-1) U46.B36
N32182370: T131.1(TP-1) U46.B37
N32182373: T133.1(TP-1) U46.A38
N32182391: T139.1(TP-1) U46.A2
N32182394: T140.1(TP-1) U46.B45
N32182397: T141.1(TP-1) U46.B4
N32182400: T145.1(TP-1) U46.B62
N32213779: T148.1(TP-1) U46.A55
N32248885: T164.1(TP-1) U46.B23
N32251566: T163.1(TP-1) U46.A24
N32254249: T162.1(TP-1) U46.A25
N32256934: T161.1(TP-1) U46.B28
N32259621: T160.1(TP-1) U46.B29
N32262310: T159.1(TP-1) U46.A23
N32265001: T158.1(TP-1) U46.B51
N32267694: T157.1(TP-1) U46.A44
N32270389: T156.1(TP-1) U46.B1
N32273086: T155.1(TP-1) U46.B68
N32275785: T154.1(TP-1) U46.A57
N32283925: T151.1(TP-1) U46.A6
N32294141: T165.1(TP-1) U51.A21
N32296986: R881.2 U51.B23
N32299833: T167.1(TP-1) U51.B24
N32302682: T168.1(TP-1) U51.A24
N32305533: T169.1(TP-1) U51.B20
N32308386: T170.1(TP-1) U51.B34
N32311244: T171.1(TP-1) U51.A64
N32314103: T172.1(TP-1) U51.B68
N32336663: T185.1(TP-1) U51.B17
N32342387: T183.1(TP-1) U51.A59
N32356732: T178.1(TP-1) U51.A44
N32359607: T177.1(TP-1) U51.B61
N32362485: T176.1(TP-1) U51.A57
N32365364: T175.1(TP-1) U51.B38
N32368245: T174.1(TP-1) U51.B37
N32371128: T173.1(TP-1) U51.B36
N32666783: C650.1 Q42.3 Q43.3 R729.2 R1628.1
N32666787: Q43.5 Q43.6 R728.2
N32698050: T184.1(TP-1) U72.46
N32753734: T186.1(TP-1) U72.25
N32757660: Q66.1 R928.2
N33347320: R749.2 U44.19
N33441735: R808.2 U46.B32
N33679357: C1105.1 R1119.1 R1142.1
N34998882: JDIMM2.197 RD14.1
N34998891: JDIMM2.201 RD13.1
N35569138: C470.2 R1144.1 Y3.1
N35646942: JMINI3.22 R703.2
N35662040: CE3.1 RE5.2
N35662190: CE4.1 RE6.2
N35748680: QC4.2 RC79.2 RC82.2
N35878381: Q75.1 R1731.1
N35891349: Q79.1 R1732.1
N35904795: Q84.6 R1733.1
N38461343: Q16.2 R399.2
N38642362: Q127.1 R1744.2
N41544557: PQ1306.6 PR1351.2 PU1302.1
N41544731: PQ1307.2 PR1334.1 PR1340.2 PU1304.1
N41544908: PQ1306.3 PR1349.2
N41545377: PC1318.2 PC1320.2 PC1321.2 PC1325.1 PR1323.2 PU1300.5
N41545445: PC1321.1 PC1324.1 PR1325.2
N41545447: PR1323.1 PR1325.1 PU1300.6
N41545453: PC1317.1 PR1322.2 PU1300.23
N41545553: PC1304.2 PC1305.1 PR1305.2 PU1300.27
N41545569: PC1303.2 PC1304.1 PR1304.2 PU1300.28
N41545593: PC1328.1 PR1327.2 PU1300.7
N41545632: PC1322.2 PR1332.2
N41545661: PC1340.1 PR1340.1 PR1343.2 PU1304.3
N41545671: PC1320.1 PC1326.1 PR1324.2 PU1300.4
N41545684: PC1307.1 PR1313.1 PR1317.1 PU1300.2
N41545694: PR1320.2 PU1300.13
N41545780: PC1318.1 PR1324.1
N41545867: PC1333.2 PC1334.1 PR1330.2 PU1300.18
N41546281: PR1326.3 PR1330.1
N41546291: PR1326.2 PR1331.2
N41546364: PC1341.1 PR1341.2 PR1349.1 PR1350.1 PU1304.2
N41546445: PQ1307.5 PU1302.4
N41556518: PC744.1 PR754.2
N41556530: PC744.2 PR750.1 PU700.15
N41556590: PC714.1 PR720.2 PU700.25
N41556606: PC710.2 PR711.2 PU700.40
N41557415: PC745.2 PR751.1
N41557433: PC751.2 PR760.1
N41557582: PC750.1 PR763.1
N41557767: PH702.2 PR725.2 PR727.2
N41558133: PC742.1 PR749.1
N41558218: PH701.2 PR712.2 PR715.2
N41558481: PC729.1 PR744.2
N41558483: PC722.1 PC723.2 PR740.1 PR741.2 PR744.1 PU700.17
N41558520: PC704.1 PC705.1 PR701.2 PR702.1 PR703.2 PU700.38
N41558526: PC704.2 PR704.1
N41558536: PC702.1 PC705.2 PR705.1 PU700.37
N41558552: PC702.2 PR703.1
N41558564: PC701.2 PR701.1
N41558599: PH700.1 PR707.2
N41558673: PC710.1 PR710.2
N41558853: PC722.2 PR736.1
N41558869: PC727.2 PR741.1
N41563264: PR90.1 PU7.15
N41563268: PC78.1 PR91.1 PU7.14
N41563287: PC90.1 PC91.2 PU7.2
N41563311: PR87.2 PR88.1 PU7.5
N41563327: PC74.1 PR82.1 PU7.17
N41563337: PR86.2 PU7.6
N41563341: PC91.1 PR89.2
N41563825: PC77.2 PR85.1
N41563829: PC92.2 PU7.4
N41563876: PR89.1 PU7.3
N41568184: PC504.1 PR502.2
N41568228: PC508.1 PR504.2
N41572339: PC404.1 PR401.2
N41572388: PC408.1 PR404.2
N41580322: PC278.2 PR200.1
N41580445: PR205.2 PU200.9
N41595933: PC115.1 PR111.1 PR113.1 PU100.13
N41596081: PC117.1 PQ105.2 PR115.2 PR116.2
N41596129: PQ104.2 PQ104.5 PQ105.1 PR114.1
N41596157: PD100.2 PR113.2
N41606152: PQ2.3 PR11.2 PR13.1
N41606158: PC10.1 PQ5.4 PR21.2 PR23.2
N41606375: PL4.1 PQ2.1 PR11.1 PR14.2
N41606402: PQ3.2 PR14.1 PR16.2
N41606406: PQ2.2 PQ3.1 PR15.2 PR17.1
N42353034: R404.1 U9.11
N42516812: PQ1311.6 PR1306.2
N42517551: PQ1300.4 PR1307.2 PR1308.1
N42519434: PQ1311.2 PQ1311.3 PR1307.1
N42556457: PR1333.2 PR1338.2 PR1342.1 PR1348.1 PU1304.7
N42556491: PC1338.1 PR1333.1 PR1335.2 PR1346.1 PU1304.5
N42556510: PC1339.1 PR1336.2 PR1347.1 PU1304.6
N45015465: R887.2 U51.B18
N45030722: R886.1 U51.B8
N45129141: Q22.1 R423.2
N45129332: Q19.6 R413.2
N46600369: Q107.3 R1086.2
N50370296: C973.2 R1658.1
N50384913: C974.2 R1659.1
N50388248: C975.2 R1660.1
N50391897: C976.2 R1661.1
N55822747: QC1.1 RC64.1
N64413733: C962.1 U72.36
N64569940: C977.1 R1076.2
N64569944: C978.1 R1077.2
N64933189: Q39.5 Q39.6 R713.2
N64933249: Q73.1 R723.2
N67392857: JDEG2.1 R864.2
N68970634: R884.1 U51.B2
N68970908: R867.2 U51.B62
N70809161: R677.2 U38.3
N70882773: Q78.6 Q79.2
N81133948: C1106.1 R1120.1 R1141.1
N398407301: PH703.1 PR746.2

Pads without a net: D23 2; D78 8; D83 3; D88 8; D89 8; FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JFP1 2; JHDMI1 14; JLID1 3; JMINI1 3 5 17 19 44 45 46 47 49; JMINI2 8 10 12 30; JMINI3 1 3 5 7 11 13 20 30 32 36 38 42 44 45 46 47 49; JSIM1 4 8; JSNIF1 1; JTAA1 7 13 14; JTP1 6 13; JXDP1 4 5 7 8 24; JXDP2 1 2 4 5 7 8 12 13 15 21 24; PD7 3; PU100 18 25; PU300 1 7; PU700 11 13 27 28 29 30 35; Q80 3 4 5; Q84 3 4 5; Q107 1 2 6; U1 A8 A11 A15 A19 A23 A55 AA4 AC1 AC3 AC4 AE6 AE7 AE10 AE11 AF4 AG4 AG11 AG13 AH2 AM14 AM15 AT21 AT49 AU19 AU21 AV19 AY21 AY22 B6 B10 B14 B18 B22 BA19 BA22 BA43 BB19 BB21 BC43 BD21 BD22 BD25 BD26 BE22 BE24 BE26 BF23 BG22 BG26 C5 C8 C9 C11 C13 C15 C17 C19 C21 C23 C51 D8 D9 D12 D13 D16 D17 D19 D21 D23 D24 D52 D53 E5 E14 E21 E55 E59 F6 F8 F10 F14 F17 F21 F22 F51 F53 G8 G10 G13 G17 G19 G22 G53 G55 G58 G59 H6 H8 H13 H19 H22 H48 H51 H60 J4 J14 J21 K4 K6 K7 K10 K13 K15 K17 K19 K22 K24 K48 K49 K53 L42 L45 L47 L51 L53 M10 M13 M14 N42 N50 P13 U14 W14; U9 4 5 18 22 25 29 30; U31 6; U38 11 14 25 27; U46 A14 A15 A16 A52 A56 B7 B12 B14 B16 B55 B61; U72 15 16 17 18 19 20 24 48; UC1 1; UH4 A30 A34 AB1 AB3 AB8 AB10 AB37 AB38 AB40 AB42 AB45 AB46 AD5 AD7 AD49 AF1 AF3 AF36 AF43 AF45 AH4 AH5 AH12 AH37 AH38 AJ47 AJ48 AK1 AK43 AK45 AL24 AM4 AM5 AM8 AM10 AM12 AM13 AM40 AM42 AN23 AP10 AP11 AP39 AP40 AP43 AP45 AP47 AP49 AT1 AT3 AT4 AT5 AT8 AT10 AT12 AT38 AT43 AT45 AT47 AT49 AU2 AU3 AU16 AU34 AV1 AV3 AV5 AV7 AV10 AV34 AW30 AW38 AY3 AY5 AY7 AY16 AY30 AY34 AY36 AY38 AY43 AY45 AY47 AY49 B21 B29 BA2 BA3 BA47 BA48 BB1 BB3 BB5 BB7 BB34 BB36 BB43 BB45 BB47 BB49 BC8 BC38 BD4 BE8 BE36 BE38 BE42 BE44 BF3 BF6 BF36 BF42 BF44 BG4 BG6 BG16 BG26 BG32 BG36 BG37 BG42 BG46 BH23 BH25 BH37 BH41 BJ16 BJ22 BJ26 BJ32 BJ36 BJ42 C18 C29 C30 C34 D44 E30 E36 E42 G30 G34 H3 H28 J48 K1 K24 K28 K30 K42 L24 L30 M20 M36 M43 N30 P37 P39 P42 P46 T14 T17 T45 V12 V19 V37 V38 V40 V42 Y1 Y3 Y13 Y36 Y37 Y43 Y45

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4970 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 672 vias
v3: diameter 0.508, hole 0.229, TOP to BOTTOM, 473 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 183 vias
v5: diameter 0.483, hole 0.229, TOP to BOTTOM, 346 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.75V_DDR_VTT_ON: length 326.2
  TOP w0.102: U46.A60 257.41,73.56 v1(256.85,73) 256.65,73 R790.2 ; v2(44.09,62.19) 44.25,62.36 v1(44.25,62.86)
  TOP w0.254: PR236.1 43.78,63.33 v1(44.25,62.86)
  IN1 w0.084: v1(42.96,85.49) 42.38,84.92 42.38,80.2 43.47,79.11 43.47,72.27 44.74,71 44.74,63.35 v1(44.25,62.86)
  IN2 w0.122: v1(42.96,85.49) 44.77,87.3 65.15,87.3 66.37,88.53 72.81,88.53 74.53,86.81 77.17,86.81 83.95,93.6 87.1,93.6 88.47,94.98 92.08,94.98 93.84,96.74 93.84,101.1 98.5,105.75 103.82,105.75 106.21,103.37 135.21,103.37 136.74,101.85 137.59,101.85 138.04,101.39 147.47,101.39 147.84,101.77 155.63,101.77 158,99.4 158,98.03 159.5,96.52 164.54,96.52 166.18,94.88 166.18,82.56 167.48,81.26 167.48,78.54 166.98,78.04 166.98,69.19 167.9,68.26 167.9,67.42 168.33,66.99 168.33,58.45 169.01,57.76 169.01,54.48 173.76,49.74 180.69,49.74 187.17,43.26 193.14,43.26 199.34,37.06 211.2,37.06 212.87,38.74 217.56,38.74 220.75,41.93 220.75,43.64 229.96,52.85 232.52,52.85 235.14,55.47 236.61,55.47 242.86,61.71 250.45,61.71 253.26,64.52 253.26,67.66 255.8,70.2 255.8,71.94 v1(256.85,73)
1.05V_0.8V_PWROK: length 202.1
  TOP w0.102: R883.2 RH283.1 112.78,22.29 v1(112.78,22.75)
  IN1 w0.084: v1(162.32,10.26) 161.9,10.68 160.5,10.68 155.6,15.58 141.13,15.58 140.29,16.42 140.29,17.57 139.31,18.55 v1(138.98,18.55) 138.14,17.71 135.8,17.71 135.46,18.05 129.19,18.05 124.22,23.02 113.05,23.02 v1(112.78,22.75)
  IN3 w0.122: v1(162.32,10.26) 163.88,8.7 174.73,8.7 174.99,8.96 179.56,8.96 184.37,13.77 184.37,17.44 184.55,17.63 184.55,21.19 184.77,21.4 184.77,22.64 185.77,23.64 185.77,25.43 185.21,25.98 185.21,26.76 186.1,27.65 186.1,28.55 187.81,30.25 187.81,32.85 187.07,33.58 187.07,36.84 185.11,38.8 185.11,49.81 176.93,57.98 173.06,57.98 170.9,60.14 170.9,61.03 170.64,61.29 170.64,72.47 170.01,73.09 170.01,78.55 169.09,79.47 169.09,89.44 v1(167.54,90.99)
  BOTTOM w0.102: v1(138.98,18.55) 138.78,18.75 138.78,19.49 v2(138.39,19.88) 137.77,20.49 137.09,20.49 136.63,20.95 136.63,22.82 137.11,23.31 U50.4
  BOTTOM w0.254: PR723.1 147.5,91.27 147.95,91.72 150.42,91.72 151.68,90.46 167.01,90.46 v1(167.54,90.99)
1.05V_0.8V_PWROK_R: length 6.9
  TOP w0.102: JXDP2.10 118.42,20.43 118.25,20.6 118.25,20.79 117.95,21.09 117.51,21.09 RH284.2 116.59,21.55 116.34,21.3 115.49,21.3 115,21.78 v2(114.04,21.78) 113.18,21.78 RH283.2
1.05V_A_PWRGD: length 184.2
  TOP w0.102: v1(294.31,61.48) 294.19,61.48 293.81,61.1 U51.A14
  TOP w0.254: v1(166.63,65.5) 163.55,65.5 v4(158.17,70.88) 157.45,71.6 v1(156.49,71.6)
  IN4 w0.084: v1(294.31,61.48) 293.77,60.93 293.77,54.81 294.26,54.32 294.26,53.63 293.38,52.74 290.25,52.74 289.46,51.95 289.46,50.33 289.08,49.94 280.03,49.94 278.49,48.4 274.58,48.4 274.03,47.85 270.93,47.85 268.61,45.53 259.65,45.53 258.58,44.46 254.73,44.46 253.25,42.99 236.33,42.99 230.17,36.83 219.59,36.83 217.6,34.84 198.1,34.84 193.86,39.09 192.48,39.09 188.92,42.64 187.46,42.64 182.77,47.33 182.77,48.01 181.45,49.34 172.98,49.34 171.42,50.9 170.64,50.9 166.76,54.77 166.76,57.39 167.67,58.29 167.67,64.46 v1(166.63,65.5)
  BOTTOM w0.254: v1(156.49,71.6) 155.97,71.08 155.97,70.48 155.44,69.94 155.44,69.45 155.16,69.18 155.16,68.43 PR400.2 155.94,67.66 PU400.1
1.5V_B+: length 25.4
  TOP w0.102: v2(23.45,59.09) 24.02,59.66 25.39,59.66
  TOP w0.508: v1(43.66,67.08) PR205.1
  IN3 w0.254: v1(27.91,60.22) 28.48,60.79 30.21,60.79 32.7,58.3 36.87,58.3 41.43,62.87 41.43,65.85 42.66,67.08 v1(43.66,67.08)
1.5V_FB: length 5.3
  TOP w0.203: 41.05,62.74 v2(41.07,62.72) ; 41.05,62.74 41.7,62.74 PR238.2 ; 41.05,62.74 40.73,63.05 40.73,63.57 40.36,63.95 PU200.6
  TOP w0.254: PR238.2 41.39,61.85 PR237.2 41.38,61.36 PC215.2
1.5V_RUN_ENABLE: length 12.8
  BOTTOM w0.406: 179.95,2.36 179.56,2.36 179.43,2.48 Q52.3
  BOTTOM w0.508: 179.95,2.36 v2(183.04,2.36) 185.37,2.36 186.85,3.83 Q59.4 189.21,3.83 C771.1 R1610.1 R920.2
1.05V_RUN_ENABLE: length 11.5
  TOP w0.102: Q64.1 141.22,43.23 141.48,43.49 141.48,44.19 R1611.1 R930.2 140.83,45.45 137.55,45.45 v3(136.62,46.38)
  BOTTOM w0.102: Q63.4 C773.1 136.06,45.82 v3(136.62,46.38)
1.5V_SUS_PWRGD: length 331.7
  TOP w0.102: v1(291.27,58.78) 291.7,58.35 U51.B9
  TOP w0.203: PU200.10 40.53,65.55 40.98,66 v2(40.98,66.98) 41.93,67.94 PR204.2 v1(41.93,68.84)
  IN4 w0.084: v1(41.93,68.84) 42.19,68.84 44.2,70.85 44.2,78.36 51.39,85.54 59.65,85.54 60.11,85.08 63.99,85.08 64.68,85.78 65.27,85.78 68.69,89.2 86.35,89.2 86.71,89.56 91.55,89.56 92.13,90.14 100.7,90.14 109.33,98.77 114.67,98.77 116.02,100.12 131.11,100.12 133.59,97.64 135.35,97.64 136.45,96.54 136.45,94.99 137.52,93.92 139.3,93.92 139.52,94.14 153.05,94.14 159.45,87.74 160.43,87.74 167.9,80.28 167.9,71.32 168.77,70.45 168.77,57.9 167.87,57 167.87,55.17 171.06,51.98 171.83,51.98 173.41,50.39 182.04,50.39 184,48.44 184,47.59 187.89,43.7 189.5,43.7 193.06,40.14 194.29,40.14 198.54,35.9 217.16,35.9 219.15,37.89 229.68,37.89 235.95,44.15 252.68,44.15 254.24,45.71 258.07,45.71 259.13,46.78 265.7,46.78 266.99,48.07 268.62,48.07 271.47,50.91 275.32,50.91 276.52,52.12 278.42,52.12 280.4,54.1 285.61,54.1 285.73,53.98 292.28,53.98 293.02,54.71 293.02,57.97 292.64,58.35 291.69,58.35 v1(291.27,58.78)
1.05V_VTTPWRGD: length 31.7
  TOP w0.254: PU500.1 126.51,10.14 127.6,9.04 128.05,9.04 128.42,8.67 PR500.1 128.95,8.13 131.63,8.13 132.49,8.99 132.49,11.03 134.49,13.03 v4(137.09,13.03) 141.18,13.03 v1(141.89,13.74)
  BOTTOM w0.254: PR83.2 v1(141.89,13.74) 140.35,13.74 138.93,15.16 138.93,17.73 139.49,18.29 139.49,18.76 139.08,19.17 139.08,19.91 138.41,20.58 U50.1
1.8V_RUN_PWRGD: length 237.7
  TOP w0.102: v1(177.27,6.08) 177.95,6.08 v2(178.63,6.77) 179.08,7.22 179.08,8.64 183.28,12.84 185.1,12.84 186.42,14.16 188.99,14.16 191.02,16.19 191.02,22.84 192.12,23.94 192.12,25.28 195.23,28.39 v1(195.23,43.16) ; v1(265.1,72.03) 264.59,71.52 U46.B10
  TOP w0.254: PR300.2 98.49,4.82 99.22,4.82 99.29,4.9 ; v1(99.31,4.9) 99.29,4.9 ; 99.29,4.9 99.29,4.92 99.32,4.95 99.32,6.66 97.12,8.86 97.12,14.49 v1(97.39,14.75)
  IN2 w0.122: v1(97.39,14.75) 97.39,15.93 98.26,16.8 130,16.8 133.74,13.07 140.05,13.07 141.18,11.94 147.87,11.94 150.48,9.33 153.65,9.33 154.7,8.28 156.75,8.28 158.67,6.36 170.84,6.36 172.43,4.77 175.96,4.77 v1(177.27,6.08)
  IN4 w0.084: v1(265.1,72.03) 264.66,71.59 264.66,70.33 264.4,70.07 258.9,70.07 258.62,69.79 256.55,69.79 255.82,70.51 248.05,70.51 247.43,71.14 238.7,71.14 236.35,68.79 236.35,64.81 235,63.46 235,60.7 230.97,56.67 230.97,56.37 228.86,54.26 228.86,52.05 221.87,45.05 215,45.05 213.94,43.99 196.06,43.99 v1(195.23,43.16)
  BOTTOM w0.254: v1(99.31,4.9) 99.07,5.13 PU300.4
1.8VSP_FB: length 6.2
  BOTTOM w0.102: v2(92.42,3.12) 92.59,3.29 PR305.1
  BOTTOM w0.254: PC301.2 PR302.2 94.58,3.29 PR305.1 93.66,3.57 94.26,4.18 94.93,4.18 95.38,4.63 PU300.6
1.8VSP_LX: length 3.8
  BOTTOM w0.102: 100.26,5.42 100.26,7.22 v2(98.82,8.66)
1.8VSP_VIN: length 0.7
  BOTTOM w0.102: v2(93.29,10.2) 93.29,9.45
2VREF_6182: length 15.4
  TOP w0.254: PU100.3 249.27,6.25 v1(249.54,5.99) 249.77,6.23 PU100.4 ; v1(250.58,12.52) 250.27,12.22 PU100.14
  IN1 w0.254: v1(250.58,12.52) 251.39,11.71 251.39,7.85 v1(249.54,5.99)
  BOTTOM w0.102: v4(250.22,10.37) 250.58,10.73 v1(250.58,12.52)
  BOTTOM w0.254: v1(249.54,5.99) 249.07,6.46 PC101.1
3.3V_RUN_ENABLE: length 7
  BOTTOM w0.102: Q56.1 232.06,52.96 231.76,52.65 v2(231.34,52.65) C766.1 R940.2 R1618.1 227.86,52.13 227.86,51.48 228.07,51.27 Q61.4
3V_PWROK#: length 3.1
  BOTTOM w0.102: U9.12 v2(163.56,103.24) 164.5,103.24 R391.2
5V_ALW_PCH_ENABLE: length 6.8
  BOTTOM w0.102: RH279.2 189.77,23.63 v2(188.12,23.63)
  BOTTOM w0.508: RH279.2 CH107.1 190.23,21.5 QH8.1 190.62,21.49 190.85,21.26 QH4.2
5V_RUN_ENABLE: length 1.7
  BOTTOM w0.102: v2(184.93,16.02) 186.67,16.02
+0.75V_DDR_VTT: length 33.3
  IN1 w1.016: 35.74,60.16 35.74,62.68 36.91,63.85 36.91,66.02 37.61,66.72 38.3,66.72 38.96,67.38 38.96,70.84 35.64,74.15 35.64,84.44
  BOTTOM w0.254: JDIMM1.203 70.03,85.25
  BOTTOM w0.356: v1(62.07,83.46) 62.07,82.88 62.4,82.55 JDIMM2.204 ; JDIMM1.204 75.06,85.55 v1(74.94,85.68) ; 70.03,85.25 v1(70.43,85.65)
  vias: v1(34.07,86.15) v1(34.71,86.15) v1(35.39,86.17) v1(35.53,59.2) v1(36.04,86.8) v1(36.04,86.17) v1(36.16,59.2) v1(53.99,84.6) v1(54.39,83.21) v1(54.64,84.6) v1(55.03,83.21) v1(55.28,84.6) v4(72.85,85.37)
+0.75V_P:
  vias: v4(36.25,62.09)
+1.0V_LAN: length 26.2
  TOP w0.203: 283.09,79.85 283.21,79.73 U31.47 ; 283.09,79.85 283.36,80.13 U31.46 ; 283.09,79.85 282.29,79.85 282.02,80.12 C466.1 ; C468.1 293.44,79.83 v4(292.21,79.83) 291.78,79.83 291.08,80.53 U31.16 ; C467.1 282.43,83.73 U31.37 ; v1(282.28,81.31) 282.47,81.5 283.17,81.5 283.34,81.33 U31.43 ; U31.22 290.71,82.93 291.24,83.46 C469.1 291.78,83.46 ; v1(289.15,77.04) 288.71,77.47 U31.11 ; U31.40 282.56,82.53 v1(282.33,82.76) ; C463.1 287.51,75.97 U31.8
  TOP w0.508: C466.1 281.46,79.63 v1(281.7,79.38) ; v1(282.21,84.69) C467.1 ; v1(293.69,82.64) 293.69,82.95 293.19,83.46 R548.1 291.78,83.46 ; C463.1 286.99,76.11 v1(286.99,76.5) ; v1(293.51,80.59) 293.51,79.9 C468.1
  vias: v1(294.67,82.8) v1(294.82,83.58) v1(295.46,83.58) v1(296.09,83.59)
+1.05V_+1.5V_1.8V_RUN: length 35
  TOP w0.508: CH53.1 144.85,26.6 v1(144.8,26.55)
  IN2 w0.102: 162.16,39.52 162.16,39.99
  IN2 w0.254: 163.38,33.98 163.4,34.01 163.4,34.21 ; 163.4,34.21 162.93,34.21 162.13,35.01 162.13,35.53 162.26,35.66 162.26,36.05 162.44,36.23 162.78,36.23 163,36.01 163,35.79 163.24,35.54 163.24,34.88 163.4,34.72 163.4,34.21
  IN2 w0.508: v3(157.78,23.66) 158.81,23.66 159.53,24.38 159.53,24.88 160.47,25.82 163,25.82 163.38,26.2 163.38,33.98 ; 162.44,36.23 162.49,36.28 162.49,37.41 161.77,38.14 161.77,39
  IN4 w0.508: v1(153.32,26.5) 153.32,26.13 153.73,25.73 157.16,25.73 157.38,25.5 157.38,24.83 157.17,24.61 157.17,24 157.51,23.66 v3(157.78,23.66)
  BOTTOM w0.254: UH4.Y49 161.19,43.19 v1(161.1,43.28) ; v3(157.78,23.66) 157.96,23.66 UH4.AF11 ; v1(153.32,26.5) 153.32,26.37 UH4.AT16 153.7,26.02 154.35,26.02 UH4.AP16
  vias: v1(142.97,25.5) v1(144.07,26.55)
+1.5V_CPU_VDDQ: length 58.4
  TOP w0.508: 101.14,18.11 102.57,16.67 R926.1
  BOTTOM w0.254: U1.AW26 113.3,48.65 112.98,48.33 v5(112.98,48.2) ; U1.BA40 112.17,55.01 111.84,54.68 v1(111.84,54.62) ; v5(108.59,51.7) 108.59,51.71 U1.BG33 ; U1.AV41 113.89,55.58 114.17,55.86 v5(114.17,56.02) ; U1.AN26 116.08,48.94 v5(116.42,49.29) ; U1.BB28 111.7,49.43 v5(111.7,49.16)
  BOTTOM w0.508: RC12.1 95.88,79.84 94.7,78.66 94.7,67.65
  BOTTOM w5.08: 96.6,55.14 96.6,43.29 98.51,41.39 98.51,29.19 98.56,29.14
  vias: v1(95.43,59.62) v1(96.07,59.62) v1(96.7,59.62) v1(97.35,59.62) v1(97.99,59.62) v1(98.62,59.62) v1(98.76,23.78) v1(99.28,59.62) v1(99.29,24.24) v1(99.8,24.7) v1(99.92,59.62) v1(100.31,25.16) v1(100.28,19.21) v1(100.55,59.62) v1(100.92,19.21) v1(101.19,59.62) v1(101.55,19.21) v1(105.33,51.7) v1(106.58,49.78) v1(112.81,50.2) v1(113.2,47.37) v1(115.58,56.22) v1(115.55,51.69) v4(96.27,19.73) v5(114.98,48.23) v5(115.45,53.91) v5(115.67,52.75) v5(115.75,54.61) v5(116.42,54.62) v5(116.42,52.84) v5(116.42,51.07) v5(117.79,55.51) v5(117.79,53.73) v5(117.79,51.95) v5(117.79,50.18)
+1.5V_CPU_VDDQ_CHG: length 3.9
  TOP w0.127: R926.2 v2(103.49,14.55)
  TOP w0.508: Q71.1 103.05,11.16 103.49,11.59 R926.2
+1.05V_M: length 211.3
  TOP w0.508: v1(159.44,32.84) 159.44,32.72 159.83,32.32 CH69.1 ; v1(161.1,33.81) 161.01,33.71 CH67.1 ; CH68.1 163.28,27.21 v1(162.7,27.21) ; R548.2 v1(292.92,85.98)
  IN2 w0.508: v1(298.59,46.2) 296.67,46.2 295.92,45.45 292.77,45.45 289.97,42.64 281.15,42.64 278.51,40.01 272.08,40.01 270.42,38.34 254.36,38.34 253.42,39.28 247.36,39.28 245.94,37.86 238.2,37.86 228.84,28.49 194.14,28.49 192.8,29.84 187.66,29.84 187.05,29.23 182.95,29.23 181.84,28.12 v1(180.52,28.12)
  IN3 w0.102: 162.3,27.59 160.64,27.59 ; 155.82,33.17 155.82,32.43 ; 155.78,34.86 155.78,34.12 ; 159.07,29.32 159.07,28.41 ; 156.62,29.21 156.62,28.55 156.76,28.41 157.42,28.41 157.44,28.43 ; 158.26,29.32 158.26,28.41 ; 156.63,33.15 156.63,32.48 ; 158.08,28.43 158.08,28.43 157.44,28.43 ; 157.44,28.43 157.44,29.2 ; 155.81,31.72 155.81,30.82
  IN3 w0.508: v1(292.92,85.98) 292.92,84.41 291.51,83 291.51,80.13 292.56,79.08 292.56,74.62 293.83,73.35 294.89,73.35 296.68,71.56 296.68,69.07 297.15,68.6 297.15,65.62 299.38,63.39 299.38,46.99 v1(298.59,46.2)
  IN4 w0.508: v1(180.52,28.12) 180.91,28.12 181.21,28.42 181.21,29.67 179.03,31.84 175.69,31.84 174.77,30.93 170.81,30.93 170.68,30.8 167.75,30.8 165.73,32.82 163.32,32.82 163.29,32.85 161.9,32.85 v1(161.89,32.84)
  BOTTOM w0.508: v1(180.52,28.12) 181.29,28.12 CH64.1 CH65.1
  vias: v1(144.32,46.44) v1(144.3,45.81) v1(144.3,45.17) v1(144.3,44.54) v1(144.94,45.81) v1(144.94,45.17) v1(144.95,46.44) v1(145.6,46.47) v1(145.6,45.81) v1(146.23,46.47) v1(151.08,48.74) v1(151.41,49.31) v1(151.72,48.75) v1(152.05,49.32) v1(152.35,48.75) v1(152.68,49.32) v1(152.99,48.75) v1(153.33,49.31) v1(153.65,48.74) v1(153.78,39.74) v1(153.99,49.31) v1(154.29,48.74) v1(157.85,33.73) v1(160.3,32.84) v1(160.3,31.33) v1(160.27,28.05) v1(161.11,31.34) v1(161.09,29.56) v1(161.1,28.84) v1(162.73,28.03) v4(152.25,47.67)
+1.5V_MEM: length 177.3
  TOP w0.508: v1(92.32,71.27) 96.9,75.84 RC80.1
  IN2 w2.032: 145.89,10.41 139.6,10.41 138.4,11.62 131.45,11.62 130.05,13.01 130.05,14.41 128.87,15.6 100.39,15.6 97.53,12.74 93.58,12.74 ; 183.09,3.57 171.81,3.57 170.4,4.98 155.96,4.98 154.22,6.72
  BOTTOM w0.356: JDIMM2.124 62.15,58.55 61.2,59.5 v1(61.2,60.31) ; JDIMM2.106 62.13,53.15 v1(61.58,53.7) ; JDIMM2.118 64.59,56.75 64.87,57.04 v1(64.87,57.34) ; v1(56.67,51.23) 56.49,51.05 JDIMM2.99 ; JDIMM1.75 69.64,46.85 v1(69.69,46.9) ; JDIMM1.94 77.56,52.55 v1(77.95,52.93) ; v1(61.2,51.2) 61.98,51.2 62.14,51.35 JDIMM2.100 ; JDIMM1.88 77.77,50.75 v1(77.95,50.57) ; JDIMM2.105 v1(56.67,52.85) ; v1(77.95,59.75) 77.94,59.75 JDIMM1.118 ; v1(69.69,59.54) 69.6,59.45 JDIMM1.117 ; JDIMM1.105 67.27,55.85 66.63,55.21 v1(66.63,54.86) 66.63,54.71 67.29,54.05 JDIMM1.99 ; v1(69.69,50.54) 69.6,50.45 JDIMM1.87 ; JDIMM2.117 56.8,56.45 v1(58.15,55.1) 57.71,54.65 JDIMM2.111 ; JDIMM2.76 61.42,44.15 v1(61.2,43.93) ; JDIMM2.75 54.25,43.85 v1(53.75,43.34) ; v1(77.95,62.04) 77.46,61.55 JDIMM1.124 ; JDIMM1.93 66.87,52.25 v1(66.54,52.58) ; JDIMM1.111 69.31,57.65 v1(69.69,57.26) ; v1(53.75,49.27) 53.76,49.25 JDIMM2.93 ; JDIMM1.112 75.73,57.95 75.73,57.95 75.28,57.95 74.83,57.49 v1(74.83,57.27) 74.83,56.36 75.04,56.15 JDIMM1.106 ; v1(53.75,47.28) 53.92,47.45 JDIMM2.87 ; JDIMM1.81 69.65,48.65 v1(69.69,48.61) ; v1(73.88,54.86) 74.58,54.16 75.24,54.16 75.43,54.35 JDIMM1.100 ; v1(61.2,55.1) 62.27,55.1 62.41,54.95 JDIMM2.112 ; v1(69.69,62.03) 69.69,61.76 69.19,61.25 JDIMM1.123 ; v1(64.77,49.3) 64.52,49.55 JDIMM2.94 ; JDIMM2.123 53.95,58.25 v1(53.75,58.05) ; JDIMM2.81 54.02,45.65 v1(53.75,45.37) ; v1(77.95,48.28) 77.28,48.95 JDIMM1.82 ; JDIMM1.76 75.24,47.15 74.74,47.65 v1(74.74,48.55) ; JDIMM2.82 64.36,45.95 64.77,46.37 v1(64.77,46.86) 64.77,47.52 64.55,47.75 JDIMM2.88
  BOTTOM w0.508: 89.54,64.81 89.54,67.05 92.32,69.83 v1(92.32,71.27)
  vias: v1(50.32,51.45) v1(50.7,58.05) v1(50.7,55.76) v1(50.7,53.73) v1(50.7,49.27) v1(50.7,47.28) v1(50.7,45.37) v1(50.7,43.34) v1(52.6,51.45) v1(53.75,55.76) v1(53.75,53.73) v1(58.15,56.97) v1(58.15,51.2) v1(58.15,48.45) v1(58.15,46.48) v1(58.15,43.93) v1(59.29,53.7) v1(61.12,41.87) v1(61.2,56.97) v1(61.2,48.45) v1(61.2,46.48) v1(69.69,52.98) v1(70.83,54.86) v1(72.74,62.03) v1(72.74,59.54) v1(72.74,57.26) v1(72.74,52.98) v1(72.74,50.54) v1(72.74,48.61) v1(72.74,46.9) v1(73.12,54.86) v1(77.16,44.47) v1(77.95,57.26) v1(79.09,55.04) v1(80.21,44.47) v1(80.99,59.75) v1(80.99,57.26) v1(80.99,52.93) v1(80.99,50.57) v1(80.99,48.28) v1(80.99,46.45) v1(81.38,55.04) v1(81.63,62.04) v1(81.92,64.5) v1(81.92,63.86) v1(82.55,64.5) v1(82.55,63.86) v1(83.19,64.5) v1(83.19,63.86) v1(83.82,64.5) v1(83.82,63.86) v1(84.46,64.5) v1(84.46,63.86) v1(90.01,13.55) v1(90.01,12.91) v1(90.65,13.55) v1(90.65,12.91) v1(91.42,13.57) v1(91.42,12.93) v1(92.06,13.57) v1(92.06,12.93) v1(184.04,5.24) v1(184.38,4.66) v1(184.67,5.24) v1(185.31,5.24) v4(78.24,14.68)
+1.5V_MEN_P: length 41.5
  TOP w0.203: PU200.5 39.21,62.82 39.35,62.67
  TOP w0.254: 39.35,62.67 40.48,61.54 PR237.1 40.48,60.49 PC215.1 PC282.1 40.47,59.09 v1(40.85,58.71)
  IN3 w0.254: v1(22.8,53.66) 23.99,53.66 24.9,54.57 37.09,54.57 40.85,58.33 v1(40.85,58.71)
  IN3 w1.016: 23.48,55.71 23.53,55.76 36.68,55.76 38.58,57.66 38.58,57.68
  vias: v1(22.76,54.95) v1(22.79,54.32) v1(30.3,52.33) v1(30.3,51.6) v1(30.98,52.32) v1(30.98,51.58) v1(38.75,58.71) v1(39.4,58.7) v1(39.97,55.59) v1(39.97,54.95) v1(39.97,54.32) v1(40,53.62) v1(40.61,55.59) v1(40.61,54.95) v1(40.61,54.32) v1(40.63,53.62) v1(41.31,56.79) v1(41.31,56.16) v1(41.31,55.52) v1(41.31,54.89) v1(41.31,54.25) v1(41.31,53.62) v1(41.94,56.16) v1(41.94,55.52) v1(41.94,54.89) v1(41.94,54.25) v1(41.94,53.62) v1(42.8,57.49) v4(40.59,56.21)
+1.05V_MP: length 18.3
  IN2 w0.254: v1(159.26,52.33) 159.26,68.67 v1(158.44,69.49)
  BOTTOM w0.508: PR406.1 158.67,69.26 v1(158.44,69.49)
  vias: v2(159.24,49.06)
+1.5V_RUN: length 187.8
  TOP w0.508: C594.1 v1(298.42,41.32) ; C593.1 278.63,41.72 v1(278.3,41.38)
  TOP w1.524: 145.67,20 147.41,18.26 147.41,16.32 149.66,14.07 149.66,9.28 ; 274.5,7.4 271.79,10.12 271.79,15.97 268.94,18.82 268.94,35.39
  IN3 w1.016: 272.05,45.67 269.21,48.51 269.21,57.77 271.34,59.9 271.34,62.98 270.67,63.65 270.67,66.76 270.13,67.29 270.13,67.9
  IN3 w1.524: 242.33,61.24 239.27,58.18 239.27,49.43 238.4,48.55 238.4,42.34 ; 153.17,6.92 155.5,4.58 168.26,4.58 169.93,2.91 184.99,2.91 187,4.91
  IN4 w1.016: 288.74,39.85 289.07,39.52 296.94,39.52 297.6,40.18 ; 279.93,40.72 283.25,37.4 285.91,37.4 287.88,39.37
  BOTTOM w0.508: v1(269.97,68.8) 270.58,68.19 C602.1
  BOTTOM w0.61: v1(298.42,41.32) 298.1,41.32 297.8,41.62 JMINI1.6 ; v1(287.09,40.7) 287.08,40.69 286.34,40.69 285.8,41.23 JMINI1.28
  BOTTOM w2.794: 237.09,39.25 233.03,35.19 233.03,27.84 228.85,23.66 223.27,23.66 217.34,17.73 217.34,14.83
  vias: v1(140.14,25.44) v1(140.81,25.44) v1(141.44,25.44) v1(151.72,8.54) v1(152.4,8.56) v1(153.03,8.56) v1(188.92,5.18) v1(189.57,5.21) v1(190.22,5.19) v1(237.93,41.06) v1(238.56,41.06) v1(239.22,41.04) v1(243.19,63.59) v1(243.2,62.94) v1(243.48,68.53) v1(244.18,68.53) v1(251.76,69.17) v1(251.77,68.52) v1(258.18,27.87) v1(258.17,19.75) v1(258.78,40.36) v1(258.78,39.72) v1(258.82,27.87) v1(258.81,19.75) v1(271.73,44.71) v1(271.71,44.03) v1(272.36,44.71) v1(278.3,40.75) v4(267.8,39.15)
+1.05V_RUN: length 53.2
  TOP w0.102: v4(140.21,31.73) v1(140.21,31.1)
  TOP w0.305: CH6.1 120.6,20.99 120.42,20.81 JXDP2.14
  TOP w0.508: CH44.1 146.75,32.7 v1(145.95,31.9) ; CH6.1 120.6,22.45 v1(120.62,22.46) ; RH359.1 158.65,38.31 159.05,37.92 159.05,36.18 159.31,35.92 v1(159.76,35.92)
  IN2 w0.508: 157.05,24.47 157.05,22.32 157.37,22.01 157.37,20.38 157.06,20.07 157.06,19.09 157.68,18.48 157.68,15.99 158.96,14.7 v1(158.96,13.83)
  IN3 w0.508: v1(120.62,22.46) 120.62,22.78 121.09,23.25 121.48,23.25 121.86,23.63 121.86,26.64 123.04,27.82 127.2,27.82 128.96,29.59 140.04,29.59 v1(140.38,29.25)
  BOTTOM w0.254: UH4.AB36 160.19,35.49 v1(159.76,35.92)
  BOTTOM w0.508: v1(158.96,13.83) 159.25,13.83 159.67,14.25 RH40.2 RH42.2 ; RH111.1 141.03,30.29 v1(140.21,31.1) ; R925.1 140.04,29.25 v1(140.38,29.25)
  vias: v1(138.99,44.31) v1(138.99,43.67) v1(138.99,42.97) v1(138.99,42.34) v1(138.99,41.7) v1(139.63,44.31) v1(139.63,43.67) v1(139.63,42.97) v1(139.63,42.34) v1(139.63,41.7) v1(154.03,30.46) v1(154.03,29.47) v1(155.36,34.48) v1(155.38,31.33) v1(155.38,28) v1(155.39,27.19) v1(155.39,26.37) v1(156.22,32.8) v1(156.21,28.84) v1(157.04,32.8) v1(157.03,30.39) v1(157.04,28.84) v1(157.04,28) v1(157.85,28.84) v1(157.84,24.4) v1(158.66,28.84) v1(158.68,26.44) v1(158.67,25.69) v1(158.67,25.05) v1(159.47,28.88) v1(159.47,26.42) v1(162.72,32.18) v1(162.72,31.2)
+1.5V_RUN_CHG: length 4.9
  BOTTOM w0.127: v2(199.66,11.45) 200.6,10.51 Q68.1
  BOTTOM w0.508: R924.2 203.5,10.08 203.07,10.51 Q68.1
+1.05V_RUN_CHG: length 4
  BOTTOM w0.102: R925.2 v2(136.86,28.53)
  BOTTOM w0.508: Q70.1 139.1,26.78 138.77,27.11 138.77,27.68 138.41,28.04 R925.2
+1.05V_RUN_VCCA_A_DPL: length 20.9
  TOP w0.508: v1(148.81,41.77) 141.76,41.77 139.73,39.74 v2(139.73,37.55) 139.74,37.54 v1(139.74,36.13)
  BOTTOM w0.254: v1(148.81,41.77) 149.19,41.39 UH4.BD47
  BOTTOM w0.508: v1(139.74,36.13) 139.74,35.58 139.16,35 CH92.1 138.91,33.47 CH94.1 137.51,33.34 LH6.2
+1.05V_RUN_VCCA_B_DPL: length 14
  TOP w0.508: v1(141.61,40.71) 144.43,40.71 v2(144.72,41) v1(148.81,41)
  BOTTOM w0.254: UH4.BF47 148.31,41.37 148.68,41 v1(148.81,41)
  BOTTOM w0.508: v1(141.61,40.71) 141.95,40.71 CH93.1 141.8,39.88 141.18,39.88 140.64,39.34 CH95.1 140.64,38.19 LH7.2
+1.05V_RUN_VTT: length 426
  TOP w0.305: JXDP1.16 89.94,75.78 92.22,78.05
  TOP w0.508: v5(117.78,59.06) 117.71,59.13 PC1197.1 ; RC29.1 132.85,81.54 v1(133.09,81.79) ; RC60.1 127.23,56.35 v1(127.12,56.46) ; RC27.1 RC35.1 131.06,81.71 v1(130.92,81.85) ; PR730.2 PR735.2 PR737.2 147.74,91.64 v1(147.74,93.02) ; PC1192.1 116.49,59.85 v5(116.78,60.15) ; RC44.1 RC126.1 135.51,79.63 v1(135.41,79.52) ; v5(119.35,59.16) 119.39,59.12 PC1175.1 PC1190.1 ; 92.22,78.05 92.22,82.29 CC65.1 92.87,84.38 v1(92.46,84.78) ; R1179.1 280.41,50.43 280.88,50.9 v1(281.03,50.9) ; v5(117.61,61.23) 117.63,61.25 PC1172.1 ; v5(117.78,57.31) 117.74,57.35 PC1198.1 ; v5(118.56,60.53) 119.21,60.53 PC1191.1 119.42,60.64 PC1185.1 ; R862.2 278.73,54.67 v1(277.81,53.76)
  IN1 w0.381: v1(127.12,56.46) 127.12,56.51 126.6,57.03 126.55,57.03 ; 125.44,56.27 126.21,57.03 126.55,57.03 ; 126.55,57.03 126.55,58.25 126.95,58.66 126.95,59.7 v5(126.34,60.32)
  IN1 w0.508: v1(121.13,54.91) 123.21,54.91 124.57,56.27 125.44,56.27 ; v1(97.08,84.83) 96.72,85.2 96.72,93.04 96.17,93.58 96.17,98.52 96.97,99.32 105.01,99.32 105.44,99.76 128.83,99.76 129.39,99.2 132.01,99.2 134.4,96.81 139.34,96.81 141.13,95.02 145.75,95.02 v1(147.74,93.02) ; v1(277.81,53.76) 278.17,53.76 v1(281.03,50.9)
  IN2 w0.254: 115.49,59.61 112.49,59.61 112.49,59.42 112.83,59.08 112.83,58.82 113.15,58.51 113.68,58.51 113.96,58.23 113.96,57.78 114.27,57.48 115.92,57.48 116.42,57.98 v5(116.42,58.18) 115.94,58.65 115.94,59.15 115.49,59.61
  IN2 w0.508: v1(130.92,81.85) 133.03,81.85 v1(133.09,81.79) 135.35,79.52 v1(135.41,79.52) 137.13,79.52 138.98,77.67 138.98,73.99 140.72,72.25 v1(140.72,71.19) ; v1(155.53,9.7) 155.53,10.28 150.2,15.62 148.35,15.62 v1(145.19,18.77) ; 112.49,59.61 110.43,59.61 109.11,60.93 109.11,68.68 114.18,73.75 114.18,78.33 111.96,80.55 111.96,81.11 110.65,82.42 109.16,82.42 104.51,87.07 93.39,87.07 92.46,86.14 v1(92.46,84.78) 93.22,84.02 94.39,84.02 95.34,84.97 96.94,84.97 v1(97.08,84.83) ; v1(189.76,34.96) 192.8,34.96 195.64,32.12 227.22,32.12 242.05,46.95 243.63,46.95 245.41,48.73 253.72,48.73 254.99,50 263.62,50 264.51,50.89 275.05,50.89 275.68,51.52 275.68,51.7 277.74,53.76 v1(277.81,53.76)
  IN3 w0.508: v1(189.76,34.96) 190.14,34.58 190.14,32.69 192.11,30.72 192.11,27.81 191.48,27.19 191.48,26.64 190.1,25.26 190.1,22.84 190.86,22.08 190.86,14.41 189.57,13.12 189.57,9.87 186.88,7.18 178.47,7.18 177.62,8.02 175.38,8.02 175.12,7.76 160.89,7.76 158.95,9.7 v1(155.53,9.7)
  IN4 w0.508: v1(134.45,62.3) 134.82,62.67 134.82,69.53 136.48,71.19 v1(140.72,71.19)
  BOTTOM w0.254: UH4.AU20 UH4.AT20 154.03,27.64 v1(154.03,27.49) ; v1(115.77,46.62) 115.77,46.75 U1.AN22 ; UH4.BJ8 146.21,21.35 v1(146.21,21.28) ; v1(147.74,93.02) 150.51,93.02 152.18,91.36 158.01,91.36 159.73,93.09 161.37,93.09 164.89,96.61 166.97,96.61 R399.1
  BOTTOM w0.508: 126.82,27.56 129.06,29.8 129.06,31.06 RC1.1 ; RC63.1 135.81,80.55 135.41,80.16 v1(135.41,79.52) ; v1(130.92,81.85) 130.92,81.65 130.6,81.33 RC128.1 ; v1(140.72,71.19) RC4.1
  vias: v1(110.08,45.18) v1(111.78,43.84) v1(113.12,43.76) v1(113.34,19.24) v1(114.1,19.21) v1(114.41,24.08) v1(114.71,41.4) v1(114.81,19.21) v1(115.42,28.46) v1(115.47,25.13) v1(115.47,19.21) v1(116.13,19.24) v1(116.21,26.25) v1(116.22,24.05) v1(116.77,19.24) v1(117.43,19.21) v1(117.53,27.47) v1(117.54,25.11) v1(117.52,24.03) v1(118.98,30.57) v1(119.41,24.04) v1(119.6,26.28) v1(119.66,35.6) v1(119.79,38.01) v1(120.22,47.39) v1(120.44,24.01) v1(120.73,48.45) v1(120.87,24.98) v1(120.88,19.21) v1(121.05,50.21) v1(121.09,56.04) v1(121.1,53.63) v1(121.1,51.9) v1(121.11,47.6) v1(121.63,35.06) v1(123.23,23.56) v1(124.01,26.35) v1(124.15,22.46) v1(124.21,29.5) v1(126.13,22.46) v1(143.92,18.77) v1(144.56,18.77) v1(152.77,18.53) v4(121.52,31.71) v5(116.42,56.4) v5(116.42,47.51) v5(116.94,42.49) v5(117.09,43.95) v5(117.17,45.74) v5(117.79,48.4) v5(117.79,46.62) v5(117.79,44.84) v5(117.81,42.54) v5(117.81,41.89) v5(118.9,47.4) v5(118.86,42.54) v5(118.92,41.26) v5(119.35,46.66) v5(119.38,45.18) v5(119.37,43.86) v5(119.79,42.54) v5(119.81,41.92) v5(121.13,46.68) v5(121.14,45.23) v5(121.14,43.86) v5(121.38,42.24)
