# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N32311244: length 6.6
  TOP w0.102: T171.1 296.21,49.87 295.12,49.87 294.34,50.64 294.34,50.8 292.88,52.26 291.96,52.26 291.76,52.45 U51.A64
N32314103: length 4.3
  TOP w0.102: U51.B68 292.01,53.46 294.85,50.62 T172.1
N32336663: length 5.1
  TOP w0.102: U51.B17 292.97,62.35 294.79,64.16 T185.1
N32342387: length 1.4
  TOP w0.102: U51.A59 289.26,52.13 289.46,51.93 T183.1
N32356732: length 8.7
  TOP w0.102: v1(275.76,57.76) 276.37,57.76 T178.1 ; U51.A44 281.94,56.6 v1(281.82,56.47)
  IN4 w0.084: v1(281.82,56.47) 281.35,56.01 278.15,56.01 276.39,57.76 v1(275.76,57.76)
N32359607: length 8.4
  TOP w0.102: T177.1 293.26,51.15 v1(293.01,51.4) ; U51.B61 288.51,53.97 288.38,54.1 288.38,54.62 v1(288.82,55.07)
  BOTTOM w0.102: v1(293.01,51.4) 291.52,51.4 289.43,53.49 289.43,54.46 v1(288.82,55.07)
N32362485: length 1.8
  TOP w0.102: T176.1 288.51,51.71 288.26,51.96 U51.A57
N32365364: length 11.9
  TOP w0.102: U51.B38 283.9,60.85 v1(284.12,60.62) ; v1(275.76,59.91) 274.94,60.73 T175.1
  IN1 w0.084: v1(284.12,60.62) 283.82,60.92 280.34,60.92 279.62,60.2 278.21,60.2 278,60.41 276.26,60.41 v1(275.76,59.91)
N32368245: length 15.3
  TOP w0.102: T174.1 273.93,62.38 v1(275.76,60.55) ; v1(284.77,60.59) 284.77,60.61 284.16,61.22 283.83,61.22 283.7,61.35 U51.B37
  IN1 w0.084: v1(284.77,60.59) 284.13,61.23 280.33,61.23 279.51,60.41 278.29,60.41 278.05,60.65 275.87,60.65 v1(275.76,60.55)
N32371128: length 13.3
  TOP w0.102: U51.B36 283.88,61.85 v1(284.07,61.65) ; T173.1 275.46,64.37 v1(277.91,61.92)
  IN1 w0.084: v1(284.07,61.65) 279.65,61.65 279.44,61.44 278.39,61.44 v1(277.91,61.92)
N32666783: length 8.3
  BOTTOM w0.102: Q42.3 240.9,46.2 241.25,45.84 R1628.1 R729.2 C650.1 241.85,48.6 v4(241.36,49.09) 239.85,49.09 239.26,49.68 Q43.3
N32666787: length 3.6
  BOTTOM w0.102: Q43.6 237.28,50.98 237.42,50.84 237.42,50.47 237.28,50.33 Q43.5 236.69,50.33 236.19,49.82 R728.2 235.93,50.66 v2(236.06,50.78)
N32698050: length 2.3
  TOP w0.102: T184.1 34.21,32.22 33.14,33.29 U72.46
N32753734: length 3.5
  TOP w0.102: T186.1 26.56,41.88 27.32,41.12 27.32,40.23 27.39,40.16 U72.25
N32757660: length 2.4
  TOP w0.102: Q66.1 R928.2 199.47,10.88 v2(199.32,10.73)
N33347320: length 3.2
  TOP w0.102: U44.19 v1(236.61,76.58)
  BOTTOM w0.102: v2(238.45,76.81) 238.01,76.37 R749.2 236.82,76.37 v1(236.61,76.58)
N33441735: length 12
  TOP w0.102: R808.2 272.32,84.85 v2(272.32,83.03) 272.32,82.55 v1(271.99,82.22) ; U46.B32 268.3,78.31 v1(268.03,78.58)
  IN1 w0.084: v1(268.03,78.58) 267.58,79.02 267.58,79.5 267.79,79.7 269.47,79.7 v1(271.99,82.22)
N33679357: length 3.2
  TOP w0.102: v2(39.77,43.93) 38.89,43.05 C1105.1 R1119.1 R1142.1
N34998882: length 3.8
  TOP w0.102: v2(57.41,79.21) v1(57.41,79.8) 57.57,79.96 RD14.1
  BOTTOM w0.102: JDIMM2.197 56.76,80.45 v1(57.41,79.8)
N34998891: length 4
  TOP w0.102: v2(53,82.95) v1(53,82.24) 52.94,82.17 RD13.1
  BOTTOM w0.102: v1(53,82.24) 53.59,81.65 JDIMM2.201
N35569138: length 4.6
  TOP w0.102: Y3.1 294.5,77.24 293.11,77.24 292.51,76.64 C470.2 R1144.1
N35646942: length 3.4
  TOP w0.102: R703.2 259.19,30.44 v1(258.94,30.68) 258.94,30.35 v2(258.7,30.11)
  BOTTOM w0.102: v1(258.94,30.68) 258.94,30.48 259.32,30.1 JMINI3.22
N35662040: length 2.5
  BOTTOM w0.102: v2(269.4,51.84) 269.84,52.28 CE3.1 270.42,52.28 RE5.2
N35662190: length 3.3
  BOTTOM w0.102: RE6.2 CE4.1 256.7,55.08 256.7,56.35 v2(256.48,56.56)
N35748680: length 3.6
  TOP w0.102: v2(103.17,7.19) RC82.2
  TOP w0.254: RC79.2 RC82.2 103.15,8.65 QC4.2
N35878381: length 6.3
  TOP w0.102: v2(167.48,59.09) 167.38,58.99 R1731.1
  TOP w0.254: R1731.1 166.3,59.57 166.05,59.83 v1(165.55,59.83)
  BOTTOM w0.254: Q75.1 165.41,62.24 164.97,61.8 164.97,60.2 165.33,59.83 v1(165.55,59.83)
N35891349: length 9
  TOP w0.254: v1(162.73,59.59) 162.62,59.47 162.49,59.47 R1732.1
  BOTTOM w0.254: v1(162.73,59.59) 162.73,59.64 162.2,60.17 162.2,61.24 163.33,62.37 v2(163.43,62.37) 163.43,62.43 164.1,63.1 164.1,63.78 164,63.88 164,64.89 164.24,65.14 Q79.1
N35904795: length 7.7
  TOP w0.254: R1733.1 161.18,58.63 161.44,58.38 162.48,58.38 162.74,58.65 v1(162.74,58.95)
  BOTTOM w0.254: Q84.6 162.26,62.09 161.8,61.63 161.8,59.97 v2(162.16,59.61) 162.16,59.18 162.39,58.95 v1(162.74,58.95)
N38461343: length 4.7
  BOTTOM w0.102: 167.46,95.21 168.33,95.21 169.9,93.64 Q16.2 169.9,92.39 v2(169.64,92.14)
N38642362: length 3.3
  TOP w0.102: R1744.2 288.66,68.45 Q127.1 289.3,70.4 v2(289.9,70.99)
N41544557: length 4.8
  TOP w0.102: PQ1306.6 36.83,28.77 v2(37.27,29.21)
  TOP w0.254: PU1302.1 39.36,26.56 PR1351.2 37.81,28.1 PQ1306.6
N41544731: length 78.3
  TOP w0.254: v3(44.19,30.68) 43.57,30.06 PQ1307.2
  IN3 w0.254: v3(44.19,30.68) 43.71,30.2 43.71,25.87 43.07,25.23 43.07,13.19 32.7,2.82 27.17,2.82 24.86,5.13 24.86,10.49 23.37,11.97 20.72,11.97 18.69,9.94 18.69,7.31 18.12,6.74 18.12,2.55 v1(17.74,2.17) 13,2.17 v1(11.52,3.64)
  BOTTOM w0.254: v1(17.74,2.17) 17.29,2.17 17.11,2.35 PU1304.1 17.11,5.79 PR1334.1 ; v1(11.52,3.64) 12.05,3.12 PR1340.2
N41544908: length 34.3
  TOP w0.102: PQ1306.3 34.29,26.8 v1(34.07,26.58) ; v1(34.83,3.4) 34.93,3.4 PR1349.2
  IN1 w0.084: v1(34.07,26.58) 35.12,26.58 39.1,22.6 40.84,22.6 42.4,21.04 42.4,12.29 34.83,4.72 v1(34.83,3.4)
  BOTTOM w0.102: v1(34.83,3.4) v2(34.14,3.4)
N41545377: length 14.5
  TOP w0.254: PR1323.2 PC1321.2 PC1325.1 ; PR1323.2 v1(43.74,20.84) ; PR1323.2 43.08,20.31 42.83,20.06 PC1318.2 42.3,19.59 42.25,19.64 PC1320.2 ; v1(37.78,21.26) 37.78,20.98 v2(37.44,20.64) 37.39,20.6 36.75,20.6 36.68,20.53 PU1300.5
  IN4 w0.254: v1(37.78,21.26) 38.78,22.26 42.32,22.26 v1(43.74,20.84)
N41545445: length 3.2
  TOP w0.102: PC1324.1 v2(41.38,24)
  TOP w0.254: PC1321.1 41.94,22.13 42.25,22.44 PR1325.2 PC1324.1
N41545447: length 10.7
  TOP w0.102: v1(43.8,22.82) 43.81,22.81 v2(44.35,22.81)
  TOP w0.254: v1(37.12,21.32) 37.1,21.32 36.81,21.03 PU1300.6 ; v1(43.8,22.82) PR1325.1 43.16,22.3 43.08,22.23 PR1323.1
  IN4 w0.254: v1(37.12,21.32) 38.44,22.64 43.62,22.64 v1(43.8,22.82)
N41545453:
  vias: v2(32.61,16.3)
N41545553: length 67
  TOP w0.254: v1(43.6,17.73) 45.52,19.64 45.52,33.86 42.98,36.4 42.98,45.56 41.68,46.86 35.49,46.86 32.78,49.57 v4(30.82,49.57) 30.16,49.57 27.7,52.03 23.34,52.03 21.51,53.86 PR1305.2 ; PC1305.1 36.67,15.14 36.72,15.19 PC1304.2 v1(36.05,16.25) 35.4,16.25 34.69,16.96 PU1300.27
  IN4 w0.254: v1(43.6,17.73) 37.53,17.73 v1(36.05,16.25)
N41545569: length 68.7
  TOP w0.254: PU1300.28 35.19,17 35.3,16.88 36.34,16.88 v1(36.92,16.29) PC1304.1 37.64,15.08 37.56,15.01 PC1303.2 ; PR1304.2 20.4,53.72 20.4,52.63 21.54,51.48 27.48,51.48 29.93,49.03 32.58,49.03 v4(33.44,48.17) 35.13,46.48 41.52,46.48 42.6,45.41 42.6,36.24 45.14,33.7 45.14,20.09 43.09,18.05 43.09,17.52 v1(43.6,17.01)
  IN4 w0.254: v1(43.6,17.01) 43.46,17.15 37.79,17.15 v1(36.92,16.29)
N41545593: length 3.8
  TOP w0.254: PC1328.1 38.93,21.62 38.93,21.63 PR1327.2 38.13,21.63 37.72,22.03 v2(37.55,22.03) 37.05,22.03 36.55,21.53 PU1300.7
N41545632: length 1.7
  TOP w0.102: PR1332.2 v2(27.36,21.99)
N41545661: length 10
  BOTTOM w0.102: v2(8.43,4.95) 9.67,4.95 PR1343.2
  BOTTOM w0.254: PR1340.1 10.88,3.22 10.88,3.6 10.27,4.21 PR1343.2 PC1340.1 11.69,4.91 14.27,4.91 14.57,4.61 PU1304.3
N41545671: length 11.1
  TOP w0.102: v2(42.18,16.49) 41.12,17.56 PC1326.1
  TOP w0.254: v1(41.33,20.28) 40.85,19.8 PC1320.1 PR1324.2 40.85,18.2 40.67,18.02 PC1326.1 ; v1(37.06,20.03) PU1300.4
  IN4 w0.254: v1(41.33,20.28) 40.4,21.22 39.13,21.22 37.93,20.03 v1(37.06,20.03)
N41545684: length 6
  TOP w0.254: PU1300.2 36.79,19.02 37.42,18.4 v2(37.42,17.76) 37.42,17.33 37.71,17.04 PC1307.1 ; PR1317.1 PC1307.1 ; PC1307.1 PR1313.1
N41545694: length 42
  TOP w0.254: PU1300.13 v3(32.69,23.5)
  IN3 w0.254: v1(26.59,5.95) 26.59,5.52 27.2,4.91 29.93,4.91 31.57,6.56 34.11,6.56 41.46,13.91 41.46,15.47 41.84,15.85 41.84,24.23 41.19,24.88 33.16,24.88 32.69,24.41 v3(32.69,23.5)
  BOTTOM w0.254: PR1320.2 v1(26.59,5.95)
N41545780: length 2.1
  TOP w0.102: v2(42.68,17.74) 42.68,18.17 42.83,18.32 PC1318.1
  TOP w0.254: PC1318.1 42.23,18.68 42.18,18.63 PR1324.1
N41545867: length 6
  TOP w0.102: PC1334.1 27.79,20.81 v2(27.54,20.56)
  TOP w0.254: PU1300.18 30.57,20.03 30.51,20.09 29.41,20.09 PC1334.1 28.68,21.71 PR1330.2 PC1333.2
N41546281: length 33.4
  TOP w0.254: PR1330.1 29.99,21.74 30.18,21.93 v1(30.26,21.93)
  IN1 w0.254: v1(31.02,11.4) 30.93,11.31 30.93,11.07 31.12,10.88 37.66,10.88 38.86,12.07 38.86,16.94 38.29,17.52 38.29,22.13 37.97,22.44 30.76,22.44 v1(30.26,21.93)
  BOTTOM w0.254: v1(31.02,11.4) 30.84,11.58 30.84,12.18 v2(30.42,12.6) 30.06,12.96 30.06,14.97 30.17,15.07 PR1326.3
N41546291: length 36
  TOP w0.254: v3(30.23,23.54) 30.23,24.1 29.86,24.47 PR1331.2
  IN1 w0.254: v1(30.33,11.4) 30.46,11.27 30.46,11 30.96,10.5 37.82,10.5 39.24,11.92 39.24,17.1 38.67,17.67 38.67,22.28 38.13,22.82 30.96,22.82 v3(30.23,23.54)
  BOTTOM w0.254: PR1326.2 29.47,15.07 29.64,14.9 29.64,12.74 30.46,11.92 30.46,11.54 v1(30.33,11.4)
N41546364: length 37.7
  TOP w0.102: v2(37.53,3.67) PR1350.1
  TOP w0.254: PR1350.1 36.07,3.67 36.05,3.65 PR1349.1 35.59,4.13 35.58,4.15 PR1341.2 PC1341.1 v1(34.58,5.42)
  IN3 w0.254: v1(15.84,4.4) 15.84,6.61 18.26,9.03 18.26,11.01 18.78,11.53 19.74,11.53 20.57,12.37 23.56,12.37 25.27,10.67 25.27,5.36 26.61,4.01 33.17,4.01 v1(34.58,5.42)
  BOTTOM w0.254: v1(15.84,4.4) PU1304.2
N41546445: length 3.9
  TOP w0.254: PQ1307.5 43.57,25.52 v2(43.31,25.26) PU1302.4
N41556518: length 3.2
  BOTTOM w0.102: PC744.1 152.32,86.89 152.32,85.72 v2(152.6,85.44)
  BOTTOM w0.254: PR754.2 151.85,87.34 PC744.1
N41556530: length 5.7
  BOTTOM w0.203: PU700.15 147.82,84.64 v2(148.63,85.45)
  BOTTOM w0.254: v2(148.63,85.45) 149.07,85.89 150.3,85.89 PR750.1 151.85,86.45 PC744.2
N41556590: length 3.9
  TOP w0.102: v1(144.3,80.67) v2(144.3,80.13)
  TOP w0.254: PC714.1 144.33,80.69 v1(144.3,80.67)
  BOTTOM w0.203: v1(144.3,80.67) 144.3,80.9 144.59,81.18 PU700.25
  BOTTOM w0.254: PR720.2 143.73,79.97 144.3,80.54 v1(144.3,80.67)
N41556606: length 5
  BOTTOM w0.102: PR711.2 142.52,89.37 v2(142.64,89.25)
  BOTTOM w0.203: PU700.40 141.34,86.24 141.19,86.38 141.19,86.94
  BOTTOM w0.254: PR711.2 PC710.2 141.19,88.06 141.19,86.94
N41557415: length 4.6
  BOTTOM w0.102: PC745.2 141.13,73.63 v2(141.13,72.18)
  BOTTOM w0.508: PC745.2 141.38,74.65 141.38,75.14 PR751.1
N41557433: length 0.6
  BOTTOM w0.102: 126.42,84.1 126.01,84.1 v2(125.9,84.21)
N41557582: length 1.1
  BOTTOM w0.102: 138.52,82.43 138.23,82.43 v2(137.69,82.98)
N41557767: length 20.3
  TOP w0.254: v1(147.35,87.49) 147.35,87.07 PR727.2 PR725.2
  IN4 w0.254: v1(147.35,87.49) 148.14,86.7 151.26,86.7 154.25,83.72 154.25,80.32 v1(154.36,80.21)
  BOTTOM w0.254: PH702.2 155.1,75.52 155.47,75.52 155.82,75.88 155.82,79.5 v2(155.21,80.11) 154.46,80.11 v1(154.36,80.21)
N41558133: length 0.6
  BOTTOM w0.102: v2(147.48,80.43) 147.48,79.8
N41558218: length 24.7
  TOP w0.254: PR715.2 144.35,86.18 PR712.2 143.23,87.3 v2(142.36,87.3) 141.94,87.3 v1(141.76,87.47) ; PH701.2 123.47,85.73 122.84,85.73 v1(122.66,85.91)
  IN2 w0.254: v1(122.66,85.91) 122.67,85.91 122.85,85.73 136.16,85.73 138.43,88.01 141.23,88.01 v1(141.76,87.47)
N41558481: length 2
  TOP w0.102: PR744.2 152.28,83.65 v2(152.43,83.8)
  TOP w0.254: PR744.2 PC729.1
N41558483: length 8.1
  TOP w0.102: v1(150.91,84.33) v2(150.91,85.33)
  TOP w0.254: v1(150.91,84.33) 150.45,83.87 PR744.1
  BOTTOM w0.203: PU700.17 147.75,83.84 147.92,83.66 PC723.2 149.48,83.66 PR741.2
  BOTTOM w0.254: PC722.1 PR740.1 151.34,83.89 v1(150.91,84.33) 150.31,84.33 149.57,83.59 PR741.2
N41558520: length 18.7
  TOP w0.102: v2(139.49,85.96) 139.49,87.37 v1(139.4,87.46)
  TOP w0.254: PR701.2 138.73,87.46 v1(139.4,87.46)
  IN4 w0.254: v1(135.93,92.17) 138.83,92.17 139.4,91.6 v1(139.4,87.46)
  BOTTOM w0.203: PU700.38 140.55,85.44
  BOTTOM w0.254: PR702.1 PC704.1 v1(135.93,92.17) ; 140.55,85.44 139.53,86.46 139.53,87.34 v1(139.4,87.46) 138.54,87.46 138.26,87.18 PC705.1 137.75,88.17 PR703.2
N41558526: length 2.1
  BOTTOM w0.102: PC704.2 135.74,91.26 v2(135.58,91.42)
  BOTTOM w0.254: PR704.1 136.73,90.87 136.75,90.88 PC704.2
N41558536: length 7.5
  BOTTOM w0.203: PU700.37 v2(138.69,85.04) 138.14,85.04 PR705.1
  BOTTOM w0.254: PR705.1 136.83,86.35 PC705.2 136.83,87.65 136.78,87.7 PC702.1
N41558552: length 2.7
  BOTTOM w0.102: v2(135.74,87.81) 135.74,88.02 136.78,89.06 PC702.2
  BOTTOM w0.254: PR703.1 PC702.2
N41558564: length 2
  TOP w0.102: v2(139.65,88.17) PR701.1
  TOP w0.254: PR701.1 PC701.2
N41558599: length 44.9
  TOP w0.102: v1(138.52,91.08) v2(138.52,91.72)
  IN4 w0.254: v1(108.98,91.01) 109.53,91.55 110.29,91.55 116.52,97.77 121.87,97.77 128.75,90.89 134.7,90.89 135.31,91.5 136.86,91.5 137.28,91.08 v1(138.52,91.08)
  BOTTOM w0.254: v1(108.98,91.01) 109.49,90.5 110.08,90.5 110.55,90.97 114.6,90.97 PH700.1 ; v1(138.52,91.08) 138.52,91.84 138.78,92.1 PR707.2
N41558673: length 2.1
  BOTTOM w0.102: PR710.2 139.74,87.77 v2(140.05,87.46)
  BOTTOM w0.254: PR710.2 139.77,88.48 PC710.1
N41558853: length 2.2
  BOTTOM w0.102: v2(151.76,81.63) 151.76,82.2 PC722.2
  BOTTOM w0.254: PC722.2 152.27,82.69 PR736.1
N41558869: length 2
  BOTTOM w0.102: PC727.2 150.26,82.48 v2(150.26,81.66)
  BOTTOM w0.254: PR741.1 PC727.2
N41563264: length 5.1
  BOTTOM w0.254: PU7.15 144.06,10.69 142.89,11.86 142.89,14.03 PR90.1
N41563268: length 7.4
  BOTTOM w0.102: v2(140.2,15.1) 140.87,14.42 PC78.1
  BOTTOM w0.254: PU7.14 143.56,10.54 142.46,11.64 142.46,14.36 PR91.1 PC78.1
N41563287: length 3.9
  BOTTOM w0.254: PC91.2 145.81,3.73 PC90.1 v2(145.81,4.81) 145.06,5.56 PU7.2
N41563311: length 4
  BOTTOM w0.254: PR88.1 PR87.2 v2(143.1,4.8) 143.56,5.27 PU7.5
N41563327: length 4.1
  BOTTOM w0.254: PU7.17 145.06,11.44 145.34,11.72 PR82.1 145.34,13.46 145.26,13.55 PC74.1
N41563337: length 3.9
  BOTTOM w0.254: PU7.6 143.06,5.62 142.31,4.86 v2(141.28,4.86) 140.63,4.21 PR86.2
N41563341: length 1.9
  BOTTOM w0.254: PR89.2 145.36,2.87 145.41,2.82 PC91.1 145.81,2.47 145.53,2.19 v3(145.36,2.19)
N41563825:
  vias: v2(136.68,2.61)
N41563829: length 2.3
  BOTTOM w0.254: PC92.2 143.99,5.35 144.06,5.43 PU7.4
N41563876: length 2.5
  BOTTOM w0.254: PR89.1 144.47,4.18 v2(144.47,4.82) 144.56,4.91 PU7.3
N41568184: length 2.4
  TOP w0.102: PR502.2 v2(119.02,9.1)
  TOP w0.508: PR502.2 120.24,9.64 120.05,9.83 PC504.1
N41568228: length 4
  BOTTOM w0.102: PR504.2 125.34,4.67 v2(125.72,4.29)
  BOTTOM w0.508: PR504.2 124.05,2.52 PC508.1
N41572339: length 1.4
  BOTTOM w0.102: v2(152.33,61.41) 152.38,61.36 PR401.2
N41572388:
  vias: v2(160.6,56.52)
N41580322:
  vias: v2(32.85,66.33)
N41580445: length 3.2
  TOP w0.203: PU200.9 40.69,65.15 v2(41.05,65.52) 41.31,65.77 41.31,66.46 PR205.2
N41595933: length 6.5
  TOP w0.102: v2(252.58,14.41) 252.35,14.18 PR113.1
  TOP w0.254: PR111.1 249.92,15.14 PC115.1 251.5,14.61 PR113.1 251.5,12.71 250.77,11.98 PU100.13
N41596081: length 5
  TOP w0.102: PQ105.2 246.49,18.7 PR115.2 PR116.2 247.99,18.95 PC117.1 v2(250.18,18.95)
N41596129: length 13.3
  TOP w0.102: v2(245.09,20.44) 244.04,19.39 PQ105.1 244.04,17.8 243.31,17.08 241.97,17.08 241.13,16.24 241.13,14.44 241.32,14.25 PQ104.2 PQ104.5 244.68,14.25 PR114.1
N41596157: length 4.9
  TOP w0.508: v1(250.59,13.51) PR113.2
  BOTTOM w0.102: v4(252.05,10.41) 251.81,10.65 PD100.2
  BOTTOM w0.508: v1(250.59,13.51) 251.44,13.51 251.81,13.14 PD100.2
N41606152: length 4.7
  TOP w0.102: v2(40.98,80.2) 40.73,79.96 PR11.2
  TOP w0.254: PQ2.3 38.33,79.85 38.64,80.16 39.21,80.16 39.41,79.96 PR11.2 PR13.1
N41606158: length 12.3
  TOP w0.254: PR23.2 PR21.2 15.7,68.79 15.45,68.54 v2(15.16,68.54) v1(14.25,68.54)
  BOTTOM w0.254: v1(14.25,68.54) 14.5,68.54 PC10.1 16.68,66.35 16.68,62.28 17.09,61.87 PQ5.4
N41606375: length 10.7
  TOP w0.254: PR11.1 39.85,81.94 39.65,82.13 v2(39.4,82.13) 37.56,82.13 37.37,81.94 PQ2.1 37.37,80.29 37.18,80.1 36.42,80.1 35.4,81.11 PL4.1 33.9,80.56 33.64,80.29 PR14.2
N41606402: length 3.9
  TOP w0.254: PR14.1 PR16.2 31.82,78.95 31.62,78.76 v2(31.62,78.37) 31.62,78.07 31.8,77.89 PQ3.2
N41606406: length 5.5
  TOP w0.254: PQ2.2 v2(34.93,78.99) 34.64,78.7 PQ3.1 PR17.1 PR15.2
N42353034: length 5.5
  BOTTOM w0.102: v2(166.96,104.95) 165.32,104.95 R404.1 164.12,103.74 162.79,103.74 162.79,103.74 U9.11
N42516812: length 4.3
  TOP w0.102: PR1306.2 30.52,76.59 v2(29.96,77.15)
  TOP w0.254: PQ1311.6 30.97,74.59 31.21,74.83 31.21,75.4 30.96,75.65 PR1306.2
N42517551: length 20.2
  TOP w0.102: v2(20.58,61.39) 19.97,61.39 v1(19.96,61.4)
  TOP w0.254: v1(25.8,72.49) PR1307.2 25.81,73.17 26.7,74.06 PR1308.1 ; v1(19.96,61.4) 19.96,61.4 PQ1300.4
  IN1 w0.254: v1(25.8,72.49) 25.32,72.49 22.22,69.39 19.8,69.39 18.52,68.11 18.52,62.34 19.46,61.4 v1(19.96,61.4)
N42519434: length 1.4
  TOP w0.102: v2(27.18,71.99) 26.71,72.46 PR1307.1
N42556457: length 10.3
  BOTTOM w0.102: PU1304.7 15.84,9.22 15.96,9.33 16.48,9.33 v2(16.83,9.69)
  BOTTOM w0.254: PR1333.2 PR1338.2 PR1342.1 PR1348.1 12.3,6.53 15.12,6.53 15.84,7.25 PU1304.7
N42556491: length 19.8
  IN3 w0.254: v1(11.84,8.95) 16.35,8.95 v1(17.33,9.93)
  IN4 w0.254: v1(11.84,8.95) 10.11,8.95 v1(8.37,7.21)
  BOTTOM w0.102: PR1346.1 19.42,11.71 v2(20.29,12.57)
  BOTTOM w0.254: v1(8.37,7.21) 8.37,6.61 PR1333.1 ; v1(17.33,9.93) PR1335.2 17.65,10.46 17.65,11.3 18.05,11.71 PC1338.1 PR1346.1 ; v1(11.84,8.95) 12.59,8.95 12.87,9.23 13.12,9.23 13.3,9.05 PU1304.5
N42556510: length 6.9
  BOTTOM w0.254: PU1304.6 14.57,7.25 14.33,7.01 12.78,7.01 v2(12.05,7.74) 11.26,7.74 PR1336.2 PR1347.1 PC1339.1
N45015465: length 3.9
  TOP w0.102: U51.B18 292.01,63.29 293.06,64.34 v2(293.06,65.06) 293.06,65.76 R887.2
N45030722: length 4.8
  TOP w0.102: v1(291.92,57.91) 291.99,57.85 U51.B8 ; v3(294.91,57.68) 294.94,57.65 R886.1
  IN1 w0.084: v3(294.91,57.68) 294.79,57.55 293.72,57.55 293.36,57.91 v1(291.92,57.91)
N45129141: length 2.7
  BOTTOM w0.102: Q22.1 146.15,98.38 R423.2 v2(145.46,96.7)
N45129332: length 2.1
  BOTTOM w0.102: R413.2 132.3,98.83 132.3,98.41 v2(132.49,98.22) 132.5,98.21 Q19.6
N46600369: length 2.3
  TOP w0.102: R1086.2 21.07,37.91 Q107.3 21.07,37.03 v2(20.74,36.71)
N50370296: length 3.7
  TOP w0.102: v2(33.28,25.11) 32.76,25.63 32.76,27.06 R1658.1
  TOP w0.508: R1658.1 C973.2
N50384913: length 0.9
  TOP w0.508: R1659.1 C974.2
N50388248: length 3.3
  TOP w0.102: R1660.1 31.81,27.06 31.81,25.5 v2(31.98,25.32)
  TOP w0.508: R1660.1 C975.2
N50391897: length 2.2
  TOP w0.102: R1661.1 29.69,27.53 v2(29.24,27.09)
  TOP w0.508: R1661.1 C976.2
N55822747: length 4.7
  TOP w0.102: v2(104.65,82.88) RC64.1 106.44,82.34 106.99,82.34 107.28,82.05 107.28,81.51 107.74,81.05 QC1.1
N64413733: length 2.7
  TOP w0.254: U72.36 27.49,34.66 26.83,34 v2(26.7,34) C962.1
N64569940: length 0.9
  TOP w0.102: C977.1 38.89,36.68 R1076.2
N64569944: length 2.7
  TOP w0.102: R1077.2 C978.1 40.45,35.1 40.82,35.1 v2(41.14,34.78)
N64933189: length 3.7
  BOTTOM w0.102: v2(233.08,52.85) 233.83,52.85 R713.2 234.1,53.13 Q39.6 234.1,54.53 234.24,54.67 234.61,54.67 234.75,54.53 Q39.5
N64933249: length 4.1
  TOP w0.508: R723.2 316.5,30.48 316.9,30.87 v2(316.9,31.25) 316.9,31.85 316.55,32.19 Q73.1
N67392857: length 3.9
  TOP w0.102: JDEG2.1 260.45,59.45 259.64,60.26 R864.2 v2(258.49,61.26)
N68970634: length 11
  TOP w0.102: R884.1 300,53.17 v1(300.2,52.98) ; U51.B2 292.32,54.85 v3(291.9,54.42)
  IN1 w0.084: v3(291.9,54.42) 292.32,54.85 293.44,54.85 294.42,53.87 295.12,53.87 296.18,52.8 300.02,52.8 v1(300.2,52.98)
N68970908: length 5.9
  TOP w0.102: v1(288.04,50.94) 288.16,50.82 R867.2 ; U51.B62 289.01,54.22 v1(288.81,54.42)
  IN1 w0.084: v1(288.04,50.94) 288.92,51.81 288.92,54.32 v1(288.81,54.42)
  BOTTOM w0.102: v2(288.92,53.9) 288.81,54 v1(288.81,54.42)
N70809161: length 3
  TOP w0.102: R677.2 276.24,15.73 v2(276.91,15.07) 277.38,14.6 U38.3
N70882773: length 2.8
  BOTTOM w0.102: Q78.6 163.59,70.11 v2(162.91,69.43) 162.91,68.75 Q79.2
N81133948: length 4.6
  TOP w0.102: R1120.1 R1141.1 39.76,41.04 C1106.1 38.37,41.39 37.13,41.39 v2(36.8,41.06)
N398407301: length 55.4
  TOP w0.102: v1(149.32,89.11) v2(150.09,89.11)
  IN3 w0.254: v1(141.23,69.3) 141.23,69.02 138.61,66.41 138.61,62.39 140,61.01 145.29,61.01 145.88,60.42 148.94,60.42 152.35,63.84 152.35,66.63 154.29,68.56 154.29,74.73 151.52,77.5 151.52,78.99 151.34,79.17 151.34,82.22 149.1,84.46 149.1,88.9 v1(149.32,89.11)
  BOTTOM w0.254: PH703.1 140.75,68.54 141.23,69.02 v1(141.23,69.3) ; PR746.2 148.93,88.72 v1(149.32,89.11)

## Copper pours and planes (outline as drawn)
1.5V_B+ on TOP (solid shape): 28.35,62.76 29.37,62.76 29.49,62.63 29.49,57.52 29.44,57.47 28.63,57.47 27.34,58.76 27.27,58.76 27.27,58.77 26.74,58.77 26.74,58.76 26.45,58.76 26.45,58.77 25.94,58.77 25.94,58.76 25.65,58.76 25.65,58.77 25.17,58.77 25.05,58.89 25.05,60.28 25.66,60.89 25.66,63.05 25.73,63.12 27.99,63.12
1.8VSP_LX on BOTTOM (solid shape): 101.19,7.4 101.19,3.64 101.06,3.52 100.36,3.52 100.23,3.39 100.23,2.13 100.16,2.05 99.34,2.05 99.25,2.14 99.25,3.38 99.69,3.82 99.69,5.28 99.49,5.48 98.52,5.48 98.5,5.49 98.41,5.57 98.41,6.21 98.52,6.31 99.32,6.31 99.47,6.47 99.47,7.36 99.74,7.62 100.96,7.62
1.8VSP_VIN on BOTTOM (solid shape): 95.96,9.39 95.96,7.33 96.27,7.02 96.27,5.53 96.2,5.46 95.4,5.46 94.67,4.72 93.94,4.72 93.94,5.25 93.39,5.25 93.39,5.55 93.94,5.55 93.94,6.05 93.39,6.05 93.39,6.35 93.94,6.35 93.94,6.93 93.05,6.93 93.05,9.41 93.23,9.59 95.76,9.59
5V_RUN_ENABLE on BOTTOM (solid shape): 189.71,17.85 189.71,16.5 189.6,16.38 189.12,16.38 188.83,16.09 188.83,15.56 189.15,15.24 189.15,14.86 188.99,14.69 186.36,14.69 186.31,14.74 186.31,16.85 187.39,17.92 189.64,17.92
+0.75V_DDR_VTT on TOP (solid shape): 35.62,60.36 35.62,59.81 35.63,59.8 36.1,59.8 36.12,59.81 36.12,60.34 36.14,60.36 36.38,60.36 36.41,60.33 36.41,59.02 36.33,58.94 35.22,58.94 35.14,59.02 35.14,60.33 35.19,60.37 35.61,60.37
+0.75V_DDR_VTT on TOP (solid shape): 76.72,85.81 76.72,84.86 76.64,84.79 69.3,84.79 69.13,84.61 65.34,84.61 64.29,83.57 64.29,83.18 64.23,83.12 60.82,83.12 60.17,82.47 56.91,82.47 56.13,81.68 53.88,81.68 53.69,81.87 53.69,84.76 53.84,84.91 57.32,84.91 58.74,83.49 59.87,83.49 62.31,85.93 76.6,85.93
+0.75V_DDR_VTT on BOTTOM (solid shape): outline of 100 points within 33.76,82.06 56.29,88.41
+0.75V_DDR_VTT on IN1 (solid shape): 36.48,86.86 36.48,84.35 36.14,84.01 34.12,84.01 33.74,84.38 33.74,86.84 33.99,87.09 36.25,87.09
+0.75V_DDR_VTT on IN1 (solid shape): 36.63,60.21 36.63,59.01 36.51,58.9 35.07,58.9 34.87,59.09 34.87,60.1 35.02,60.26 36.58,60.26
+0.75V_P on TOP (solid shape): 37.42,63.99 37.42,63.94 37.37,63.89 37.37,63.81 37.01,63.46 37.01,62.7 37.11,62.6 37.85,62.6 37.9,62.65 37.9,63.71 37.95,63.76 38.06,63.76 38.11,63.71 38.11,62.09 36.53,60.51 34.35,60.51 34.12,60.74 34.12,63.61 34.27,63.76 35.08,63.76 35.18,63.66 35.18,63.51 35.39,63.31 35.72,63.31 36.48,64.07 37.34,64.07
+1.0V_LAN on TOP (solid shape): 296.66,84.77 296.66,84.06 296.63,83.98 296.59,83.94 296.59,82.34 296.48,82.23 296.44,82.23 294.47,82.23 294.3,82.4 294.3,83.1 294.57,83.36 294.57,83.8 294.36,84.01 294.04,84.01 294,84.05 294,84.71 294.09,84.81 296.62,84.81
+1.0V_LAN on IN1: 284.4,74.98 283.72,75.65 281.44,75.65 281.29,75.8 281.29,84.35 282.01,85.07 283.43,85.07 284.14,84.36 284.14,79.04 285.27,77.91 288.71,77.91 289.9,79.09 289.9,83.49 290.54,84.13 298.04,84.13 298.32,83.85 298.32,81.62 297.96,81.27 296.25,81.27 295.79,80.81 295.79,79.52 295.61,79.35 293.05,79.35 292.88,79.18 292.88,75.96 292.51,75.59 286.67,75.59 286.06,74.98
+1.05V_+1.5V_1.8V_RUN on BOTTOM (solid shape): 145.12,26.9 145.12,26.1 144.94,25.92 143.44,25.92 143.24,25.71 143.24,25.4 143.07,25.24 142.46,25.24 142.33,25.37 142.33,26.9 142.49,27.07 144.95,27.07
+1.05V_+1.5V_1.8V_RUN on IN2 (solid shape): 161.36,43.43 161.36,43.28 161.36,43.23 161.36,42.53 162.29,41.6 162.29,40.55 162.29,40.5 162.29,39.99 162.26,39.96 162.25,39.93 162.16,39.88 162.07,39.92 162.04,39.96 162.01,40 161.98,40.06 162,40.14 162.09,40.44 161.91,40.71 161.86,40.8 161.91,40.88 161.7,41.59 161.51,40.88 161.56,40.79 161.51,40.71 161.33,40.42 161.45,40.1 161.48,40.03 161.46,39.96 161.54,39.4 162.09,39.53 162.17,39.59 162.26,39.54 162.29,39.51 162.29,38.72 162.1,38.53 161.37,38.53 160.7,39.2 160.68,39.3 160.76,39.37 161.07,39.78 160.7,40.13 160.63,40.16 160.6,40.23 160.6,42.26 160.8,42.47 160.8,43.46 160.91,43.57 161.22,43.57
+1.05V_+1.5V_1.8V_RUN on IN3 (solid shape): outline of 795 points within 142.67,24.42 153.62,29.04
+1.5V_CPU_VDDQ on TOP (solid shape): outline of 3364 points within 90.3,17.6 120.57,60.49
+1.5V_CPU_VDDQ on BOTTOM (solid shape): 101.46,67.37 101.46,59.39 101.46,59.38 101.46,55.13 100.62,54.29 94.29,54.29 91.72,56.86 91.72,67.41 92.67,68.35 100.49,68.35
+1.5V_CPU_VDDQ on BOTTOM (solid shape): outline of 131 points within 95.86,12.25 101.81,30.13
+1.5V_CPU_VDDQ on BOTTOM (solid shape): outline of 663 points within 114.73,47.89 118.61,56.16
+1.5V_CPU_VDDQ on IN2 (solid shape): outline of 2696 points within 93.92,48 118.38,60.08
+1.5V_CPU_VDDQ on IN3 (solid shape): outline of 3263 points within 94.49,47.86 119.53,60
+1.05V_M on TOP (solid shape): outline of 543 points within 143.95,39.15 155.75,50.01
+1.05V_M on BOTTOM (solid shape): 161.39,31.4 161.39,31.25 161.68,30.97 161.68,30.82 161.58,30.72 161.42,30.72 161.36,30.77 160.83,30.77 160.76,30.71 159.79,30.71 159.73,30.77 159.73,30.96 159.9,31.12 159.9,31.45 159.73,31.62 159.73,31.64 159.73,31.8 159.79,31.86 160.93,31.86
+1.05V_M on BOTTOM (solid shape): 155.71,49.54 155.71,45.96 155.04,45.29 151.54,45.29 150.26,44.01 150.06,44.01 149.31,43.26 147.08,43.26 145.5,41.68 142.31,41.68 142.09,41.9 142.09,45.9 142.33,46.14 143.53,46.14 144.22,46.82 145,46.82 145.39,47.21 145.39,47.21 145.63,47.45 150.5,47.45 150.7,47.65 150.7,49.37 151.33,50 155.25,50
+1.05V_M on BOTTOM (solid shape): 161.67,30.15 161.67,29.95 161.5,29.78 161.5,29.46 161.9,29.06 162.02,29.06 162.54,28.54 162.98,28.54 163.04,28.59 163.2,28.59 163.29,28.5 163.29,27.41 162.83,26.95 162.6,26.95 162.45,27.1 162.45,27.34 162.61,27.51 162.61,27.74 162.07,28.28 161.44,28.28 161.3,28.42 160.95,28.42 160.71,28.18 160.71,27.82 160.85,27.68 160.85,27.56 160.75,27.46 160.63,27.46 160.32,27.78 160.19,27.78 160.03,27.94 160.03,28.17 160.17,28.32 160.17,28.61 160.23,28.67 160.55,28.67 160.98,29.1 160.98,29.35 160.84,29.5 160.84,29.62 160.54,29.91 160.54,30.13 160.62,30.21 161.61,30.21
+1.05V_M on BOTTOM (solid shape): outline of 85 points within 158.9,32.33 162.11,34.28
+1.05V_M on IN2 (solid shape): 155.73,49.67 155.73,46 155.01,45.28 151.45,45.28 149.76,43.6 144.3,43.6 144,43.9 144,46.59 145.38,47.97 148.08,47.97 150.06,49.95 155.45,49.95
+1.05V_M on IN3 (solid shape): outline of 2640 points within 143.81,26.9 163.35,49.68
+1.05V_M on IN4 (solid shape): outline of 107 points within 157.53,31.07 162.16,34.09
+1.5V_MEM on TOP (solid shape): outline of 12352 points within 43.17,12.15 92.99,64.98
+1.5V_MEM on BOTTOM (solid shape): 185.09,7.99 185.43,7.99 186.04,7.39 186.04,3.9 185.63,3.48 181.68,3.48 181.45,3.71 181.45,7.77 181.67,7.99 185.09,7.99
+1.5V_MEM on BOTTOM (solid shape): outline of 447 points within 81.51,10.98 96.65,65.11
+1.5V_MEM on VCC (solid shape): outline of 142 points within 48.96,39.93 115.61,61.66
+1.5V_MEM on IN2 (solid shape): 94.09,13.84 94.09,11.74 94,11.66 91.37,11.66 91.05,11.97 91.05,13.64 91.29,13.88 94.05,13.88
+1.5V_MEM on IN2 (solid shape): 186.29,5.42 186.29,2.78 186.06,2.55 182.88,2.55 182.81,2.62 182.81,5.37 182.98,5.54 186.17,5.54
+1.5V_MEM on IN2 (solid shape): outline of 93 points within 145,4.8 155.31,11.47
+1.5V_MEM on IN3 (solid shape): outline of 4560 points within 48.93,42.33 85.1,65.17
+1.5V_MEM on GND2 (solid shape): outline of 147 points within 48.97,41.24 115.6,63.7
+1.5V_MEN_P on TOP (solid shape): 39.86,60.21 39.86,58.61 39.71,58.46 38.59,58.46 38.49,58.56 38.49,59.41 39.02,59.41 39.02,59.84 38.49,59.84 38.49,60.16 38.61,60.28 39.78,60.28
+1.5V_MEN_P on TOP (solid shape): 43.54,57.61 43.54,56.03 43.04,56.03 43.04,55.33 43.54,55.33 43.54,54.83 43.04,54.83 43.04,54.13 43.54,54.13 43.54,53.53 43.36,53.35 39.87,53.35 39.58,53.64 39.58,56.3 40.34,57.06 41.39,57.06 42.21,57.88 43.27,57.88
+1.5V_MEN_P on BOTTOM (solid shape): 25.68,59.25 28.69,59.25 29.62,58.32 29.95,58.12 30.28,58.32 41.43,58.32 42.64,59.52 47.03,59.52 47.45,59.1 47.45,53.32 47.08,52.95 45.38,52.95 43.71,51.28 30.13,51.28 27.76,53.65 24.63,53.65 24.39,53.42 22.53,53.42 22.13,53.82 22.13,56.98 21.49,57.62 21.49,59.59 21.75,59.84 25.09,59.84
+1.5V_MEN_P on IN3 (solid shape): 23.7,56.3 23.7,54.47 23.35,54.11 22.54,54.11 22.38,54.26 22.38,56.25 22.59,56.45 23.55,56.45
+1.5V_MEN_P on IN3 (solid shape): 39.65,58.84 39.65,58.02 38.89,57.26 38.08,57.26 37.95,57.39 37.95,58.3 38.61,58.96 39.53,58.96
+1.5V_MEN_P on IN4 (solid shape): 43.97,57.49 43.97,51.32 43.57,50.91 30.31,50.91 29.69,51.53 29.69,56.49 31.17,57.97 43.49,57.97
+1.05V_MP on BOTTOM (solid shape): 160.37,55.62 160.37,49.88 159.75,49.26 159.75,46.01 159.57,45.83 156.19,45.83 155.86,46.16 155.86,47.47 156.39,47.47 156.39,47.97 155.86,47.97 155.86,48.27 156.39,48.27 156.39,48.77 155.86,48.77 155.86,50.91 155.61,51.17 155.6,51.17 155.45,51.32 152.94,51.32 152.82,51.44 152.82,53.83 153.03,54.04 157.64,54.04 158.76,55.15 158.76,55.54 158.97,55.75 160.23,55.75
+1.5V_RUN on TOP (solid shape): 153.44,9.43 153.44,7.62 153.22,7.4 148.88,7.4 148.7,7.59 148.7,9.44 148.9,9.65 153.23,9.65
+1.5V_RUN on TOP (solid shape): 260.24,28.14 260.24,27.37 260.18,27.31 257.9,27.31 257.85,27.36 257.85,28.13 257.93,28.21 260.17,28.21
+1.5V_RUN on TOP (solid shape): 276.51,7.76 276.51,6.79 276.33,6.61 274.05,6.61 273.74,6.92 273.74,7.81 273.92,7.99 276.28,7.99
+1.5V_RUN on TOP (solid shape): 252.24,69.73 252.24,65.95 252.16,65.87 251.41,65.87 250.72,66.57 250.72,67.84 250.24,68.32 244.93,68.32 244.78,68.17 243.39,68.17 243.21,68.35 243.21,70.04 243.46,70.3 251.68,70.3
+1.05V_RUN on TOP (solid shape): 162.99,32.32 162.99,31.66 163.68,30.97 163.68,30.05 163.62,29.99 163,29.99 162.94,30.05 162.94,30.57 162.42,31.09 162.42,31.33 162.06,31.68 162.04,31.69 161.82,31.69 161.75,31.75 161.75,32.38 161.81,32.44 162.87,32.44
+1.5V_RUN on TOP (solid shape): outline of 226 points within 139.4,19.03 146.36,25.92
+1.5V_RUN on TOP (solid shape): outline of 417 points within 237.17,34.39 272.88,45.17
+1.05V_RUN on TOP (solid shape): outline of 426 points within 153.77,24.13 160.57,35.48
+1.5V_RUN on BOTTOM (solid shape): 239.66,41.05 239.66,39.75 237.48,37.57 236.62,37.57 235.47,38.71 235.47,39.67 237.2,41.41 239.3,41.41
+1.5V_RUN on BOTTOM (solid shape): 261.31,19.9 261.31,19.53 261.16,19.39 258.12,19.39 257.88,19.62 257.88,19.91 258.03,20.06 261.15,20.06
+1.5V_RUN on BOTTOM (solid shape): 141.69,26.84 141.69,25.3 141.57,25.18 140.01,25.18 139.86,25.34 139.86,26.16 140.57,26.87 141.66,26.87
+1.5V_RUN on BOTTOM (solid shape): 259.36,28.03 261.18,28.03 261.31,27.91 261.31,27.42 261.25,27.36 257.87,27.36 257.81,27.42 257.81,28.1 257.88,28.18 259.21,28.18
+1.5V_RUN on BOTTOM (solid shape): 259.42,40.06 261.28,40.06 261.34,40.01 261.34,39.43 261.28,39.38 258.4,39.38 258.34,39.44 258.34,40.57 258.44,40.67 258.81,40.67
+1.5V_RUN on BOTTOM (solid shape): 278.13,43.74 278.13,41.96 278.2,41.89 278.2,41.88 278.29,41.75 278.43,41.66 278.44,41.65 278.57,41.52 278.57,40.62 278.39,40.45 277.52,40.45 277.36,40.6 277.36,41.4 277.46,41.49 277.46,43.7 277.56,43.8 278.06,43.8
+1.05V_RUN on BOTTOM (solid shape): 163.94,31.95 163.94,31.68 164.24,31.38 164.24,31.37 164.35,31.19 164.53,31.08 164.54,31.08 164.6,31.02 164.6,30.82 164.51,30.72 162.82,30.72 162.59,30.95 162.58,30.96 162.53,31.05 162.46,31.11 162.46,31.34 162.62,31.49 162.62,31.84 162.45,32.01 162.45,32.25 162.53,32.31 162.57,32.38 162.58,32.39 162.87,32.68 163.21,32.68
+1.05V_RUN on BOTTOM (solid shape): 139.92,44.73 139.92,40.09 139.79,39.96 138.84,39.96 138.02,39.14 138.02,37.27 138.25,37.04 138.25,36.11 138.19,36.05 135.15,36.05 135.03,36.17 135.03,40.63 135.91,40.63 135.91,40.57 135.92,40.52 135.93,40.47 135.95,40.42 135.98,40.37 136.02,40.33 136.06,40.29 136.11,40.26 136.16,40.24 136.21,40.23 136.26,40.22 136.29,40.22 136.54,40.22 136.54,40.19 137.31,40.19 137.31,41.01 136.54,41.01 136.54,40.98 136.29,40.98 136.26,40.98 136.21,40.97 136.16,40.96 136.11,40.93 136.06,40.9 136.02,40.87 135.98,40.83 135.95,40.78 135.93,40.73 135.92,40.68 135.91,40.63 135.03,40.63 135.03,44.6 135.3,44.86 139.78,44.86
+1.05V_RUN on BOTTOM (solid shape): 160.75,29.39 160.8,29.32 160.85,29.26 160.85,29.15 160.52,28.81 159.78,28.81 159.4,28.44 159.3,28.44 159.15,28.28 158.98,28.28 158.98,28.28 158.17,28.28 158.11,28.34 158,28.34 157.99,28.34 157.85,28.37 157.71,28.34 157.7,28.34 157.58,28.34 157.32,28.08 157.32,27.9 157.17,27.76 156.92,27.76 156.77,27.9 156.77,28.14 156.86,28.23 156.86,28.24 156.91,28.28 156.91,28.43 156.91,28.55 156.79,28.67 156.79,28.85 156.46,29.18 156.46,29.32 156.55,29.41 159.16,29.41 159.31,29.26 159.62,29.26 159.74,29.38 159.77,29.41 160.74,29.41
+1.05V_RUN on BOTTOM (solid shape): 155.29,31.64 155.44,31.64 155.62,31.47 155.62,31.21 155.3,30.89 155.3,30.72 154.89,30.31 154.88,30.31 154.81,30.26 154.75,30.18 154.73,30.15 154.72,30.06 154.73,30.01 154.73,29.3 154.72,29.27 154.54,29.08 154.54,28.9 154.45,28.82 154.29,28.82 154.17,28.94 154.17,29.01 153.83,29.36 153.82,29.36 153.76,29.42 153.76,29.67 153.53,29.9 153.53,30.03 153.76,30.26 153.76,30.57 154.2,31.01 154.26,31.05 154.3,31.09 154.41,31.29 154.39,31.52 154.38,31.53 154.38,31.71 154.21,31.88 154.21,32.03 154.3,32.13 154.8,32.13
+1.05V_RUN on BOTTOM (solid shape): 156.78,33.42 156.78,33.4 157.61,32.57 157.61,30.81 157.5,30.7 157.5,30.64 157.49,30.62 157.44,30.34 157.6,30.11 157.6,29.98 157.52,29.89 157.32,29.89 157.09,30.12 156.94,30.12 156.88,30.18 156.83,30.26 156.76,30.31 156.46,30.6 156.46,30.93 156.58,31.05 156.58,31.22 156.6,31.33 156.58,31.43 156.58,31.52 156.46,31.64 156.46,32.14 156.32,32.28 155.76,32.28 155.65,32.4 155.65,32.5 155.71,32.56 155.76,32.64 155.94,32.83 155.94,32.95 156.47,33.48 156.72,33.48
+1.05V_RUN on BOTTOM (solid shape): 155.17,28.49 155.17,28.43 155.18,28.42 155.18,28.38 155.28,28.28 155.32,28.28 155.33,28.27 155.45,28.27 155.47,28.27 155.62,28.12 155.62,27.88 155.49,27.75 155.49,27.46 155.62,27.33 155.62,27.05 155.57,27 155.57,26.97 155.54,26.95 155.54,26.81 155.54,26.63 155.61,26.56 155.61,26.26 155.47,26.12 155.33,26.12 155.09,25.89 154.91,25.89 154.81,25.99 154.81,26.33 154.22,26.92 154.22,27.08 154.82,27.67 154.83,27.67 154.85,27.71 154.91,27.77 154.95,27.8 154.96,27.82 154.96,28.24 154.95,28.25 154.93,28.27 154.84,28.35 154.83,28.45 154.86,28.53 154.9,28.58 154.95,28.6 155.06,28.6
+1.05V_RUN on BOTTOM (solid shape): 160.05,26.85 160.05,25.99 159.95,25.89 159.8,25.89 159.53,26.16 159.35,26.16 159.24,26.27 159.22,26.28 158.83,26.2 158.92,25.81 158.92,24.94 158.79,24.81 158.46,24.81 158.1,24.45 158.1,24.33 158.06,24.29 158.02,24.26 157.9,24.13 157.63,24.13 157.07,24.7 157.07,24.9 157.07,24.91 157.1,25.08 157.07,25.25 157.07,25.26 157.07,25.52 157.16,25.62 158.22,25.62 158.55,25.94 158.55,26.2 158.41,26.34 158.41,26.49 158.25,26.65 158.17,26.65 158.09,26.73 158.09,26.88 158.17,26.97 159.93,26.97
+1.5V_RUN on BOTTOM (solid shape): outline of 275 points within 186.62,4.78 218.99,15.39
+1.5V_RUN on BOTTOM (solid shape): outline of 319 points within 242.49,60.05 265.43,71.14
+1.5V_RUN on IN1 (solid shape): outline of 406 points within 243.22,66.18 270.91,69.96
+1.05V_RUN on VCC (solid shape): 143.41,45.62 143.41,41 148.26,36.15 155.49,36.15 155.5,36.15 155.66,36.12 155.81,36.15 155.82,36.15 160.07,36.15 161.56,34.66 161.55,34.63 161.64,34.24 162.04,34.15 162.07,34.16 162.37,33.86 162.36,33.83 162.46,33.44 162.84,33.35 162.87,33.36 163.23,33 163.23,26.1 161.34,24.22 142.41,24.22 142.02,24.61 142.02,27.12 140.71,28.42 140.72,28.45 140.63,28.83 140.25,28.92 140.22,28.92 138.46,30.67 138.46,30.86 138.51,30.97 138.52,31.09 138.51,31.21 138.46,31.32 138.46,45.55 138.85,45.93 143.1,45.93
+1.05V_RUN on IN2 (solid shape): outline of 4735 points within 138,24.14 163,44.92
+1.5V_RUN on IN3 (solid shape): 239.46,42.4 239.46,40.92 239.31,40.78 237.69,40.78 237.51,40.95 237.51,42.35 237.8,42.63 239.22,42.63
+1.5V_RUN on IN3 (solid shape): 270.95,68.98 270.95,67.62 270.77,67.45 269.53,67.45 269.39,67.59 269.39,69.18 269.59,69.37 270.56,69.37
+1.5V_RUN on IN3 (solid shape): 272.77,45.67 272.77,44.07 272.47,43.77 271.61,43.77 271.41,43.97 271.41,46.04 271.66,46.29 272.15,46.29
+1.5V_RUN on IN3 (solid shape): 154.08,8.03 154.08,6.66 153.42,6 152.2,6 151.21,6.99 151.21,8.58 151.52,8.89 153.22,8.89
+1.5V_RUN on IN3 (solid shape): 190.49,5.57 190.49,4.81 190.16,4.48 186.46,4.48 186.21,4.74 186.21,5.59 186.44,5.83 190.23,5.83
+1.5V_RUN on IN3 (solid shape): 244.58,69.45 244.58,63.85 244.01,63.29 244.01,61.77 242.67,60.42 242.25,60.42 241.4,61.27 241.4,61.47 242.37,62.45 242.37,64.54 242.96,65.13 242.96,69.38 243.21,69.63 244.4,69.63
+1.5V_RUN on IN3 (solid shape): outline of 323 points within 256.69,19.34 259.82,40.64
+1.5V_RUN on IN4 (solid shape): 287.46,40.87 288.84,40.87 289.13,40.57 289.13,39.23 288.85,38.95 286.98,38.95 286.74,39.19 286.74,40.78 286.93,40.97 287.36,40.97
+1.5V_RUN on IN4 (solid shape): 298.9,41.62 298.9,40.23 298.09,39.42 297.52,39.42 296.91,40.03 296.91,40.26 297.51,40.86 297.51,41.41 297.82,41.72 298.8,41.72
+1.5V_RUN on IN4 (solid shape): outline of 239 points within 271.33,39.79 280.73,44.99
+1.05V_RUN_VTT on TOP (solid shape): outline of 366 points within 126.02,60.06 134.92,63.46
+1.05V_RUN_VTT on TOP (solid shape): outline of 484 points within 152.14,17.81 154.59,29.84
+1.05V_RUN_VTT on TOP (solid shape): outline of 4789 points within 109.06,23.25 124.68,48.73
+1.05V_RUN_VTT on BOTTOM (solid shape): 142.69,21.39 144.01,21.39 145.51,19.89 145.51,18.43 145.33,18.25 142.77,18.25 142.64,18.38 142.64,19.25 142.17,19.71 142.17,21.1 141.8,21.47 140.99,21.47 140.92,21.53 140.92,22.08 140.97,22.12 141.96,22.12
+1.05V_RUN_VTT on BOTTOM (solid shape): outline of 1191 points within 110.9,9.83 127.09,35.34
+1.05V_RUN_VTT on BOTTOM (solid shape): outline of 1460 points within 115.73,41.76 122.7,61.49
+1.05V_RUN_VTT on IN1 (solid shape): outline of 2342 points within 111.13,40.82 121.74,61.53
+1.05V_RUN_VTT on VCC (solid shape): outline of 335 points within 116.11,22.8 127.92,65.24
+1.05V_RUN_VTT on IN2 (solid shape): outline of 2284 points within 141.16,18.32 154.54,27.76
+1.05V_RUN_VTT on IN2 (solid shape): outline of 6345 points within 106.63,18.96 124.44,48.66
+1.05V_RUN_VTT on IN3 (solid shape): outline of 1293 points within 122.47,18.35 146.74,27.92
+1.05VTTP on BOTTOM (solid shape): 113.48,15.43 113.98,15.43 113.98,15.94 114.28,15.94 114.28,15.43 114.78,15.43 114.78,15.94 115.39,15.94 115.54,15.79 115.54,12.75 114.99,12.75 114.99,12.25 115.54,12.25 115.54,11.95 114.99,11.95 114.99,11.45 115.54,11.45 115.54,9.64 115.7,9.47 115.7,8.18 116.05,7.83 116.05,4.32 115.81,4.08 112.99,4.08 112.77,4.3 112.77,4.72 112.58,7.63 110.65,9.82 110.65,15.38 110.8,15.53 111.8,15.53 112.21,15.94 113.48,15.94
+1.05VTTP on IN1 (solid shape): 115.6,11.01 115.6,7.58 115.47,7.45 112.62,7.45 112.46,7.61 112.46,11.11 112.74,11.39 115.22,11.39
+1.8V_RUN on TOP (solid shape): 109.15,34.81 109.15,30.54 108.8,30.19 106.55,30.19 104.15,27.79 104.15,24.47 105.31,23.3 105.31,18.96 105.14,18.78 102.57,18.78 102.13,19.23 102.13,23.38 101.91,23.6 101.91,32.06 104.13,34.29 106.79,34.29 107.43,34.93 109.02,34.93
+1.8V_RUN on TOP (solid shape): outline of 1175 points within 140.43,16.4 151.25,35.13
+1.8V_RUN on BOTTOM (solid shape): 150.99,17.06 150.99,15.22 150.93,15.16 150.44,15.16 150.37,15.23 150.37,15.71 149.86,16.22 149.86,17.01 150.02,17.18 150.88,17.18
+1.8V_RUN on BOTTOM (solid shape): 111.63,37.38 111.63,36.04 111.48,35.89 111.48,35.49 111.29,35.3 111.29,34.22 109.84,32.77 109.07,32.77 105.21,28.92 105.21,28.81 105.2,28.8 104.25,25.52 106.18,22.69 106.18,18.68 106.96,17.89 106.96,13.85 106.87,13.76 105.18,13.76 104.99,13.57 102.88,13.57 102.77,13.68 102.77,21.09 102.09,21.78 102.09,33.72 102.46,34.09 106.63,34.09 107.48,34.93 109.73,34.93 110.7,35.9 110.7,35.9 110.79,35.96 110.85,36.04 110.85,36.05 110.89,36.09 110.89,37.02 110.76,37.15 110.76,37.48 110.83,37.55 110.94,37.55 110.95,37.56 111.45,37.56
+1.8V_RUN on IN1 (solid shape): outline of 1018 points within 148.74,16.27 157.58,27.44
+1.8V_RUN on IN3 (solid shape): outline of 844 points within 148.5,16.61 158.19,27.59
+1.8V_RUN on IN4 (solid shape): outline of 2893 points within 103.05,15.74 151.42,25.95
+1.8V_RUN_LVDS on TOP (solid shape): outline of 99 points within 143.56,35.6 155,38.14
+1.8V_RUN_LVDS on BOTTOM (solid shape): 145.2,36.6 145.2,35.6 144.38,34.77 144.38,33.79 144.21,33.62 143.17,33.62 142.98,33.81 142.98,36.48 143.11,36.6 144.24,36.6 144.36,36.72 145.08,36.72
+1.8V_RUNP on BOTTOM (solid shape): outline of 105 points within 101.31,3.58 105.76,13.54
+3.3V_ALW on TOP (solid shape): 206.21,7.46 206.21,5.49 206.08,5.36 203.32,5.36 203.18,5.5 203.18,7.52 203.28,7.62 206.05,7.62
+3.3V_ALW on TOP (solid shape): 265.33,63.05 265.33,61.99 265.24,61.9 259.39,61.9 259.28,62.01 259.28,63.04 259.48,63.24 265.15,63.24
+3.3V_ALW on TOP (solid shape): 206.23,17.17 206.23,15.15 206.08,15 203.33,15 203.04,15.29 203.04,17.22 203.42,17.59 205.8,17.59
+3.3V_ALW on TOP (solid shape): 313.2,37.67 313.2,32.59 312.95,32.34 311.91,32.34 310.43,33.82 310.43,37.71 310.77,38.06 312.82,38.06
+3.3V_ALW on TOP (solid shape): 277.98,48.7 277.98,45.53 277.87,45.41 276.78,45.41 276.1,46.09 276.1,48.22 276.64,48.75 277.93,48.75
+3.3V_ALW on BOTTOM (solid shape): 313.47,45.25 313.47,41.62 313.16,41.31 309.83,41.31 309.49,41.66 309.49,45.26 309.65,45.42 313.29,45.42
+3.3V_ALW on BOTTOM (solid shape): 205.96,5.8 205.96,4.63 205.76,4.42 204.79,4.42 204.6,4.22 204.6,3.54 204.47,3.4 200.85,3.4 200.68,3.58 200.68,5.45 201.23,6.01 205.76,6.01
+3.3V_ALW on BOTTOM (solid shape): 93.8,6.79 93.8,6.48 93.26,6.48 93.26,5.93 93.8,5.93 93.8,5.68 93.26,5.68 93.26,5.13 93.8,5.13 93.8,4.66 93.59,4.44 91.74,4.44 91.56,4.62 91.56,6.54 91.82,6.8 93.79,6.8
+3.3V_ALW on BOTTOM (solid shape): 133.94,102.54 133.94,102.19 134.13,101.99 134.61,101.99 134.78,102.17 138.8,102.17 138.97,102 138.97,100.69 138.79,100.51 135.23,100.51 135.14,100.42 133.3,100.42 133.06,100.67 132.24,100.67 132.07,100.84 132.07,102.56 132.23,102.72 133.75,102.72
+3.3V_ALW on BOTTOM (solid shape): 266.2,13.9 269.61,13.9 269.82,13.69 269.82,11.34 269.56,11.08 269.21,11.08 269.18,11.09 268.39,11.33 267.58,11.42 267.48,11.42 267.47,11.42 266.47,11.3 265.52,10.96 265.51,10.96 264.47,10.96 264.47,11.08 263.94,11.08 263.93,11.08 263.93,11.61 264.47,11.61 264.47,12.36 263.93,12.36 263.93,12.81 264.47,12.81 264.47,13.54 263.93,13.54 263.93,14.14 264.15,14.36 265.74,14.36
+3.3V_ALW on BOTTOM (solid shape): 238.63,56.34 238.63,51.56 238.47,51.41 236.79,51.41 236.45,51.07 235.83,51.07 235.43,50.67 235.43,49.37 235.61,49.19 236.56,49.19 237.15,48.6 240.51,48.6 240.64,48.47 240.64,47.01 240.49,46.86 236.77,46.86 236.22,46.31 232.21,46.31 231.94,46.59 231.94,51.52 231.95,51.53 235.23,51.53 235.24,51.48 235.25,51.42 235.27,51.37 235.3,51.32 235.33,51.28 235.37,51.24 235.42,51.21 235.47,51.18 235.52,51.16 235.57,51.15 235.63,51.15 235.69,51.16 235.74,51.17 235.79,51.19 235.84,51.22 235.88,51.26 235.92,51.3 235.95,51.35 235.97,51.4 235.99,51.45 236,51.5 236,51.56 235.99,51.62 235.97,51.67 235.95,51.72 235.92,51.77 235.88,51.81 235.84,51.84 235.79,51.87 235.74,51.89 235.69,51.91 235.63,51.91 235.57,51.91 235.52,51.9 235.47,51.88 235.42,51.86 235.37,51.83 235.33,51.79 235.3,51.74 235.27,51.69 235.25,51.64 235.24,51.59 235.23,51.53 231.95,51.53 232.32,51.9 234.75,51.9 235.98,53.13 235.98,56.01 236.39,56.42 238.55,56.42
+3.3V_ALW on BOTTOM (solid shape): outline of 173 points within 149.34,3.34 155.83,11.5
+3.3V_ALW on IN1 (solid shape): 173.83,13.42 174.06,13.34 174.29,13.42 175.29,13.42 175.59,13.28 175.88,13.42 178.69,13.42 178.7,13.42 179.16,13.42 179.4,13.18 179.4,11.44 179.08,11.12 175.76,11.12 175.6,10.96 175.41,10.96 175.39,10.97 174.93,10.9 174.88,10.43 174.97,10.33 175.1,10.27 175.13,10.26 175.13,8.32 174.52,7.71 171.28,7.71 170.79,8.19 170.79,12.26 170.88,12.35 170.97,12.38 171.04,12.32 171.66,12.21 171.55,12.83 171.49,12.9 171.52,12.99 171.95,13.42
+3.3V_ALW on IN1 (solid shape): outline of 148 points within 311.92,31.66 316.9,42.73
+3.3V_ALW on IN1 (solid shape): outline of 157 points within 150.97,5.88 155.86,11.43
+3.3V_ALW on IN1 (solid shape): outline of 157 points within 194.34,5.31 206.23,12.47
+3.3V_ALW on IN1 (solid shape): 284.04,49.13 284.04,47.52 283.68,47.15 281.58,47.15 281.51,47.19 281.48,47.27 281.49,47.36 281.47,47.44 281.48,47.52 281.55,47.57 281.82,47.83 281.74,48.19 281.72,48.26 281.74,48.32 281.73,48.83 281.23,48.88 281.15,48.86 281.08,48.9 280.39,48.75 281,48.38 281.07,48.4 281.14,48.36 281.17,48.32 281.19,48.26 281.17,48.19 281.08,48.02 281.09,47.83 281.08,47.75 281.01,47.7 280.93,47.67 280.86,47.62 280.79,47.6 280.72,47.62 280.25,47.64 280.12,47.18 280.14,47.15 279.72,46.73 275.94,46.73 275.63,47.04 275.63,48.46 275.9,48.74 278.18,48.74 279.07,49.63 283.54,49.63
+3.3V_ALW on VCC (solid shape): outline of 1164 points within 131.35,8.6 314.1,109.88
+3.3V_ALW on IN4 (solid shape): 153.87,11.15 153.87,9.81 153.55,9.48 151.62,9.48 150.59,8.45 150.33,8.45 149.17,9.62 149.17,9.73 150.83,11.39 153.63,11.39
+3.3V_ALW on IN4 (solid shape): outline of 352 points within 117.1,3.9 131.98,15.56
+3.3V_ALW on IN4 (solid shape): outline of 564 points within 90.79,3.92 111.89,12.53
+3.3V_ALW_PCH on TOP (solid shape): 164.4,33.66 164.4,33.24 164.4,33.24 164.4,33.12 164.63,32.9 164.63,32.19 164.56,32.13 163.3,32.13 163.16,32.27 163.16,32.89 163.19,32.93 163.59,32.93 163.87,33.21 163.87,33.65 163.93,33.71 164.01,33.71 164.36,33.71
+3.3V_ALW_PCH on TOP (solid shape): 165.02,29.92 165.02,28.44 164.91,28.34 164.18,28.34 164.08,28.24 164.08,27.66 163.3,27.66 163.09,27.87 163.09,27.9 163.1,28.12 162.98,28.31 162.75,28.55 161.65,28.55 161.6,28.6 161.6,29.74 161.74,29.88 162.93,29.88 162.97,29.84 164.08,29.84 164.23,29.99 164.94,29.99
+3.3V_ALW_PCH on BOTTOM (solid shape): 203.15,2.35 203.15,2.02 203.05,1.92 200.95,1.92 200.69,2.17 200.69,2.85 200.87,3.02 202.48,3.02
+3.3V_ALW_PCH on BOTTOM (solid shape): 163.9,30.05 163.9,29.71 164.58,29.03 164.58,27.88 164.53,27.82 163.57,27.82 163.45,27.94 163.45,28.58 163.28,28.75 163.21,28.75 163.2,28.76 163.01,28.76 162.93,28.67 162.62,28.67 162.06,29.23 161.92,29.23 161.66,29.49 161.66,29.78 162.1,30.23 163.72,30.23
+3.3V_ALW_PCH on IN1 (solid shape): 177.08,10.68 177.08,9.42 176.93,9.27 175.91,9.27 175.71,9.47 175.71,10.82 175.89,11 176.76,11
+3.3V_ALW_PCH on IN1 (solid shape): 202.91,7.91 202.91,4.8 203.23,4.49 203.23,2.1 203.06,1.93 201.03,1.93 199.63,3.32 199.63,6.14 198.54,7.23 198.54,8.42 198.75,8.63 202.2,8.63
+3.3V_ALW_PCH on IN1 (solid shape): 157.43,30.23 157.51,30.19 157.78,30.04 158.08,30.15 158.15,30.17 158.22,30.14 158.28,30.09 159.13,30.09 159.22,30.03 159.2,29.92 159.09,29.62 159.25,29.34 159.29,29.26 159.25,29.19 159.19,29.13 159.14,29.06 159.06,29.02 158.98,29.05 158.65,29.22 158.34,29.04 158.26,29 158.17,29.04 157.85,29.22 157.52,29.04 157.44,29 157.36,29.04 157.04,29.22 156.71,29.04 156.53,29.04 155.94,29.11 156,28.52 156,28.32 155.93,28.26 155.88,28.19 155.79,28.15 155.71,28.19 155.5,28.37 155.22,28.35 155.13,28.37 155.09,28.45 155.09,28.96 155.14,29.01 155.14,29.94 155.42,30.21 156.69,30.21 156.73,30.14 156.79,30.09 157.1,30.01 157.36,30.19
+3.3V_ALW_PCH on IN1 (solid shape): 164.28,28.57 164.28,28 164.33,27.94 164.33,27.02 164.29,26.94 164.2,26.93 163.8,26.84 163.71,26.44 163.7,26.35 163.62,26.31 163.28,26.31 163.11,26.48 163.11,26.51 163.07,26.66 162.98,26.79 162.91,26.86 163.08,27.22 162.91,27.52 162.87,27.61 162.92,27.7 162.74,28.41 162.52,27.71 162.56,27.62 162.51,27.54 162.44,27.48 162.38,27.41 162.3,27.37 162.21,27.41 161.92,27.56 161.62,27.42 161.54,27.38 161.46,27.42 161.41,27.48 161.34,27.52 161.29,27.6 161.49,28.02 161.29,28.33 161.24,28.42 161.29,28.51 161.48,28.8 161.35,29.13 161.32,29.2 161.35,29.28 161.09,29.94 160.84,29.27 160.88,29.2 160.84,29.12 160.72,28.8 160.91,28.51 160.96,28.42 160.91,28.33 160.84,28.28 160.79,28.21 160.69,28.16 160.61,28.22 160.3,28.43 159.95,28.27 159.87,28.23 159.79,28.27 159.74,28.33 159.67,28.38 159.62,28.46 159.67,28.55 159.86,28.86 159.7,29.18 159.66,29.26 159.7,29.34 159.85,29.62 159.75,29.91 159.73,30.02 159.82,30.09 162.76,30.09
+3.3V_ALW_PCH on IN1 (solid shape): outline of 1329 points within 157.2,11.06 163.69,28.7
+3.3V_ALW_PCH on IN2 (solid shape): outline of 121 points within 172,24.53 177.15,26.61
+3.3V_ALW_PCH on IN2 (solid shape): outline of 430 points within 144.7,27.88 155.66,29.91
+3.3V_ALW_PCH on IN3 (solid shape): outline of 909 points within 162.18,10.07 181.68,27.69
+3.3V_ALW_PCH on IN4 (solid shape): outline of 818 points within 154.78,24.8 177.01,31.35
+3.3V_ALW_PCH_JTAG on IN1 (solid shape): outline of 235 points within 169.41,13.61 177.34,18.23
+3.3V_ALWP on BOTTOM (solid shape): 263.77,14.64 263.77,13.42 264.35,13.42 264.35,12.93 263.8,12.93 263.8,12.23 264.35,12.23 264.35,11.73 263.8,11.73 263.8,10.96 264.35,10.96 264.35,10.14 264.33,10.13 263.14,8.12 263.11,5.8 263.09,5.71 263.01,5.67 260.09,5.67 259.93,5.83 259.93,6.05 259.93,6.05 259.93,14.26 260.39,14.71 263.69,14.71
+3.3V_LAN on TOP (solid shape): 315.02,91.38 315.02,88.9 314.9,88.78 313.61,88.78 313.45,88.95 313.45,91.37 313.69,91.62 314.79,91.62
+3.3V_LAN on TOP (solid shape): 279.58,80.68 279.92,80.68 280.05,80.55 280.05,79.99 279.89,79.83 279.01,79.83 278.9,79.94 277.29,79.94 277.18,80.05 277.18,80.9 277.3,81.02 279.23,81.02
+3.3V_LAN on BOTTOM (solid shape): 315.68,46.3 315.68,45.78 316.23,45.22 316.23,44.36 316.38,44.22 316.38,42.43 316.15,42.2 315.09,42.2 314.91,42.38 314.91,42.97 314.38,43.5 313.85,43.5 313.75,43.6 313.75,45.42 313.33,45.84 312.04,45.84 311.96,45.92 311.96,46.3 312.01,46.36 315.62,46.36
+3.3V_LAN on IN1 (solid shape): outline of 1437 points within 286.31,42.24 318.19,75.45
+3.3V_LAN on IN2 (solid shape): 314.94,91.44 314.94,89.12 314.68,88.86 313.72,88.86 313.47,89.1 313.47,91.43 313.67,91.63 314.75,91.63
