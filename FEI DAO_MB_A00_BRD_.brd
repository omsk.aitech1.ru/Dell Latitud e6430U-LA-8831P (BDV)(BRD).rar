# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_LAN on IN2 (solid shape): 313.78,64.69 313.78,64.06 313.44,63.72 311.58,63.72 311.46,63.85 311.46,64.84 311.61,64.99 313.49,64.99
+3.3V_LAN on IN2: 285.66,73.59 284.42,74.83 283.62,74.83 282.97,75.47 281.49,75.47 281.31,75.65 281.31,78.47 280,79.78 279.1,79.78 278.91,79.97 278.48,79.97 277.97,80.48 277.97,84.22 282.62,88.87 298.17,88.87 298.64,88.4 298.64,87.17 298.18,86.71 295.89,86.71 295.89,86.72 293.5,86.72 293.5,86.71 291.06,86.71 284.53,86.72 283.37,85.56 283.37,81.11 284.03,80.45 284.03,79.19 287.83,75.38 287.83,73.84 287.59,73.59
+3.3V_LAN_OUT on IN2: 288.47,75.04 287.42,76.1 287.42,76.74 287,77.16 285.86,77.16 285.62,77.4 285.62,78.48 285.86,78.72 289.35,78.72 289.77,79.14 289.77,84.01 289.29,84.49 287.24,84.49 287.06,84.67 287.06,86.08 287.33,86.34 292.24,86.34 292.63,86.34 292.66,86.34 293.58,86.34 293.6,86.34 294.4,86.34 294.43,86.34 295.17,86.34 295.2,86.34 295.59,86.34 296.08,85.85 296.08,84.02 296.07,83.99 296.03,83.97 295.67,83.59 296.03,83.21 296.08,83.21 296.08,79.42 295.92,79.25 294.96,79.25 294.95,79.24 292.99,79.24 292.88,79.13 292.88,75.38 292.54,75.04
+3.3V_M on TOP (solid shape): 281.64,70.05 281.64,69.26 281.35,68.98 281.35,68.55 281.24,68.44 280.57,68.44 280.38,68.63 280.38,69.12 280.73,69.47 280.73,70.01 280.93,70.22 281.48,70.22
+3.3V_M on TOP (solid shape): outline of 196 points within 179.41,40.88 193.32,48.55
+3.3V_M on BOTTOM (solid shape): 319.54,46.5 319.54,43.72 319.36,43.55 317.86,43.55 317.76,43.65 317.76,46.45 317.96,46.66 319.39,46.66
+3.3V_M on BOTTOM (solid shape): 199.43,25.62 199.76,25.62 200.95,24.43 204.14,24.43 204.27,24.29 204.27,23.43 204.21,23.36 202.91,23.36 202.52,22.96 200.4,22.96 199.07,24.29 197.85,24.29 197.69,24.44 197.69,25.45 197.86,25.62 199.43,25.62
+3.3V_M on BOTTOM (solid shape): 212.77,39.99 212.92,39.75 213.08,39.53 213.08,37.47 212.76,37.15 212.76,35.39 212.48,35.11 211.56,35.11 211.26,35.41 211.26,38.05 211.29,38.12 211.36,38.15 211.42,38.15 211.48,38.16 211.56,38.16 211.95,38.56 211.95,39.04 210.97,40.03 210.97,40.58 211.23,40.85 211.91,40.85
+3.3V_M on IN1 (solid shape): outline of 785 points within 154.88,87.6 170.46,109.55
+3.3V_M on IN2 (solid shape): 318.92,46.4 318.92,44.9 318.67,44.66 315.43,44.66 315.12,44.97 315.12,46.27 315.51,46.66 318.66,46.66
+3.3V_M on IN2 (solid shape): 161.89,18.52 161.89,17.91 161.75,17.77 161.69,17.76 161.38,17.76 161.37,17.75 161.34,17.75 160.94,17.35 160.94,15.96 160.78,15.8 159.9,15.8 159.6,16.1 159.6,16.44 159.61,16.48 159.62,16.53 159.63,16.58 159.63,16.64 159.63,16.67 159.63,16.69 159.63,16.75 159.62,16.8 159.61,16.85 159.6,16.89 159.6,18.2 160.08,18.2 160.09,18.14 160.1,18.09 160.12,18.03 160.14,17.98 160.18,17.94 160.22,17.9 160.26,17.87 160.31,17.84 160.37,17.83 160.42,17.82 160.48,17.81 160.53,17.82 160.59,17.83 160.64,17.86 160.69,17.88 160.73,17.92 160.77,17.96 160.8,18.01 160.82,18.06 160.84,18.11 160.84,18.17 160.84,18.22 160.84,18.28 160.82,18.33 160.8,18.38 160.77,18.43 160.73,18.47 160.69,18.51 160.64,18.54 160.59,18.56 160.53,18.57 160.48,18.58 160.42,18.58 160.37,18.56 160.31,18.55 160.26,18.52 160.22,18.49 160.18,18.45 160.14,18.41 160.12,18.36 160.1,18.31 160.09,18.25 160.08,18.2 159.6,18.2 159.6,19.05 159.86,19.32 161.09,19.32
+3.3V_M on IN2 (solid shape): outline of 97 points within 300.81,43.91 305.35,46.68
+3.3V_M on IN3 (solid shape): 167.81,88.73 167.81,87.44 167.7,87.32 166.19,87.32 166.01,87.5 166.01,88.62 166.29,88.9 167.65,88.9
+3.3V_M on IN3 (solid shape): 199.52,26.11 199.52,23.03 199.26,22.77 198.11,22.77 197.69,23.2 197.69,25.98 197.93,26.22 199.41,26.22
+3.3V_M on IN3 (solid shape): 301.04,69.16 301.04,67.01 300.91,66.89 299.98,66.89 299.92,66.95 299.92,69.11 300.18,69.38 300.82,69.38
+3.3V_M on IN3 (solid shape): 206.67,10.58 206.67,10.26 207.22,9.72 207.22,9.26 206.92,8.95 205.96,8.95 205.47,9.44 205.47,10.6 205.54,10.68 206.58,10.68
+3.3V_M on IN3 (solid shape): 302.52,47.24 302.52,44.24 302.2,43.91 301.12,43.91 300.81,44.22 300.81,47.14 301.07,47.4 302.36,47.4
+3.3V_M on IN3 (solid shape): 172,54.62 172,53.2 172.03,53.17 172.03,52.68 171.77,52.42 171.34,52.42 170.96,52.81 170.96,53.45 170.08,54.32 170.08,54.62 170.31,54.85 171.77,54.85
+3.3V_M on IN3 (solid shape): 195.07,42 195.07,41.78 194.48,41.18 194.23,41.18 194.07,41.35 193.26,41.35 193.14,41.23 192.65,41.23 192.07,41.81 192.07,42.3 192.27,42.5 194.57,42.5
+3.3V_M on IN3 (solid shape): 180.88,49.46 180.88,47.62 180.76,47.5 179.71,47.5 179.58,47.63 179.58,49.44 179.72,49.59 180.76,49.59
+3.3V_M on IN3 (solid shape): 212.18,39.91 212.18,39.47 211.78,39.08 211.33,39.08 210.63,39.78 210.03,39.78 209.25,40.56 209.94,41.24 209.94,41.25 210.83,41.25
+3.3V_M on IN4 (solid shape): 301.29,69 301.29,68.52 300.78,68.01 300.34,68.01 298.72,69.63 298.72,69.99 299.24,70.52 299.77,70.52
+3.3V_M on IN4 (solid shape): 281.69,72.06 281.69,69.66 281.49,69.45 280.88,69.45 280.65,69.68 280.65,72.01 280.85,72.21 281.54,72.21
+3.3V_PCIE_FLASH on TOP (solid shape): 267.18,22.88 267.18,21.93 266.67,21.43 263.54,21.43 263.46,21.51 263.46,22.22 263.62,22.37 265.21,22.37 265.84,23.01 267.05,23.01
+3.3V_PCIE_FLASH on TOP (solid shape): 260.16,29.81 260.16,28.4 260.1,28.34 254.3,28.34 252.75,26.79 244.63,26.79 244.6,26.82 243.54,26.82 243.02,27.34 243.02,29.19 243.37,29.55 248.45,29.55 249.44,28.55 251.55,28.55 252.78,29.79 258.98,29.79 259.04,29.84 260.12,29.84
+3.3V_PCIE_FLASH on TOP (solid shape): outline of 220 points within 234.6,41.13 260.17,45.62
+3.3V_PCIE_FLASH on BOTTOM (solid shape): 261.34,29.56 261.34,29 261.3,28.96 257.76,28.96 257.7,29.02 257.7,29.54 257.82,29.65 261.24,29.65
+3.3V_PCIE_FLASH on BOTTOM (solid shape): 238.18,46.32 238.18,44.84 237.93,44.59 235.68,44.59 235.53,44.73 235.53,46.04 235.66,46.16 236.4,46.16 236.71,46.47 238.03,46.47
+3.3V_PCIE_FLASH on BOTTOM (solid shape): 260.43,42.65 261.32,41.77 261.32,41.06 261.25,41 259.15,41 259.15,41 258.72,41 258.43,41.3 258.43,43.37 258.5,43.44 259.64,43.44
+3.3V_PCIE_FLASH on BOTTOM (solid shape): outline of 124 points within 243.02,16.37 269.65,29.54
+3.3V_PCIE_FLASH on IN3 (solid shape): 245.54,29.68 245.54,28.59 245.3,28.35 243.37,28.35 241.92,29.81 241.92,30.3 243.26,31.65 243.57,31.65
+3.3V_PCIE_FLASH on IN3 (solid shape): 243.91,42.21 243.91,38.21 243.81,38.11 241.89,38.11 241.69,38.31 241.69,42.1 241.99,42.4 243.72,42.4
+3.3V_PCIE_WWAN on TOP (solid shape): 308.63,37.74 308.63,36.54 310.07,35.11 310.07,33.72 312.97,30.82 314.44,30.82 314.48,30.77 314.48,30.11 314.34,29.97 311.33,29.97 306.53,34.77 306.53,37.73 306.69,37.88 308.49,37.88
+3.3V_PCIE_WWAN on TOP (solid shape): outline of 467 points within 273.6,32.27 282.05,45.01
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 276.51,44.54 276.51,41.89 276.36,41.74 275.1,41.74 274.83,42.01 274.83,44.51 274.99,44.66 276.38,44.66
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 300.99,43.49 300.99,41.37 300.75,41.13 299.28,41.13 299.09,41.32 299.09,43.57 299.28,43.76 300.72,43.76
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 308.51,37.74 308.51,34.34 308.26,34.09 305.14,34.09 304.97,34.26 304.97,37.55 305.4,37.98 308.27,37.98
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 281.72,35.16 281.72,33.08 281.22,32.58 281.22,31.58 281.14,31.5 280.56,31.5 280.26,31.2 278.42,31.2 278.22,31.39 278.22,33.23 278.35,33.36 280.16,33.36 280.37,33.57 280.37,35.19 280.41,35.23 281.65,35.23
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 288.42,44.84 288.42,44.02 288.28,43.88 288.2,43.88 288.13,43.88 287.85,43.88 287.71,43.74 287.71,41.89 287.56,41.74 287.25,41.74 287.09,41.9 287.09,45.02 287.17,45.09 288.17,45.09
+3.3V_PCIE_WWAN on IN1 (solid shape): outline of 1122 points within 275.23,35.17 301.44,45.07
+3.3V_PCIE_WWAN on IN2 (solid shape): 307.33,37.97 309.04,37.97 309.35,37.66 309.35,35.46 307.99,34.1 305.02,34.1 301.86,37.26 301.86,38.78 300.89,39.76 299.99,39.76 299.7,40.05 299.7,43.27 300.02,43.58 301.72,43.58
+3.3V_RUN on TOP (solid shape): 39.2,44.94 39.2,44.13 39.02,43.95 38.2,43.95 37.8,44.36 37.8,44.99 37.95,45.15 38.99,45.15
+3.3V_RUN on TOP (solid shape): 159.72,85.18 159.72,83.73 159.62,83.63 158.11,83.63 157.97,83.77 157.97,85.06 158.2,85.29 159.6,85.29
+3.3V_RUN on TOP (solid shape): 165.03,109.59 165.03,108.73 164.94,108.65 162.74,108.65 162.62,108.77 162.62,109.59 162.77,109.74 164.88,109.74
+3.3V_RUN on TOP (solid shape): 290.87,8.07 290.87,5.73 290.6,5.47 289.28,5.47 289.07,5.68 289.07,8.23 289.15,8.32 290.62,8.32
+3.3V_RUN on TOP (solid shape): 202.68,18.02 202.68,16.13 202.59,16.04 200.89,16.04 200.51,16.43 200.51,18 201.03,18.53 202.17,18.53
+3.3V_RUN on TOP (solid shape): 154.1,107.64 154.1,107.29 152.35,105.54 151.99,105.54 151.33,106.2 151.33,106.55 153.05,108.27 153.47,108.27
+3.3V_RUN on TOP (solid shape): 67.12,84.02 67.12,83.67 67.4,83.4 68.81,83.4 68.85,83.36 68.85,82.79 68.8,82.74 67.32,82.74 66.93,83.13 66.47,83.13 65.82,83.78 65.82,84.1 65.98,84.25 66.89,84.25
+3.3V_RUN on TOP (solid shape): 42.34,39.08 42.34,37.69 42.34,37.69 42.34,36.53 42.17,36.36 41.41,36.36 41.18,36.59 41.18,37.42 40.93,37.66 40.93,38.36 41.46,38.36 41.46,38.8 40.93,38.8 40.93,39.18 41.08,39.32 42.1,39.32
+3.3V_RUN on TOP (solid shape): 234.98,44.23 234.98,43.77 234.48,43.77 234.48,43.26 234.98,43.26 234.98,42.97 234.48,42.97 234.48,42.46 234.98,42.46 234.98,41.51 234.19,40.73 227.87,40.73 227.39,41.21 227.39,44.28 227.65,44.55 234.67,44.55
+3.3V_RUN on TOP (solid shape): 144.87,55.38 144.87,54.37 145.2,54.04 146.2,54.04 146.5,53.73 146.5,52.93 146.27,52.7 145.79,52.7 145.55,52.94 144.72,52.94 144.53,53.13 144.53,55.37 144.61,55.45 144.81,55.45
+3.3V_RUN on TOP (solid shape): 208.9,10.07 208.9,10.06 209.39,9.56 209.39,7.96 209.14,7.71 206.6,7.71 206.41,7.9 206.41,8.77 206.55,8.92 206.96,8.92 207.19,9.15 207.19,9.8 206.42,10.57 206.42,10.93 207.14,11.64 207.32,11.64
+3.3V_RUN on TOP (solid shape): 54.15,81.31 54.15,80.9 54.53,80.52 56.08,80.52 56.13,80.47 56.13,79.97 56.07,79.91 52.73,79.91 52.6,80.04 52.6,80.8 52.62,80.83 53.14,80.83 53.35,81.04 53.35,81.3 53.49,81.44 54.01,81.44
+3.3V_RUN on TOP (solid shape): outline of 846 points within 156.09,11.84 166.7,23.41
+3.3V_RUN on BOTTOM (solid shape): 230.35,50.06 230.35,41.74 229.96,41.36 226.47,41.36 226.03,41.81 226.03,50.21 226.18,50.36 230.05,50.36
+3.3V_RUN on BOTTOM (solid shape): 75.1,100.62 75.1,100.32 74.73,99.95 74.73,99.48 74.68,99.42 73.98,99.42 73.87,99.53 73.87,100.48 74.18,100.79 74.93,100.79
+3.3V_RUN on BOTTOM (solid shape): 75.14,91.23 75.14,90.83 74.01,89.7 73,89.7 72.71,89.99 72.71,90.31 73.86,91.47 74.9,91.47
+3.3V_RUN on BOTTOM (solid shape): 162.96,15.02 162.96,13.75 162.78,13.57 161.52,13.57 161.4,13.7 161.4,13.71 161.34,13.76 161.34,14.98 161.47,15.11 162.87,15.11
+3.3V_RUN on BOTTOM (solid shape): 54.03,81.26 56.14,81.26 56.22,81.17 56.22,80.94 56.14,80.86 54.16,80.86 54.02,80.71 54.02,80.36 53.88,80.22 53.27,80.22 53.19,80.3 53.19,81.25 53.39,81.45 53.84,81.45
+3.3V_RUN on BOTTOM (solid shape): 61.46,87.93 61.46,85.99 61.36,85.89 60.2,85.89 60.11,85.97 60.11,87.88 60.19,87.96 61.43,87.96
+3.3V_RUN on BOTTOM (solid shape): 155.08,107.1 155.08,106.6 154.51,106.03 153.79,106.03 153.7,106.04 153.61,106.03 152.53,106.03 152.39,106.17 152.39,106.43 153.37,107.41 154.77,107.41
+3.3V_RUN on BOTTOM (solid shape): 253.81,47.07 253.81,46.83 253.78,46.8 253.25,46.8 253.24,46.78 253.24,46.35 253.28,46.3 253.76,46.3 253.78,46.28 253.78,45.95 253.72,45.89 251.85,45.89 251.72,46.01 251.72,46.61 252.22,47.11 253.77,47.11
+3.3V_RUN on BOTTOM (solid shape): 66.96,87.14 66.96,84.6 67.25,84.31 69.12,84.31 69.21,84.23 69.21,83.92 69.15,83.86 67.1,83.86 66.93,83.69 65.85,83.69 65.74,83.8 65.74,87.13 65.94,87.34 66.77,87.34
+3.3V_RUN on BOTTOM (solid shape): 40.28,45.08 41.81,45.08 43.76,43.14 43.76,38.3 43.23,37.77 41.84,37.77 41.34,38.28 41.34,39.23 41.79,39.68 41.79,42.61 40.6,43.79 38.62,43.79 38.41,44.01 38.41,44.88 38.41,44.88 38.41,45.08 38.59,45.27 40.09,45.27
+3.3V_RUN on BOTTOM (solid shape): 162.85,35.48 162.88,35.47 162.99,35.28 163.16,35.21 163.18,35.21 163.32,35.08 163.32,34.6 163.19,34.47 162.9,34.47 162.34,33.92 161.89,33.92 161.79,34.01 161.78,34.03 161.78,34.06 161.76,34.23 161.65,34.36 161.65,34.6 161.86,34.82 161.86,34.97 162.09,35.2 162.11,35.21 162.14,35.22 162.34,35.26 162.45,35.44 162.47,35.47 162.5,35.48
+3.3V_RUN on BOTTOM (solid shape): outline of 893 points within 243.03,65.44 258.59,79.69
+3.3V_RUN on IN1 (solid shape): 75.15,100.68 75.15,98.83 74.96,98.64 73.96,98.64 73.8,98.8 73.8,100.65 73.98,100.83 75,100.83
+3.3V_RUN on IN1 (solid shape): 75.28,91.86 75.28,90.88 75.02,90.61 72.02,90.61 71.68,90.95 71.68,91.77 72.01,92.1 75.04,92.1
+3.3V_RUN on IN1 (solid shape): outline of 924 points within 257.93,61.27 275.06,67.02
+3.3V_RUN on VCC (solid shape): outline of 937 points within 64.02,14.56 287.08,109.88
+3.3V_RUN on IN2 (solid shape): 35.01,60.31 35.01,59.09 34.91,58.99 33.58,58.99 33.41,59.17 33.41,60.26 33.56,60.41 34.91,60.41
+3.3V_RUN on IN2 (solid shape): 53.93,81.34 53.93,80.17 53.83,80.07 52.38,80.07 52.25,80.2 52.25,81.32 52.46,81.52 53.75,81.52
+3.3V_RUN on IN2 (solid shape): 279.07,79.57 279.07,79.06 279.63,78.49 280.52,78.49 280.89,78.12 280.89,76.73 280.57,76.41 277.5,76.41 275.16,74.07 275.16,71.06 274.97,70.87 272.97,70.87 272.68,71.17 272.68,74.92 276.25,78.5 276.94,78.5 277.35,78.92 277.35,79.62 277.54,79.81 278.83,79.81
+3.3V_RUN on IN2 (solid shape): outline of 99 points within 161.29,12.98 166.45,14.37
+3.3V_RUN on IN2 (solid shape): outline of 202 points within 158.36,20.05 160.3,23.33
+3.3V_RUN on IN3 (solid shape): 252.48,73.41 252.3,73.24 250.66,73.24 250.15,73.74 250.15,79.18 252.48,79.18
+3.3V_RUN on IN3 (solid shape): 275.08,68.01 275.08,64.18 275.05,64.16 274.17,64.16 274.03,64.3 274.03,67.97 274.12,68.05 275.04,68.05
+3.3V_RUN on IN3 (solid shape): 275.11,53.34 275.11,51.61 274.87,51.37 274.24,51.37 274.05,51.55 274.05,53.39 274.18,53.52 274.93,53.52
+3.3V_RUN on IN3 (solid shape): 275.13,74.65 275.13,71.17 274.86,70.91 272.92,70.91 272.67,71.16 272.67,74.67 272.85,74.86 274.93,74.86
+3.3V_RUN on IN3 (solid shape): 67.43,85.03 67.43,83.94 67.22,83.73 65.87,83.73 64.45,85.15 58.46,85.15 57.33,84.02 57.33,82.83 54.67,80.17 53.34,80.17 52.99,80.53 52.99,81.3 53.38,81.7 54.24,81.7 55.76,83.21 55.76,85.02 57.26,86.52 65.95,86.52
+3.3V_RUN on IN3 (solid shape): 287.76,25.26 287.76,22.01 288.31,21.46 289.39,21.46 290.19,20.65 290.19,17.3 291.76,15.73 291.76,6.95 290.39,5.58 289.34,5.58 288.91,6.01 288.91,9.42 289.97,10.48 289.97,11.37 289.66,11.68 289.66,13.85 288.49,15.02 288.49,15.75 288.2,16.04 288.2,19.46 287.79,19.87 286.95,19.87 286.09,20.74 286.09,25.24 286.3,25.44 287.58,25.44
+3.3V_RUN on IN3 (solid shape): 249.16,56.54 249.16,54.3 248.96,54.09 248.7,54.09 248.42,54.38 247.59,54.38 247.39,54.17 246.74,54.17 246.67,54.24 246.67,54.4 246.33,54.91 245.94,54.43 245.94,54.27 245.85,54.17 245.19,54.17 245.07,54.29 245.07,56.56 245.33,56.81 248.89,56.81
+3.3V_RUN on IN3 (solid shape): outline of 813 points within 156.18,18 161.62,26.78
+3.3V_RUN on IN4 (solid shape): 39.44,45.88 39.44,45.64 39.44,45.64 39.44,44.17 39.06,43.79 38.71,43.79 38.07,44.43 38.07,46.08 38.44,46.45 38.87,46.45
+3.3V_RUN on IN4 (solid shape): 246.07,81.39 246.07,76.19 246.01,76.1 245.9,76.12 245.4,76.13 245.32,75.63 245.32,75.53 245.23,75.47 243.74,75.47 243.57,75.65 243.57,80.01 243.13,80.44 237.62,80.44 237.34,80.16 237.34,79.72 238.12,78.94 238.12,75.09 238.51,74.7 238.51,74.01 238.48,73.98 237.1,73.98 236.84,74.24 236.84,75.51 237.01,75.83 236.84,76.15 236.84,76.28 236.99,76.58 236.84,76.89 236.84,77.04 237.03,77.37 236.84,77.7 236.84,78.08 236.18,78.73 236.18,81.28 236.97,82.08 245.38,82.08
+3.3V_RUN on IN4 (solid shape): outline of 119 points within 278.4,19.78 315.71,27.82
+3.3V_RUN on IN4 (solid shape): outline of 149 points within 32.39,58.89 39.5,62.24
+3.3V_RUN on IN4 (solid shape): outline of 676 points within 293.67,51.09 301.05,66.08
+3.3V_RUN_CARD on TOP (solid shape): 295.34,18.12 295.34,16.18 295.25,16.09 293.42,16.09 293.3,16.22 293.3,18.09 293.53,18.32 295.13,18.32
+3.3V_RUN_CARD on TOP (solid shape): 282.26,11.84 282.26,10.77 283.07,9.96 283.07,8.58 283.03,8.54 281.62,8.54 281.57,8.59 281.57,10.3 281.59,10.33 281.62,10.45 281.6,10.57 281.76,10.72 281.97,10.93 281.97,11.83 282.04,11.9 282.2,11.9
+3.3V_RUN_CARD on BOTTOM (solid shape): 296.65,17.51 296.65,16.42 296.39,16.16 293.5,16.16 293.3,16.37 293.3,17.59 293.51,17.8 296.35,17.8
+3.3V_RUN_CARD on IN1 (solid shape): outline of 1003 points within 281.49,8.15 296.55,18.33
+3.3V_RUN_DVDD on TOP (solid shape): 38.85,39.68 40.01,39.68 40.79,38.9 40.79,38.68 40.8,38.67 41.33,38.67 41.33,38.67 41.33,38.49 40.83,38.49 40.8,38.49 40.77,38.46 40.77,38.04 40.01,38.04 40.01,38.36 40.01,38.36 40.01,38.49 39.91,38.59 39.81,38.78 39.63,38.88 39.62,38.89 39.55,38.96 38.53,38.96 38.26,38.69 38.26,38.25 38.21,38.2 37.57,38.2 37.24,38.54 34.39,38.54 34.37,38.56 34.37,38.77 34.41,38.82 36.54,38.82 37.58,39.86 38.68,39.86
+3.3V_RUN_DVDD on BOTTOM (solid shape): outline of 221 points within 36.54,34.1 40.68,39.81
+3.3V_RUN_TPM on TOP (solid shape): outline of 308 points within 258.52,48.17 273.53,55.48
+3.3V_RUN_TPM on BOTTOM (solid shape): 256.72,49.14 256.72,48.6 256.88,48.45 257.38,48.45 257.5,48.33 257.5,47.65 257.43,47.58 256.35,47.58 255.99,47.23 255.99,46.1 255.73,45.83 253.98,45.83 253.95,45.86 253.95,48.24 254.94,49.23 256.63,49.23
+3.3V_RUN_TPM on IN4 (solid shape): outline of 284 points within 254.69,47.74 265.86,55.33
+3.3V_RUN_VCC_CLKF33 on IN1 (solid shape): outline of 2093 points within 163.11,34.72 175.44,41.5
+3.3V_SB3V on BOTTOM (solid shape): 259.42,49.8 261.74,49.8 261.77,49.77 261.77,49.41 261.74,49.39 258.92,49.39 258.73,49.58 256.06,49.58 255.99,49.65 255.99,50.14 256.05,50.19 259.03,50.19
+3.3V_TP on TOP (solid shape): 214.91,14.88 214.91,6.56 214.8,6.44 213.88,6.44 213.77,6.55 213.77,14.75 214.03,15.01 214.79,15.01
+3.3V_WLAN on TOP (solid shape): outline of 212 points within 235.9,51.55 243.31,68.81
+3.3V_WLAN on BOTTOM (solid shape): 242.72,68.57 242.72,68.14 242.51,67.92 242.51,66.05 242.35,65.89 241.45,65.89 241.15,66.19 241.15,68.52 241.43,68.81 242.49,68.81
+3.3V_WLAN on BOTTOM (solid shape): 254.54,69.79 254.54,68.68 253.72,67.86 253.72,66.06 253.55,65.89 253.25,65.89 253.08,66.06 253.08,67.96 252.93,68.12 252.93,69.82 253.23,70.12 254.21,70.12
+3.3V_WLAN on BOTTOM (solid shape): 247.71,59.61 247.71,57.72 247.71,57.72 247.71,57.6 248,57.31 248,56.64 247.9,56.54 247.9,55.71 247.87,55.68 246.21,55.68 246.04,55.86 246.04,56.31 246.02,56.33 246.02,57.46 246.27,57.71 246.27,59.66 246.41,59.8 247.52,59.8
+3.3V_WLAN on BOTTOM (solid shape): 265.77,67.73 265.77,66.23 265.77,66.22 265.8,65.86 266.11,65.69 266.14,65.69 266.6,65.23 266.6,63.98 266.52,63.9 265.47,63.9 265.38,63.99 265.38,64.6 265.09,64.89 265.09,67.73 265.28,67.93 265.58,67.93
+3.3V_WLAN on BOTTOM (solid shape): 244.69,53.37 246.35,53.37 246.65,53.06 246.65,49.97 245.64,48.95 242.14,48.95 241.74,49.35 241.74,50.79 241.27,51.27 239.55,51.27 239.06,51.76 239.06,53.44 242.13,53.44 242.13,53.44 242.19,53.47 242.25,53.41 242.27,53.38 242.3,53.33 242.34,53.29 242.38,53.25 242.43,53.22 242.48,53.2 242.54,53.19 242.59,53.18 242.65,53.19 242.7,53.2 242.76,53.22 242.81,53.24 242.85,53.28 242.89,53.32 242.92,53.36 242.95,53.41 242.97,53.46 242.98,53.52 242.98,53.58 242.98,53.63 242.96,53.69 242.94,53.74 242.91,53.79 242.88,53.83 242.84,53.87 242.79,53.9 242.76,53.91 242.47,54.2 242.13,54.2 242.13,54.25 241.37,54.25 241.37,53.44 239.06,53.44 239.06,54.13 239.36,54.43 240.36,54.43 240.57,54.63 243.43,54.63
+3.3V_WLAN on IN1 (solid shape): outline of 245 points within 240.04,51.16 247.85,58.37
+3.3V_WLAN on IN4 (solid shape): 255.58,68.69 255.58,67.15 254.89,66.45 252.11,66.45 251.96,66.61 251.96,68.12 252.29,68.46 252.29,69.18 252.72,69.62 254.65,69.62
+3.3V_WLAN on IN4 (solid shape): 242.88,68.43 242.88,66.19 242.59,65.89 240.91,65.89 240.35,65.33 240.35,63.86 238.68,62.2 238.68,61.36 238.11,60.78 236.24,60.78 236.04,60.98 236.04,63.4 237.06,64.43 237.06,67.12 238.73,68.79 242.52,68.79
+3.3V_WLAN on IN4 (solid shape): outline of 311 points within 264.47,64.34 271,68.01
+3.3VDDH on TOP (solid shape): 282.82,11.78 283.17,11.78 285.05,9.9 285.05,9.48 285.4,9.13 286.46,9.13 286.57,9.02 286.57,8.11 286.63,8.05 287.61,8.05 287.8,8.25 288.57,8.25 288.65,8.16 288.65,5.99 288.44,5.78 285.7,5.78 285.04,6.44 285.04,8.22 284.74,8.52 283.44,8.52 283.37,8.58 283.37,9.94 282.47,10.85 282.47,11.81 282.55,11.9 282.71,11.9
+3.3VDDH on IN2 (solid shape): 287.33,10.57 287.33,6.91 287.14,6.71 285.26,6.71 285.08,6.89 285.08,7.41 283.36,9.13 283.36,10 282.82,10.54 282.82,11.46 283.21,11.85 286.06,11.85
+5V_ALW on TOP (solid shape): 165.61,67.6 165.61,66.44 165.47,66.29 164.91,66.29 164.73,66.47 164.73,67.58 164.88,67.74 165.47,67.74
+5V_ALW on TOP (solid shape): 149.34,105.73 149.34,103.87 149.26,103.79 148.17,103.79 148.08,103.88 148.08,105.72 148.26,105.9 149.16,105.9
+5V_ALW on TOP (solid shape): 40.23,69.24 40.23,68.22 38.89,66.89 38.89,65.81 38.83,65.75 38.77,65.75 38.7,65.81 38.7,67.27 39.21,67.78 39.21,69.11 39.46,69.36 40.1,69.36
+5V_ALW on TOP (solid shape): 20.22,43.88 20.22,42.45 20.91,41.76 20.91,40.99 20.7,40.78 19.03,40.78 18.88,40.93 18.88,42.16 19.16,42.44 19.16,43.86 19.29,44 20.1,44
+5V_ALW on TOP (solid shape): 166.74,62.36 166.74,61.06 166.73,61.06 166.73,60.66 166.31,60.23 165.53,60.23 165.32,60.43 165.32,61.35 165.58,61.61 165.58,62.41 165.64,62.46 166.63,62.46
+5V_ALW on TOP (solid shape): 158.23,76.74 158.23,76.12 157.08,74.97 156.48,74.97 156.35,75.09 156.35,75.91 157.36,76.92 158.06,76.92
+5V_ALW on TOP (solid shape): 240.74,7 240.74,6.2 242.53,4.41 244.15,4.41 245.16,3.39 248.27,3.39 248.64,3.02 253.71,3.02 254.15,3.46 254.16,3.45 255.55,4.85 260.51,4.85 261.08,4.28 261.08,2.18 260.89,1.99 238.82,1.99 238.6,2.22 238.6,6.88 238.86,7.14 240.6,7.14
+5V_ALW on TOP (solid shape): outline of 493 points within 302.38,48.75 307.63,66.38
+5V_ALW on BOTTOM (solid shape): 165.42,68.49 165.42,66.44 165.3,66.32 165,66.32 164.81,66.51 164.81,67.15 164.41,67.56 164.41,68.51 164.46,68.56 165.35,68.56
+5V_ALW on BOTTOM (solid shape): 167.61,62.67 167.61,61.46 166.39,60.24 165.38,60.24 165.25,60.36 165.25,61.49 166.52,62.75 167.53,62.75
+5V_ALW on BOTTOM (solid shape): 109.88,107.32 109.88,106.72 109.78,106.62 109.72,106.62 109.58,106.64 109.44,106.6 108.82,106.6 108.69,106.73 108.69,107.68 108.81,107.79 109.4,107.79
+5V_ALW on BOTTOM (solid shape): 195.75,17.16 195.75,11.36 195.34,10.96 192.46,10.96 192.16,11.26 192.16,17.03 192.16,17.04 192.16,17.36 192,17.52 191.26,17.52 191.08,17.7 191.08,18.86 191.28,19.06 193.85,19.06
+5V_ALW on BOTTOM (solid shape): 20.94,43.86 20.94,41.04 20.7,40.8 18.98,40.8 18.87,40.91 18.87,42.33 18.65,42.55 18.65,43.65 18.71,43.71 18.74,43.74 19.11,43.74 19.37,44 20.8,44
+5V_ALW on BOTTOM (solid shape): 221.49,6.27 221.49,5.63 220.99,5.63 220.99,4.93 221.49,4.93 221.49,4.43 220.99,4.43 220.99,3.73 221.49,3.73 221.49,2.1 221.32,1.93 218.29,1.93 218.13,2.09 218.13,5.02 219.5,6.39 221.38,6.39
+5V_ALW on BOTTOM (solid shape): 305.33,52.03 306.88,52.03 306.99,51.92 306.99,51.33 306.86,51.2 305.71,51.2 305.28,50.77 305.28,50.19 305.14,50.06 304.1,50.06 303.03,48.98 302.52,48.98 302.29,49.21 302.29,52.15 302.51,52.36 304.99,52.36
+5V_ALW on BOTTOM (solid shape): 242.42,5.76 242.42,4.81 242.83,4.4 244.16,4.4 245.19,3.37 248.31,3.37 248.7,2.99 253.7,2.99 255.55,4.85 260.51,4.85 261.08,4.28 261.08,2.1 260.89,1.92 239.19,1.92 239.17,1.93 238.8,1.93 238.63,2.1 238.63,5.26 239.24,5.86 242.31,5.86
+5V_ALW on IN1 (solid shape): 42.47,61.63 42.47,60.69 42.37,60.59 40.8,60.59 40.47,60.92 40.47,62.04 40.59,62.16 41.94,62.16
+5V_ALW on IN1 (solid shape): 41.58,71.78 41.58,69 41.58,68.99 41.55,68.84 41.58,68.7 41.58,68.69 41.58,68.65 41.48,68.55 40.05,68.55 39.65,68.95 39.65,71.63 40.04,72.01 41.35,72.01
+5V_ALW on IN1 (solid shape): 109.99,107.39 109.99,106.77 109.86,106.64 109.45,106.64 108.21,105.4 106.38,105.4 106.24,105.54 106.24,106.42 106.35,106.53 106.96,106.53 107.88,106.53 108.86,107.52 109.86,107.52
+5V_ALW on VCC (solid shape): outline of 256 points within 19.59,1.92 325.52,62.32
+5V_ALW on IN2 (solid shape): 149.33,105.73 149.33,104.29 149.21,104.16 148.21,104.16 148.08,104.29 148.08,105.72 148.27,105.9 149.16,105.9
+5V_ALW on IN2 (solid shape): 109.81,107.93 109.81,107.48 109.94,107.35 109.94,106.82 109.81,106.69 108.79,106.69 108.64,106.84 108.64,107.92 108.73,108.01 109.73,108.01
+5V_ALW on IN2 (solid shape): 305.02,8.34 305.02,2.94 304,1.92 290.13,1.92 290.13,1.96 289.57,2.58 288.82,2.24 286.69,2.24 286.68,2.23 271.96,2.23 271.64,1.92 238.8,1.92 238.6,2.12 238.6,5.23 239.24,5.86 241,5.86 242.48,4.39 244.2,4.39 245.21,3.38 248.27,3.38 248.63,3.02 253.83,3.02 255.63,4.83 257.38,4.83 258.03,5.48 263.81,5.48 265.27,4.02 269.01,4.02 269.74,4.75 290.37,4.75 290.81,4.31 296.8,4.31 301.34,8.85 304.51,8.85
+5V_ALW on IN4 (solid shape): 305.02,8.34 305.02,2.94 304.25,2.17 290.07,2.17 289.44,2.6 288.79,2.19 273.72,2.19 273.45,1.92 257.8,1.92 257.59,2.13 257.59,5.04 258.03,5.48 263.81,5.48 264.98,4.31 266.8,4.31 267.01,4.11 268.03,4.11 268.23,4.31 271.77,4.31 272.26,4.79 288.99,4.79 289.47,4.31 296.8,4.31 301.34,8.85 304.51,8.85
+5V_ALW on IN4 (solid shape): outline of 127 points within 159.57,60.24 165.99,67.64
+5V_ALW_PCH on BOTTOM (solid shape): 192.02,24.89 192.02,23.27 192.44,22.84 192.44,19.74 192.28,19.58 191.61,19.58 191.42,19.77 191.42,21.8 190.94,22.29 190.94,24.9 191.13,25.09 191.81,25.09
+5V_ALW_PCH on BOTTOM (solid shape): 190.44,36.28 191.47,35.24 191.47,33.41 191.09,33.03 189.18,33.03 189.1,33.12 189.1,34.39 188.53,34.96 189.37,34.96 189.38,34.9 189.39,34.85 189.41,34.8 189.44,34.75 189.47,34.71 189.51,34.67 189.56,34.63 189.61,34.61 189.66,34.59 189.71,34.58 189.77,34.58 189.83,34.58 189.88,34.6 189.93,34.62 189.98,34.65 190.02,34.69 190.06,34.73 190.09,34.77 190.11,34.82 190.13,34.88 190.14,34.93 190.14,34.99 190.13,35.04 190.11,35.1 190.09,35.15 190.06,35.19 190.02,35.24 189.98,35.27 189.93,35.3 189.88,35.32 189.83,35.34 189.77,35.34 189.71,35.34 189.66,35.33 189.61,35.31 189.56,35.29 189.51,35.25 189.47,35.22 189.44,35.17 189.41,35.12 189.39,35.07 189.38,35.02 189.37,34.96 188.53,34.96 188.22,35.27 185.96,35.27 185.74,35.48 185.74,36.78 185.9,36.94 189.77,36.94
+5V_ALW_PCH on IN3 (solid shape): outline of 106 points within 190.54,22.15 194.77,34.68
+5V_ALWP on BOTTOM (solid shape): 227.54,9.89 227.54,6.77 226.96,6.18 226.96,2.25 226.72,2.02 222.14,2.02 221.67,2.49 221.67,3.85 221.66,3.87 221.12,3.87 221.12,4.31 221.62,4.31 221.62,4.33 221.64,4.33 221.64,5.03 221.62,5.03 221.62,5.06 221.12,5.06 221.12,5.51 221.63,5.51 221.65,5.53 221.65,7.1 223.58,9.03 223.58,9.99 224.07,10.48 226.95,10.48
+5V_RUN on TOP (solid shape): 44.54,33.74 44.54,31.65 44.42,31.52 43.16,31.52 42.73,31.95 42.73,33.58 43.08,33.93 44.35,33.93
+5V_RUN on TOP (solid shape): 88.19,12.4 88.19,10.89 88.01,10.7 86.64,10.7 86.46,10.88 86.46,11.86 85.7,12.63 85.7,13.2 86.2,13.69 86.91,13.69
+5V_RUN on TOP (solid shape): 169.92,103.91 169.92,101.43 169.56,101.08 168.88,101.08 168.64,101.32 168.64,103.88 168.79,104.04 169.79,104.04
+5V_RUN on TOP (solid shape): 22.73,28.4 22.73,27.46 22.67,27.4 20.78,27.4 20.21,26.84 19.04,26.84 18.83,27.04 18.83,28.13 19.17,28.47 22.65,28.47
+5V_RUN on TOP (solid shape): outline of 104 points within 168.46,63.43 171.62,66.69
+5V_RUN on TOP (solid shape): outline of 409 points within 182.57,20.7 190.33,32.64
+5V_RUN on BOTTOM (solid shape): 169.51,103.35 169.51,102.13 169.3,101.91 168.8,101.91 168.46,102.26 168.46,103.31 168.62,103.48 169.39,103.48
+5V_RUN on BOTTOM (solid shape): 47.57,52.05 47.57,51.02 47.41,50.85 45.74,50.85 45.52,51.07 45.52,51.76 45.95,52.2 47.43,52.2
+5V_RUN on BOTTOM (solid shape): 11.44,62.25 11.44,61.29 11.3,61.15 9.77,61.15 9.63,61.29 9.63,62.32 9.73,62.42 11.27,62.42
+5V_RUN on BOTTOM (solid shape): 163.51,96.96 163.51,95.64 162.3,94.43 162.01,94.43 161.85,94.59 161.85,95.37 162.43,95.95 162.43,97.14 162.54,97.25 163.21,97.25
+5V_RUN on BOTTOM (solid shape): 189.73,13.88 189.73,9.44 189.49,9.19 185.64,9.19 185.48,9.35 185.48,10.51 185.17,10.82 183.46,10.82 183.24,11.04 183.24,13.19 184.23,14.18 189.43,14.18
+5V_RUN on BOTTOM (solid shape): 28.19,52.6 28.19,52.26 27.68,51.75 27.57,51.75 27.45,51.86 27.45,51.86 27.11,52.21 25.11,52.21 24.87,52.45 24.87,52.88 25.2,53.21 27.58,53.21
+5V_RUN on BOTTOM (solid shape): 83.05,95.82 85.38,95.82 85.57,95.63 85.57,95.28 85.58,95.28 85.58,94.85 85.58,94.85 85.58,94.3 85.37,94.09 84.3,94.09 83.89,94.5 82.06,94.5 81.35,95.21 81.35,96.04 81.58,96.27 82.6,96.27
+5V_RUN on VCC (solid shape): outline of 937 points within 43.97,7.45 187.86,91.91
+5V_RUN on IN2 (solid shape): 12.13,62.24 12.13,61.27 11.99,61.14 10.86,61.14 10.78,61.22 10.78,62.27 10.88,62.37 12.01,62.37
+5V_RUN on IN2 (solid shape): 26.28,53.88 26.28,52.34 25.99,52.05 24.75,52.05 24.46,52.34 24.46,53.85 25.1,54.49 25.67,54.49
+5V_RUN on IN2 (solid shape): 85.56,95.08 85.56,94.34 85.29,94.07 84.24,94.07 83.83,94.48 83.39,94.48 82.5,93.6 82.5,92.57 77.04,87.11 74.74,87.11 74.47,87.38 74.47,88.72 74.74,88.99 76.86,88.99 80.97,93.1 80.97,94.37 82.12,95.52 85.13,95.52
+5V_RUN on IN3 (solid shape): 21.68,29.83 21.68,28.14 21.2,27.66 20.8,27.66 20.07,26.92 19.04,26.92 18.81,27.15 18.81,29.13 19.7,30.02 21.49,30.02
+5V_RUN on IN3 (solid shape): 187.91,21.51 187.91,19.5 187.83,19.25 187.91,19.01 187.91,11.94 187.52,11.54 186.25,11.54 186.12,11.67 186.12,16.56 186.43,16.86 186.43,21.45 186.75,21.77 187.66,21.77
+5V_RUN on IN3 (solid shape): 44.54,33.68 44.54,31.57 44.35,31.38 44,31.38 43.29,30.67 43.29,29.65 43.09,29.45 40.56,29.45 40.36,29.65 40.36,31.59 41.99,31.59 41.99,31.54 42.01,31.48 42.03,31.43 42.05,31.38 42.09,31.34 42.13,31.3 42.17,31.27 42.22,31.24 42.28,31.22 42.33,31.21 42.39,31.21 42.44,31.22 42.5,31.23 42.55,31.25 42.6,31.28 42.64,31.32 42.68,31.36 42.71,31.41 42.73,31.46 42.75,31.51 42.75,31.57 42.75,31.62 42.75,31.68 42.73,31.73 42.71,31.78 42.68,31.83 42.64,31.87 42.6,31.9 42.55,31.93 42.5,31.96 42.44,31.97 42.39,31.98 42.33,31.97 42.28,31.96 42.22,31.95 42.17,31.92 42.13,31.89 42.09,31.85 42.05,31.8 42.03,31.76 42.01,31.7 41.99,31.65 41.99,31.59 40.36,31.59 40.36,32.37 41.95,33.95 44.27,33.95
+5V_RUN on IN4 (solid shape): 169.49,103.25 169.49,102.12 168.69,101.32 168.69,98.65 165.37,95.34 163.59,95.34 162.71,94.45 162.06,94.45 161.92,94.59 161.92,95.53 163.02,96.63 164.84,96.63 167.48,99.27 167.48,102.12 168.76,103.4 169.33,103.4
+5V_USB_CHG_PWR on BOTTOM (solid shape): 314.49,54.64 316.22,54.64 316.47,54.9 316.68,54.9 317.15,54.42 317.15,53.78 316.36,52.99 314.76,52.99 314.58,52.81 314.58,51.6 314.52,51.54 311.87,51.54 311.68,51.72 309.16,51.72 309.08,51.8 309.08,51.94 309.17,52.03 310.14,52.03 313.12,55.01 314.12,55.01
+5V_USB_PWR on TOP (solid shape): 19.87,53.67 19.87,51.48 20.3,51.05 24.1,51.05 24.3,50.85 24.3,48.71 24.13,48.55 20.36,48.55 20.22,48.41 20.22,46.89 20.1,46.76 18.15,46.76 17.38,47.53 17.38,50.35 21.51,50.35 21.51,50.3 21.52,50.24 21.54,50.19 21.57,50.14 21.6,50.1 21.64,50.06 21.69,50.02 21.74,50 21.79,49.98 21.85,49.97 21.9,49.97 21.96,49.98 22.01,49.99 22.06,50.01 22.11,50.04 22.15,50.08 22.19,50.12 22.22,50.16 22.24,50.21 22.26,50.27 22.27,50.32 22.27,50.38 22.26,50.43 22.24,50.49 22.22,50.54 22.19,50.58 22.15,50.63 22.11,50.66 22.06,50.69 22.01,50.71 21.96,50.73 21.9,50.73 21.85,50.73 21.79,50.72 21.74,50.7 21.69,50.68 21.64,50.65 21.6,50.61 21.57,50.56 21.54,50.51 21.52,50.46 21.51,50.41 21.51,50.35 17.38,50.35 17.38,53.65 17.62,53.89 19.64,53.89
+5V_USB_PWR on BOTTOM (solid shape): 19.97,54.7 19.97,52.11 19.81,51.96 16.83,51.96 16.39,52.4 15.24,52.4 14.76,52.87 14.76,53.3 16.29,54.82 19.84,54.82
+DVDD_CORE on TOP (solid shape): 37.78,32.48 37.78,31.62 37.73,31.56 37.11,31.56 36.12,32.56 36.12,32.89 34.37,34.63 34.37,34.73 34.45,34.81 35.45,34.81
+V1.05S_VCCPP_B+ on TOP (solid shape): 124.88,7.12 129.32,7.12 129.7,6.74 129.7,6.2 129.18,6.2 129.18,5.69 129.7,5.69 129.7,5.4 129.18,5.4 129.18,4.89 129.7,4.89 129.7,3.87 129.52,3.7 121.49,3.7 121.45,3.74 121.45,7.64 121.69,7.88 124.12,7.88
+V1.05SP_B+ on TOP (solid shape): 153.81,72.47 154.32,72.47 154.32,72.98 154.61,72.98 154.61,72.47 155.12,72.47 155.12,72.98 155.67,72.98 155.86,72.79 155.86,62.06 156.18,61.74 157.26,61.74 157.49,61.51 157.49,59.45 157.31,59.27 154.91,59.27 154.27,58.63 153.1,58.63 153.01,58.72 153.01,62.14 153.26,62.38 153.26,62.52 153.26,64.53 153.26,64.53 153.26,72.86 153.38,72.98 153.81,72.98
+VCC_4022 on BOTTOM (solid shape): 158.23,107.53 158.23,106.91 157.82,106.51 157.82,105.02 157.74,104.94 157.62,104.94 157.55,105.01 157.55,105.84 157.26,106.13 156.35,106.13 155.7,106.77 155.7,107.5 155.79,107.59 158.17,107.59
+VCC_CORE on TOP (solid shape): outline of 952 points within 124.13,45.64 145.25,64.24
+VCC_CORE on BOTTOM (solid shape): outline of 1541 points within 124.12,46.75 145.95,67.17
+VCC_CORE on IN1 (solid shape): outline of 978 points within 124.43,46.76 144.98,55.83
+VCC_CORE on VCC (solid shape): 140.88,69.45 140.87,69.42 140.96,69.03 141.35,68.94 141.38,68.95 144.76,65.56 144.77,65.54 144.8,65.44 144.87,65.35 144.9,65.28 144.87,65.2 144.76,64.89 144.94,64.61 144.94,52.67 144.89,52.47 144.94,52.28 144.94,47.82 143.56,46.44 137,46.44 136.99,46.48 136.62,46.76 136.25,46.48 136.24,46.44 127.9,46.44 126.77,47.57 126.77,47.58 126.56,47.84 126.23,47.84 126.22,47.84 124.96,47.84 124.95,47.84 124.78,47.88 124.62,47.84 124.61,47.84 124.54,47.84 124.11,48.27 124.11,56.5 124.47,56.86 125.99,56.86 126,56.85 126.28,56.85 126.75,56.39 126.75,56.37 127.03,56.09 127.42,56.22 129.55,56.22 130.56,57.24 131.96,57.24 132.18,57.46 132.21,57.45 132.56,57.55 132.66,57.9 132.66,57.93 133.25,58.53 133.25,71.23 133.99,71.97 138.36,71.97
+VCC_CORE on IN4 (solid shape): outline of 1329 points within 124.18,46.43 145.17,62.1
+VCC_GFXCORE on TOP (solid shape): outline of 2082 points within 111.77,57.26 127.16,87.65
+VCC_GFXCORE on BOTTOM (solid shape): outline of 1563 points within 116.37,57.11 128.21,88.18
+VCC_GFXCORE on IN1 (solid shape): outline of 1052 points within 116.55,56.92 125.88,77.92
+VCC_GFXCORE on VCC (solid shape): 135.41,83.93 135.41,72.97 134.92,72.48 133.78,72.48 132.75,71.44 132.75,59.86 132.71,59.85 132.42,59.48 132.71,59.11 132.75,59.1 132.75,58.74 132.2,58.19 132.19,58.19 132.02,58.09 131.92,57.92 131.92,57.91 131.75,57.74 130.35,57.74 129.34,56.74 127.38,56.74 127.23,56.83 127.06,56.84 127.03,56.83 126.51,57.36 120.41,57.36 120.17,57.6 120.17,61.15 119.41,61.91 119.41,65.39 119.79,65.77 119.79,66.4 120.93,67.54 120.93,72.33 116.49,76.77 116.49,82.11 114.84,83.76 114.84,84.07 114.85,84.09 115.52,85.21 115.77,86.49 115.77,86.51 116.6,87.34 132.01,87.34
+VCC_GFXCORE on IN2 (solid shape): outline of 3078 points within 115.73,57.55 128.62,87.61
+VCC_GFXCORE on IN4 (solid shape): outline of 1129 points within 116.13,57.46 128.05,78.21
+VCC_PWR_SRC on TOP (solid shape): 118.52,88.38 118.96,88.38 118.96,88.92 119.28,88.92 119.44,88.77 119.44,88.07 117.35,85.99 117.35,85.43 117.23,85.3 116.02,85.3 115.8,85.52 115.8,88.14 116.11,88.44 117.23,88.44 117.71,88.92 118.52,88.92
+VCC_PWR_SRC on BOTTOM (solid shape): 153.15,76.31 154.09,76.31 154.22,76.18 154.22,74.99 154.41,74.8 156.72,74.8 156.81,74.89 157.16,74.89 157.19,74.93 160,74.93 160.03,74.9 160.03,72.54 159.98,72.49 156.42,72.49 155.02,71.09 155.02,69.75 154.6,69.33 154.6,67.27 154.56,67.23 151.87,67.23 151.82,67.28 151.82,68.65 150.56,69.91 150.48,70 150.48,73.98 149.94,74.51 149.94,75.74 149.79,75.89 149,75.89 148.98,75.92 148.98,76.53 149.05,76.6 152.87,76.6
+VCC_PWR_SRC on IN3 (solid shape): 117.65,88.22 117.65,83.8 117.46,83.61 115.91,83.61 115.78,83.74 115.78,88.17 116.05,88.44 117.43,88.44
+VCC_PWR_SRC on IN3 (solid shape): 135.27,70.77 136.99,70.77 137.17,70.6 137.17,68.69 136.95,68.48 133.87,68.48 132.61,69.74 131.92,69.74 131.81,69.86 131.81,71.57 132.06,71.82 134.22,71.82
+VCC_PWR_SRC on IN4 (solid shape): 152.56,74.7 152.56,72.6 152.37,72.41 150.59,72.41 150.14,72.86 150.14,74.7 150.34,74.89 152.37,74.89
+VCC_PWR_SRC on IN4 (solid shape): 137.52,69.91 137.52,69.5 138.97,68.06 138.97,67.78 137.79,66.6 137.58,66.6 136.47,67.71 136.47,68.09 135.72,68.84 135.72,69.76 136.1,70.14 137.29,70.14
+VCC_SA on TOP (solid shape): outline of 1948 points within 122.41,30.24 136.66,47.87
+VCC_SA on BOTTOM (solid shape): outline of 123 points within 127.4,14.01 138.21,24.88
+VCC_SA on BOTTOM (solid shape): outline of 512 points within 122.31,42.27 128.27,47.28
+VCC_SA on VCC (solid shape): 124.46,47.33 124.78,47.14 125.1,47.33 126.06,47.33 126.23,47.16 126.46,47.13 126.49,47.13 127.69,45.93 131.95,45.93 131.96,45.91 132.3,45.69 132.63,45.91 132.64,45.93 137.59,45.93 137.95,45.57 137.95,31.44 137.81,31.29 137.76,31.09 137.81,30.89 137.95,30.74 137.95,30.46 140.01,28.4 140.01,28.4 140.09,28.29 140.2,28.21 140.2,28.21 141.51,26.9 141.51,21.02 139.88,19.39 139.87,19.39 139.73,19.3 139.64,19.16 139.63,19.15 138.56,18.07 133.73,18.07 133.03,18.07 128.43,22.67 128.43,35.27 128.52,35.51 128.43,35.76 128.43,37.8 128.46,37.81 128.71,37.96 128.78,38.25 128.58,38.53 128.24,38.53 128.2,38.51 126.09,40.63 126.09,40.65 125.99,40.92 125.71,41.03 125.69,41.03 124.6,42.12 124.34,42.12 124.33,42.13 124.22,42.14 124.12,42.13 124.11,42.12 123.96,42.12 123.6,42.48 123.6,44.01 123.25,44.35 123.26,44.38 123.18,44.78 122.78,44.86 122.76,44.85 122.59,45.02 122.59,46.97 122.95,47.33
+VCC_SA on IN2 (solid shape): outline of 2637 points within 122.7,17.9 138.37,46.94
+VCC_SA on IN3 (solid shape): outline of 1333 points within 122.26,33.41 137.16,47.11
+VCCDIFFCLKN on TOP (solid shape): 157.72,35.45 157.8,35.46 158.2,35.46 158.29,35.37 158.29,35.28 158.92,34.65 158.92,34.3 158.85,34.23 157.69,34.23 157.46,34.45 157.46,35.44 157.49,35.46 157.63,35.46
+VCCSA_BT on BOTTOM (solid shape): 141.32,12.72 141.32,10.32 142.2,9.44 142.77,9.44 142.87,9.35 142.87,9.23 142.79,9.15 141.48,9.15 140.34,10.3 140.34,12.7 140.44,12.8 141.24,12.8
+VCCSA_BT_1 on BOTTOM (solid shape): 139.86,12.78 139.86,11.9 139.82,11.86 138.44,11.86 138.34,11.96 138.34,12.69 138.52,12.87 139.77,12.87
+VCCSA_P on BOTTOM (solid shape): outline of 116 points within 127.13,5.98 135.87,15.95
+VCCSA_PHASE on BOTTOM (solid shape): 138.13,12.4 138.13,10.6 139.02,9.71 140.29,9.71 141.1,8.9 142.8,8.9 142.86,8.85 142.86,6.74 142.75,6.64 141.28,6.64 140.59,5.95 137.21,5.95 137.04,6.12 137.04,12.41 137.2,12.56 137.97,12.56
+VCCSA_PWR_SRC on BOTTOM (solid shape): 150.96,9.05 150.96,8.17 149.94,7.14 149.21,7.14 149.21,6.56 149.76,6.56 149.76,6.27 149.21,6.27 149.21,5.76 149.76,5.76 149.76,5.47 149.21,5.47 149.21,4.89 149.97,4.89 149.97,3.57 149.79,3.39 149.05,3.39 148.85,3.59 148.42,3.59 148.24,3.41 147.66,3.41 147.22,3.85 147.22,5.24 145.75,6.72 145.75,7.86 145.83,7.93 147.19,7.93 147.67,8.41 147.67,9.02 147.77,9.12 150.89,9.12
+VDDA_AVDD on TOP (solid shape): 27.36,39.3 28.3,39.3 28.38,39.23 28.38,39.1 28.3,39.02 26.83,39.02 26.19,39.66 26.19,39.86 26.37,40.04 26.62,40.04
+VDDA_AVDD on TOP (solid shape): 29.27,34.38 29.27,31.81 28.85,31.39 28.85,30.89 28.78,30.81 27.1,30.81 25.96,29.68 24.35,29.68 23.55,28.87 20.95,28.87 20.82,29 20.82,30.73 20.97,30.88 22.45,30.88 23.55,31.99 25.76,31.99 25.97,32.2 28.25,32.2 28.8,32.75 28.8,33.24 29,33.43 29,34.38 29.03,34.41 29.24,34.41
+VDDA_AVDD on IN4 (solid shape): outline of 223 points within 24.57,30.21 28.97,41.23
+VDDA_PVDD on TOP (solid shape): 41.86,33.41 41.86,31.57 41.77,31.47 40.14,29.85 40.14,29.15 40.1,29.11 37.8,29.11 37.36,29.54 37.04,29.54 36.08,30.5 34.94,30.5 34.73,30.71 33.61,30.71 33.46,30.85 33.46,31.7 33.68,31.92 36.21,31.92 37.1,31.03 39.71,31.03 40.67,31.99 40.67,31.99 40.91,32.23 40.91,33.37 41,33.46 41.81,33.46
+VDDA_PVDD on IN3 (solid shape): 34.84,31.48 34.84,30.84 34.67,30.67 33.97,30.67 32.9,29.6 29.5,29.6 29.31,29.79 29.31,30.59 29.61,30.89 32.3,30.89 33.15,31.74 34.58,31.74
+VDDH_SD on TOP (solid shape): 279.25,11.83 279.25,10.65 278.69,10.1 278.69,8.55 278.58,8.43 275.67,8.43 275.58,8.52 275.58,9.09 275.7,9.21 276.69,9.21 276.93,9.45 276.93,9.8 279.03,11.9 279.18,11.9
GND on TOP (solid shape): 210,23.9 203,23.9 203,35.9 210,35.9
GND on TOP (solid shape): 242,29 230,29 230,36 242,36
GND on TOP (solid shape): 16.44,44.12 16.44,42.24 16.2,42 14.05,42 13.94,42.11 13.94,44.17 14.12,44.35 16.2,44.35
GND on TOP (solid shape): 33.74,45.98 33.74,44.76 33.51,44.54 32.31,44.54 32.19,44.66 32.19,45.93 32.42,46.16 33.56,46.16
GND on TOP (solid shape): 26.61,19.8 26.61,17.83 26.28,17.5 23.68,17.5 23.32,17.86 23.32,18.75 24.44,19.87 26.54,19.87
GND on TOP (solid shape): 86.65,49.89 86.65,46.34 86.4,46.09 83.98,46.09 83.72,46.34 83.72,49.79 83.88,49.95 86.6,49.95
GND on TOP (solid shape): 265.02,15.68 265.02,12.98 264.83,12.79 263.16,12.79 263.05,12.9 263.05,15.6 263.34,15.9 264.8,15.9
GND on TOP (solid shape): 88.58,39.5 88.58,36.23 88.5,36.15 81.09,36.15 80.97,36.27 80.97,39.29 81.62,39.94 88.14,39.94
GND on TOP (solid shape): 280.82,8.09 280.82,7.07 280.71,6.96 276.96,6.96 276.81,7.11 276.81,8.14 276.88,8.2 280.71,8.2
GND on TOP (solid shape): 19.87,25.93 19.87,20.26 19.8,20.19 17.82,20.19 17.56,20.46 17.56,25.94 17.79,26.17 19.63,26.17
GND on TOP (solid shape): 31.53,65.94 31.53,57.81 31.18,57.46 29.97,57.46 29.69,57.74 29.69,62.82 29.56,62.95 28.61,62.95 28.48,63.08 28.48,66 28.61,66.13 31.34,66.13
GND on TOP (solid shape): 217.2,25.89 217.2,23.45 215.93,22.18 215.93,20.68 215.56,20.3 213.3,20.3 213.09,20.51 213.09,23.03 215.19,25.13 215.19,25.91 215.41,26.13 216.97,26.13
GND on TOP (solid shape): 36.7,25.89 36.7,25.02 36.56,24.88 36.06,24.88 36.06,24.3 35.88,24.3 35.88,24.88 33.99,24.88 33.84,25.03 33.84,25.92 33.99,26.07 36.51,26.07
GND on TOP (solid shape): 129.32,83.44 129.32,80.45 128.99,80.13 128.58,80.13 128.58,80.12 127.83,80.12 127.71,80.25 127.71,83.29 127.98,83.57 129.19,83.57
GND on TOP (solid shape): 30.41,19.67 31.86,19.67 31.91,19.62 31.91,19.47 31.83,19.39 30.61,19.39 30.54,19.31 29.27,19.31 29.14,19.44 29.14,19.69 29.27,19.82 30.26,19.82
GND on TOP (solid shape): 49.81,3.45 49.81,1.67 49.56,1.42 48.67,1.42 48.29,1.8 48.29,2.94 47.91,3.32 44.42,3.32 43.91,2.82 43.91,1.8 43.59,1.48 41.81,1.48 41.56,1.74 41.56,4.21 42.32,4.98 48.29,4.98
GND on TOP (solid shape): 129.01,10.35 129.01,9.66 129.11,9.56 130,9.56 130.08,9.64 130.08,10.37 130.13,10.42 131.37,10.42 131.48,10.32 131.48,9.33 131.3,9.15 128.48,9.15 128.38,9.26 128.38,10.35 128.45,10.42 128.94,10.42
GND on TOP (solid shape): 223.44,26.71 223.44,25.65 223.71,25.38 223.71,24.23 223.61,24.12 222.98,24.12 222.89,24.22 222.89,25.36 222.54,25.71 222.54,26.05 222.28,26.31 222.28,26.9 222.31,26.93 223.22,26.93
GND on TOP (solid shape): 38.24,68.36 38.24,68.07 38.19,67.9 38.24,67.74 38.24,67.57 38.11,67.43 38.11,65.8 38.05,65.75 37.95,65.75 37.9,65.8 37.9,66.76 37.65,67.02 37.65,68.37 37.81,68.54 38.07,68.54
GND on TOP (solid shape): 258.19,16.78 258.19,16.21 257.96,15.97 257.96,13.57 257.61,13.23 257.61,12.48 257.51,12.38 255.99,12.38 255.89,12.48 255.89,13.34 255.63,13.6 254.68,13.6 254.48,13.8 254.48,16.22 254.47,16.22 254.47,16.55 254.76,16.84 258.13,16.84
GND on TOP (solid shape): 27.5,28.39 27.5,27.35 27.7,27.15 27.7,23.03 27.36,22.69 26.66,22.69 26.58,22.77 26.58,23.64 26.79,23.85 26.79,26.98 26.6,27.18 25.68,27.18 25.61,27.25 25.61,28.39 25.68,28.47 27.43,28.47
GND on TOP (solid shape): 118.42,4.28 118.42,2.73 118.65,2.5 119.85,2.5 120.24,2.89 121.06,2.89 121.49,3.32 127.5,3.32 127.67,3.16 127.67,2.11 127.54,1.98 114.68,1.98 114.56,2.1 114.56,4.19 114.76,4.39 118.31,4.39
GND on TOP (solid shape): 143.79,86.38 143.79,85.81 143.92,85.68 144.68,85.68 144.81,85.81 144.81,86.16 144.93,86.28 146.41,86.28 146.47,86.21 146.47,85.68 146.72,85.43 147.55,85.43 147.85,85.73 147.85,86.21 147.89,86.26 148.57,86.26 148.62,86.2 148.62,83.78 147.41,82.57 142.59,82.57 142.14,83.02 142.14,86.34 142.3,86.49 143.68,86.49
GND on TOP (solid shape): 153.09,64.4 153.09,62.53 152.62,62.06 152.62,58.46 153.4,57.68 154.17,57.68 154.86,56.99 154.86,55.2 154.71,55.05 152.01,55.05 151.81,55.25 151.81,56.52 151.01,57.32 151.01,62.67 151.01,62.68 151.01,63.29 152.19,64.47 153.02,64.47
GND on TOP (solid shape): 324.3,32.01 324.3,3.36 324.05,3.11 317.81,3.11 317.66,3.26 317.66,4.07 317.96,4.38 322.31,4.38 322.64,4.71 322.64,29.8 322.18,30.26 320.35,30.26 319.99,30.62 319.99,32.57 320.17,32.75 323.56,32.75
GND on TOP (solid shape): 64,4.1 64,1.4 63.38,1.18 62.92,0.73 62.79,0.6 62.63,0.52 61.43,0.52 61.22,0.73 61.22,3.99 61.53,4.3 63.8,4.3
GND on TOP (solid shape): 40.82,4.43 40.82,0.51 39.49,0.51 39.26,0.57 39.08,0.73 38.78,1.07 38.39,1.3 38.39,1.31 38.21,1.49 38.21,4.19 38.6,4.59 40.66,4.59
GND on TOP (solid shape): 133.52,95.39 134.25,95.39 134.4,95.24 134.4,93.99 133.63,93.22 133.63,91.65 135.22,90.07 135.22,83.12 134.95,82.84 133.47,82.84 133.29,83.03 133.29,86.12 133.51,86.35 133.51,89.66 132.17,91 132.17,92.36 131.99,92.54 130.03,92.54 128.59,93.98 127.58,93.98 126.17,95.4 124.91,95.4 124.06,96.25 124.06,97.25 124.38,97.58 131.33,97.58
GND on TOP (solid shape): 119.42,84.02 119.42,81.34 118.56,80.48 115.93,80.48 115.72,80.69 115.72,81.16 115.33,81.54 114.15,81.54 114.15,81.55 111.94,81.55 111.71,81.77 111.71,82.78 112,82.78 113,82.92 113.93,83.31 113.95,83.33 114.5,83.73 114.96,84.22 119.22,84.22
GND on TOP (solid shape): 39.09,65.62 39.25,65.62 39.27,65.59 39.27,63.92 39.25,63.89 38.59,63.89 38.51,63.81 38.51,62.77 38.49,62.75 38.36,62.75 38.31,62.8 38.31,63.79 38.21,63.89 37.8,63.89 37.72,63.81 37.72,62.82 37.65,62.75 37.57,62.75 37.5,62.82 37.5,63.83 37.51,63.85 37.55,63.89 37.55,64.65 37.55,64.65 37.55,64.86 37.55,64.86 37.55,65.06 37.55,65.24 37.55,65.46 37.55,65.59 37.57,65.62 38.71,65.62
GND on TOP (solid shape): 22.2,75.88 22.28,75.84 22.46,74.72 23.39,74.24 23.43,74.23 23.44,74.19 23.44,72.51 22.93,71.99 20.36,71.99 19.84,72.51 19.84,75.64 20.08,75.88
GND on TOP (solid shape): 245.65,110.83 245.65,105.4 245.64,105.4 245.64,103.49 245.18,102.36 246.15,101.61 247.19,101.61 247.55,101.26 247.55,98.71 247.18,98.35 239.87,98.35 237.04,101.17 237.04,110.95 237.17,111.07 245.41,111.07
GND on TOP (solid shape): 86.98,111.53 86.98,109.93 86.61,109.56 86.61,105.67 86.14,105.19 86.14,102.22 85.63,101.71 82.93,101.71 82.52,102.12 82.52,104.69 83.85,104.7 84.83,105.43 84.37,106.56 84.36,111.52 84.36,111.61 84.56,111.82 86.69,111.82
GND on TOP (solid shape): 328.39,69.58 328.39,65.97 328.08,65.67 320.72,65.67 319.05,66.07 318.07,64.65 318.07,64.22 315.6,64.22 315.45,64.37 315.45,64.82 319.52,68.89 320.55,68.89 321.25,68.99 321.83,69.38 321.83,69.89 328.07,69.89
GND on TOP (solid shape): 321.59,92.66 325.04,96.35 326.96,91.69 326.96,91.08 327.68,90.37 330.38,90.37 330.47,90.28 330.47,88.07 330.31,87.91 323.14,87.91 321.23,89.82 317.82,89.82 316.73,88.74 315.57,88.74 315.37,88.93 315.37,91.35 315.59,91.56 321.09,91.56 321.59,92.06
GND on TOP (solid shape): 8.2,89.08 11.53,89.97 13.5,87.15 11.68,84.39 8.42,84.99 4.92,84.99 4.57,85.34 4.57,86.87 4.47,86.97 1.23,86.97 1.11,87.08 1.11,88.92 1.27,89.08
GND on TOP (solid shape): 318.5,51.37 318.5,50.25 318.7,50.05 322.31,50.05 323.02,50.76 326.93,50.76 327.56,50.12 327.56,46.8 325.5,44.73 325.5,38.99 323.5,33.75 321.5,38.99 321.5,48.29 320.91,48.88 317.15,48.88 315.55,50.48 315.55,51.39 315.93,51.78 318.09,51.78
GND on TOP (solid shape): 269.9,112.04 273.16,112.67 275,109.9 273.23,107.16 270.01,107.66 269.27,107.66 267.94,106.32 267.94,98.48 267.7,98.25 264.89,98.25 264.47,98.67 264.47,101.22 264.86,101.61 265.85,101.61 266.82,102.36 266.36,103.49 266.07,103.78 266.07,110.68 267.43,112.04
GND on TOP (solid shape): 62.95,106.92 59.73,110.77 64.55,112.18 64.55,112.18 67.56,112.18 67.62,112.04 67.64,111.9 67.64,111.82 67.67,111.8 67.67,107.8 67.64,107.77 67.64,106.57 67.18,105.44 68.15,104.69 69.19,104.69 69.5,104.38 69.5,102.38 69.49,102.38 69.49,102.12 69.09,101.72 68.4,101.72 67.4,102.72 65.61,102.72 64.36,103.97 64.36,106.21 63.64,106.92
GND on TOP (solid shape): 8.35,68.29 8.35,58.96 8.88,58.43 13.61,58.43 13.87,58.18 15.51,58.18 16.1,57.59 16.1,56.03 15.84,55.78 13.93,55.78 13.93,56.25 12.95,57.67 11.28,57.27 7.73,57.27 7.22,56.75 5.01,56.75 4.86,56.91 4.86,56.92 4.53,57.25 4.53,58.8 2.05,61.39 4.52,64 4.52,65.72 4.68,65.88 5.1,65.88 6.46,66.72 6.31,68.31 6.31,68.5 6.42,68.6 8.03,68.6
GND on TOP (solid shape): outline of 266 points within 171.53,50.65 179.52,58.65
GND on BOTTOM (solid shape): 246.64,11.4 241.64,11.4 241.64,14.4 246.64,14.4
GND on BOTTOM (solid shape): 21.94,56.35 21.94,52.41 21.75,52.22 20.86,52.22 20.48,52.6 20.48,56.35 20.54,56.41 21.87,56.41
GND on BOTTOM (solid shape): 63.8,11.93 63.8,9.82 63.7,9.72 62.34,9.72 62.25,9.81 62.25,11.99 62.47,12.21 63.52,12.21
GND on BOTTOM (solid shape): 130.96,85.18 130.96,83.83 130.83,83.7 128.79,83.7 128.55,83.93 128.55,85.17 128.83,85.45 130.7,85.45
GND on BOTTOM (solid shape): 138.64,3.63 138.64,2.52 138.59,2.47 137.95,2.47 137.8,2.62 137.8,3.65 137.93,3.78 138.5,3.78
GND on BOTTOM (solid shape): 139.54,31.08 139.54,29.33 139.48,29.26 136.8,29.26 136.74,29.32 136.74,31.13 137,31.39 139.22,31.39
GND on BOTTOM (solid shape): 140.62,51.95 140.62,50.85 140.48,50.71 136.24,50.71 135.93,51.01 135.93,51.72 136.25,52.04 140.53,52.04
GND on BOTTOM (solid shape): 154.59,65.94 154.59,64.48 154.46,64.35 151.35,64.35 151.22,64.47 151.22,65.94 151.35,66.06 154.46,66.06
GND on BOTTOM (solid shape): 242.09,94.96 242.09,92.35 241.9,92.16 239.87,92.16 239.74,92.29 239.74,95.02 240,95.27 241.78,95.27
GND on BOTTOM (solid shape): 308.2,42.59 308.2,39.91 307.79,39.51 305.14,39.51 304.88,39.77 304.88,42.52 305.1,42.73 308.06,42.73
GND on BOTTOM (solid shape): 160.1,80.99 160.1,78.7 159.96,78.56 156.67,78.56 156.41,78.82 156.41,80.95 156.62,81.16 159.93,81.16
GND on BOTTOM (solid shape): 259.03,15.61 259.03,11.59 258.87,11.42 257.35,11.42 257.21,11.56 257.21,15.33 257.98,16.1 258.55,16.1
GND on BOTTOM (solid shape): 140.71,59.48 140.71,58.56 140.48,58.33 136.24,58.33 135.93,58.63 135.93,59.34 136.25,59.66 140.53,59.66
GND on BOTTOM (solid shape): 140.71,55.67 140.71,54.75 140.48,54.52 136.24,54.52 135.93,54.82 135.93,55.53 136.25,55.85 140.53,55.85
