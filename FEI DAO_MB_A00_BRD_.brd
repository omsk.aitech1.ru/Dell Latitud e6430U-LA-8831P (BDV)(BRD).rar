# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 159.97,65.95 159.97,64.46 159.86,64.35 155.17,64.35 155,64.52 155,65.87 155.19,66.06 159.86,66.06
GND on BOTTOM (solid shape): 163.1,55.59 163.1,52.92 162.87,52.69 162.87,52.31 162.79,52.23 161.63,52.23 161.42,52.44 161.42,55.46 161.65,55.69 163,55.69
GND on BOTTOM (solid shape): 163.35,109.21 163.35,107.96 163.25,107.86 156.59,107.86 156.53,107.91 156.53,109.39 156.69,109.55 163.01,109.55
GND on BOTTOM (solid shape): 229.5,5.69 230.16,5.69 230.36,5.5 230.36,2.5 229.94,2.08 227.73,2.08 227.48,2.33 227.48,5.38 227.79,5.7 229.49,5.7
GND on BOTTOM (solid shape): 252.82,51.91 252.82,49.88 251.82,48.88 248.57,48.88 248.41,49.04 248.41,51.83 248.67,52.09 252.63,52.09
GND on BOTTOM (solid shape): 140.59,48.06 140.59,47.21 140.33,46.95 136.27,46.95 135.98,47.23 135.98,47.68 135.99,47.69 135.99,47.85 136.32,48.18 140.48,48.18
GND on BOTTOM (solid shape): 110.2,13.39 110.2,10.69 110.01,10.5 108.36,10.5 108.17,10.69 108.17,11.5 108.17,11.51 108.17,11.74 108.07,11.84 108.07,13.37 108.28,13.58 110.01,13.58
GND on BOTTOM (solid shape): 141.91,21.1 141.91,19.35 142.01,19.25 142.01,18.3 141.89,18.18 139.86,18.18 139.74,18.3 139.74,18.92 139.65,19.01 139.65,21.04 139.8,21.2 141.81,21.2
GND on BOTTOM (solid shape): 289.15,83.7 289.15,79.36 289.09,79.29 284.74,79.29 284.66,79.37 284.66,83.69 284.72,83.74 289.1,83.74
GND on BOTTOM (solid shape): 16.35,44.6 16.35,42.76 15.84,42.25 13.84,42.25 13.9,42.5 13.93,42.75 13.93,44.59 14.25,44.92 16.03,44.92
GND on BOTTOM (solid shape): 144.12,39.59 144.12,39.53 144.11,39.52 144.11,36.97 144.06,36.91 142.4,36.91 142.08,37.24 142.08,39.35 142.41,39.68 144.03,39.68
GND on BOTTOM (solid shape): 159.88,107.27 159.88,106.46 159.72,106.31 159.03,106.31 158.82,106.1 158.82,105 158.77,104.94 158.12,104.94 158.06,105.01 158.06,106.43 158.98,107.35 159.8,107.35
GND on BOTTOM (solid shape): 126.32,27.23 126.32,25 125.71,24.38 124.63,24.38 124.53,24.48 124.53,26.01 124.43,26.11 124.43,26.45 124.53,26.55 124.53,28.09 124.6,28.15 125.4,28.15
GND on BOTTOM (solid shape): 97.9,9.3 97.9,7.62 98.25,7.28 98.25,4.35 98.22,4.32 96.48,4.32 96.44,4.36 96.44,7.23 96.84,7.63 96.84,9.31 97.11,9.59 97.61,9.59
GND on BOTTOM (solid shape): 100.64,10.23 100.64,10.18 100.64,8.82 100.47,8.66 99.21,8.66 99.1,8.77 99.1,10.11 99.28,10.3 100.57,10.3
GND on BOTTOM (solid shape): 49.81,3.45 49.81,1.67 49.56,1.42 48.67,1.42 48.29,1.8 48.29,2.94 47.91,3.32 44.42,3.32 43.91,2.82 43.91,1.8 43.59,1.48 41.81,1.48 41.56,1.74 41.56,4.21 42.32,4.98 48.29,4.98
GND on BOTTOM (solid shape): 318.5,51.37 318.5,50.25 318.7,50.05 322.31,50.05 323.02,50.76 326.93,50.76 327.56,50.12 327.56,46.8 325.5,44.73 325.5,40.45 321.5,40.45 321.5,48.29 320.91,48.88 317.15,48.88 315.55,50.48 315.55,51.39 315.93,51.78 318.09,51.78
GND on BOTTOM (solid shape): 238.65,14.17 238.65,10.78 238.59,10.72 237.61,10.72 237.39,10.95 237.39,12.65 237.04,12.99 236.19,12.99 235.39,12.19 235.39,11.14 235.27,11.02 233.57,11.02 233.36,11.24 233.36,14.34 233.72,14.7 238.12,14.7
GND on BOTTOM (solid shape): 24.87,15.38 24.87,12.2 24.8,12.13 23.71,12.13 22.77,12.57 21.73,12.65 21.48,12.9 21.48,15.04 21.9,15.46 24.79,15.46
GND on BOTTOM (solid shape): 150.99,10.76 150.99,9.69 150.81,9.51 147.87,9.51 147.49,9.13 147.49,8.42 147.24,8.16 145.78,8.16 145.6,7.99 145.6,6.77 145.57,6.74 143.06,6.74 143.03,6.77 143.03,9.31 143.08,9.36 145.78,9.36 147.37,10.95 150.79,10.95
GND on BOTTOM (solid shape): 133.09,95.82 133.1,95.82 133.52,95.39 134.24,95.39 134.4,95.23 134.4,94 132.81,92.42 132.56,92.17 132.56,91.51 132.39,91.34 129.57,91.34 129.37,91.53 129.37,94.27 129,94.64 127.6,94.64 127.21,94.25 127.21,91.74 127.04,91.57 124.24,91.57 124.05,91.75 124.05,97.25 124.38,97.58 131.33,97.58
GND on BOTTOM (solid shape): 324.3,32.01 324.3,3.36 324.05,3.11 317.81,3.11 317.66,3.26 317.66,4.07 317.96,4.38 322.31,4.38 322.64,4.71 322.64,29.8 322.18,30.26 320.35,30.26 319.99,30.62 319.99,32.57 320.17,32.75 323.56,32.75
GND on BOTTOM (solid shape): 108,11.54 108,10.4 106.99,10.19 106.06,9.77 106.05,9.76 105.1,9.76 105,9.87 105,11.27 105.05,11.33 105.78,11.33 105.89,11.22 106.43,11.22 106.93,11.73 107.81,11.73
GND on BOTTOM (solid shape): 64,4.1 64,1.4 63.38,1.18 62.92,0.73 62.79,0.6 62.63,0.52 61.43,0.52 61.22,0.73 61.22,3.99 61.53,4.3 63.8,4.3
GND on BOTTOM (solid shape): 40.82,4.43 40.82,0.51 39.49,0.51 39.26,0.57 39.08,0.73 38.78,1.07 38.39,1.3 38.39,1.31 38.21,1.49 38.21,4.19 38.6,4.59 40.66,4.59
GND on BOTTOM (solid shape): 115.55,84.06 115.55,83.41 115.25,83.11 115.25,80.24 115.72,79.76 115.72,78.65 115.42,78.35 111.95,78.35 111.47,78.83 111.47,82.67 111.58,82.78 112,82.78 112.68,82.85 113.34,83.03 114.19,83.48 114.89,84.14 114.98,84.22 115.39,84.22
GND on BOTTOM (solid shape): 154.4,78.5 154.4,76.92 154.15,76.66 153.43,76.66 153.3,76.78 148.69,76.78 147.92,77.56 146.59,77.56 146.18,77.15 146.18,74.95 146.06,74.83 142.14,74.83 141.95,75.01 141.95,76.22 140.75,77.43 140.07,77.43 139.62,77.88 139.62,79.17 139.78,79.33 141.36,79.33 141.58,79.11 141.58,78.29 141.81,78.06 145,78.06 145.7,78.76 151.68,78.76 152.32,79.4 153.5,79.4
GND on BOTTOM (solid shape): 245.65,110.84 245.65,105.4 245.64,105.4 245.64,103.49 245.18,102.36 246.15,101.61 247.19,101.61 247.55,101.26 247.55,98.71 247.18,98.35 239.87,98.35 237.04,101.17 237.04,111 237.13,111.08 245.4,111.08
GND on BOTTOM (solid shape): 86.98,111.53 86.98,109.93 86.61,109.56 86.61,105.67 86.14,105.19 86.14,102.22 85.63,101.71 82.93,101.71 82.52,102.12 82.52,104.48 82.73,104.69 83.85,104.7 84.83,105.43 84.37,106.56 84.36,111.52 84.36,111.61 84.56,111.82 86.69,111.82
GND on BOTTOM (solid shape): 169.38,37.78 169.57,37.62 169.81,37.68 170.08,37.68 170.25,37.5 170.25,37.32 169.99,37.06 169.87,37.06 169.53,37.16 169.36,36.85 169.21,36.7 168.77,36.7 168.63,36.84 168.63,37.36 168.89,37.62 168.91,37.62 169.09,37.65 169.2,37.78
GND on BOTTOM (solid shape): 167.92,41.84 167.92,41.58 167.84,41.38 167.93,41.18 167.93,40.9 167.89,40.86 167.86,40.8 167.81,40.75 167.74,40.75 167.67,40.76 167.61,40.76 167.56,40.76 167.41,40.76 167.21,40.55 167.05,40.55 166.96,40.64 166.96,40.98 167.09,41.11 167.14,41.11 167.4,41.29 167.31,41.6 167.31,41.84 167.41,41.94 167.82,41.94
GND on BOTTOM (solid shape): 131.61,55.61 131.63,55.6 131.64,55.59 131.82,55.42 132.51,55.42 132.62,55.31 132.62,55.01 132.52,54.91 131.69,54.91 131.57,54.83 131.5,54.69 131.49,54.67 131.48,54.65 131.28,54.65 131.24,54.68 131.13,54.69 131,54.65 130.97,54.65 130.95,54.64 130.63,54.64 130.61,54.65 129.96,54.65 129.6,54.29 129.56,54.27 129.42,54.27 129.01,54.68 129.01,54.98 129.12,55.09 129.29,55.09 129.53,55.01 129.76,55.1 129.77,55.1 130.13,55.47 130.42,55.47 130.56,55.61
GND on BOTTOM (solid shape): 165.5,20.09 165.72,20.09 165.94,19.88 165.94,19.73 165.86,19.51 165.99,19.31 165.99,19.22 165.66,18.9 165.49,19.07 165.49,19.45 165.43,19.51 165.43,19.54 165.32,19.77 165.07,19.81 164.98,19.82 164.94,19.9 164.92,19.98 164.88,20.05 164.86,20.13 164.9,20.2 164.98,20.27 165.04,20.37 165.06,20.39 165.21,20.39
GND on BOTTOM (solid shape): 328.39,69.59 328.39,65.97 328.08,65.67 320.72,65.67 319.05,66.07 318.07,64.65 318.07,64.22 315.6,64.22 315.45,64.37 315.45,64.82 319.52,68.89 320.55,68.89 321.25,68.99 321.83,69.38 321.83,69.89 328.09,69.89
GND on BOTTOM (solid shape): 163.02,23.8 163.02,23.68 162.86,23.52 162.86,23.33 162.9,23.29 162.9,22.84 162.93,22.63 163.09,22.5 163.14,22.49 163.2,22.49 163.34,22.35 163.35,22.28 163.35,22.03 163.26,21.94 162.99,21.94 162.89,22.11 162.72,22.21 162.65,22.22 162.58,22.22 162.54,22.22 162.47,22.2 162.44,22.25 162.39,22.31 162.33,22.37 162.33,22.53 162.44,22.68 162.44,22.86 162.35,22.99 162.21,23.05 162.19,23.05 161.99,23.24 161.99,23.48 162.48,23.96 162.86,23.96
GND on BOTTOM (solid shape): 131.98,53.38 131.98,53.19 131.74,52.95 131.73,52.95 131.59,52.88 131.52,52.74 131.51,52.73 131.09,52.31 131.09,52.25 130.94,52.04 130.68,52.1 130.64,52.14 129.2,52.14 129.04,52.3 129.04,52.69 129.44,53.09 129.66,53.09 129.67,53.08 129.83,53.03 129.99,53.08 130,53.09 130.17,53.09 130.38,52.88 130.59,52.88 130.61,52.87 130.99,52.8 131.22,53.12 131.22,53.14 131.37,53.29 131.38,53.29 131.57,53.48 131.87,53.48
GND on BOTTOM (solid shape): 165.33,22.21 165.33,22.18 165.27,22.09 165.24,22 165.23,21.93 165.22,21.86 165.22,21.84 165.16,21.78 165.1,21.77 165.06,21.76 165.02,21.74 164.98,21.72 164.93,21.66 164.89,21.6 164.85,21.55 164.78,21.53 164.52,21.5 164.35,21.32 164.33,21.29 164.08,21.29 163.98,21.39 163.98,21.48 164,21.5 164.08,21.62 164.11,21.76 164.13,21.82 164.19,21.85 164.31,21.89 164.4,21.98 164.44,21.98 164.54,22.08 164.6,22.06 164.85,22.1 165.03,22.28 165.04,22.31 165.22,22.31
GND on BOTTOM (solid shape): 130.38,50.63 130.45,50.6 130.48,50.53 130.7,50.22 131.08,50.27 131.12,50.28 131.15,50.26 131.55,49.87 131.61,49.87 131.62,49.85 131.72,49.81 131.83,49.8 131.85,49.8 131.87,49.79 131.92,49.74 131.92,49.69 132.02,49.58 132.47,49.58 132.62,49.43 132.62,49.2 132.5,49.08 132.26,49.08 132.13,49.2 131.5,49.2 131.41,49.29 131.41,49.3 131.24,49.49 130.99,49.47 130.98,49.46 130.7,49.46 130.34,49.81 129.99,49.81 129.98,49.82 129.83,49.87 129.67,49.82 129.66,49.81 129.49,49.81 129.01,50.3 129.01,50.44 129.13,50.56 129.13,50.58 129.17,50.63
GND on BOTTOM (solid shape): 161.35,24.28 161.35,24.02 161.29,23.89 161.29,23.74 161.28,23.69 161.23,23.68 161.23,23.68 161.08,23.66 160.97,23.57 160.96,23.56 160.91,23.39 160.97,23.23 160.97,23.05 160.83,22.91 160.44,22.91 160.34,23.01 160.2,23.05 160.13,23.07 160.1,23.13 160.07,23.23 160.02,23.31 159.99,23.38 160.02,23.45 160.1,23.56 160.14,23.7 160.17,23.75 160.22,23.78 160.34,23.82 160.43,23.9 160.47,23.99 160.48,24.09 160.48,24.11 160.74,24.38 161.25,24.38
GND on BOTTOM (solid shape): 321.59,92.66 325.04,96.35 326.96,91.69 326.96,91.08 327.68,90.37 330.38,90.37 330.47,90.28 330.47,88.07 330.31,87.91 323.14,87.91 321.23,89.82 317.82,89.82 316.73,88.74 315.57,88.74 315.37,88.93 315.37,91.35 315.59,91.56 321.09,91.56 321.59,92.06
GND on BOTTOM (solid shape): 8.2,89.08 11.53,89.97 13.5,87.15 11.68,84.39 8.42,84.99 4.92,84.99 4.54,85.37 4.54,86.7 4.29,86.95 1.24,86.95 1.11,87.08 1.11,88.92 1.27,89.08
GND on BOTTOM (solid shape): 321.5,42.25 323.5,44.25 325.5,42.25 325.5,38.99 326.32,35.73 323.6,33.75 323.6,33.75 310.4,33.75 310.4,39.95 321.5,39.95
GND on BOTTOM (solid shape): outline of 105 points within 121.89,11.19 129.88,21.42
GND on BOTTOM (solid shape): 162.89,21.24 162.89,20.9 162.93,20.71 163.09,20.59 163.14,20.58 163.19,20.58 163.28,20.55 163.3,20.45 163.29,20.27 163.36,20.11 163.58,19.97 163.83,20 163.84,20 163.96,19.87 163.96,19.74 163.93,19.7 163.91,19.67 163.9,19.63 163.89,19.46 163.98,19.33 163.98,19.2 163.73,18.94 163.59,18.94 163.32,19.21 163.32,19.31 163.42,19.66 163.08,19.81 163,19.82 162.95,19.9 162.83,20.11 162.59,20.15 162.5,20.16 162.46,20.24 162.45,20.3 162.43,20.35 162.43,20.74 162.45,20.79 162.46,20.9 162.46,21.26 162.54,21.34 162.79,21.34
GND on BOTTOM (solid shape): 168.71,40.23 168.71,40.03 168.78,39.65 169.16,39.69 169.21,39.71 169.25,39.68 169.56,39.45 169.93,39.56 170.14,39.56 170.21,39.5 170.21,39.32 170.07,39.18 169.72,39.18 169.69,39.16 169.67,39.16 169.42,39.06 169.37,38.8 169.35,38.71 169.28,38.67 169.18,38.64 169.1,38.59 169.02,38.56 168.94,38.61 168.83,38.71 168.68,38.77 168.62,38.8 168.59,38.87 168.45,39.13 168.16,39.11 168.02,39.11 167.88,39.25 167.88,39.49 167.96,39.73 167.87,39.96 167.85,40.03 167.88,40.1 167.93,40.15 167.97,40.21 168.07,40.31 168.63,40.31
GND on BOTTOM (solid shape): 269.9,112.04 273.16,112.67 275,109.9 273.23,107.16 270.01,107.66 269.27,107.66 267.94,106.32 267.94,98.48 267.7,98.25 264.89,98.25 264.47,98.67 264.47,101.22 264.86,101.61 265.85,101.61 266.82,102.36 266.36,103.49 266.07,103.78 266.07,110.68 267.43,112.04
GND on BOTTOM (solid shape): 62.95,106.92 59.73,110.77 64.55,112.18 64.55,112.18 67.56,112.18 67.62,112.04 67.64,111.9 67.64,111.82 67.67,111.8 67.67,107.8 67.64,107.77 67.64,106.57 67.18,105.44 68.15,104.69 69.19,104.69 69.5,104.38 69.5,102.38 69.49,102.38 69.49,102.12 69.09,101.72 68.4,101.72 67.4,102.72 65.61,102.72 64.36,103.97 64.36,106.21 63.64,106.92
GND on BOTTOM (solid shape): 8.01,67.99 8.01,64.75 8,64.75 8,63.31 7.57,62.88 7.57,58.71 7.58,58.7 7.58,58.21 7.9,57.88 11.78,57.88 12.32,58.43 13.64,58.43 13.92,58.15 15.55,58.15 16.16,57.54 16.16,56.09 15.91,55.84 13.93,55.84 13.93,56.25 12.95,57.67 11.28,57.27 7.08,57.27 6.6,56.79 5.27,56.79 4.79,57.27 4.79,57.27 4.56,57.27 4.53,57.31 4.53,58.8 2.05,61.4 4.53,64 4.53,64.87 4.52,64.88 4.52,65.66 4.73,65.87 5.87,65.87 6.44,66.44 6.44,66.7 6.62,67.4 6.44,68.1 6.44,68.48 6.57,68.6 7.4,68.6
GND on BOTTOM (solid shape): 168.99,35.13 169.06,35.1 169.16,35.03 169.27,35 169.33,34.97 169.36,34.91 169.36,34.87 169.37,34.84 169.35,34.75 169.28,34.71 169.01,34.43 169.28,34.15 169.35,34.1 169.37,34.01 169.42,33.75 169.67,33.65 169.69,33.66 169.76,33.59 170.14,33.59 170.26,33.47 170.26,33.13 170.24,33.1 170.22,33.07 169.88,33.07 169.53,33.2 169.37,32.86 169.35,32.77 169.28,32.72 169.21,32.71 169.15,32.69 168.92,32.86 168.62,32.85 168.6,32.89 168.59,32.93 168.56,33.08 168.45,33.18 168.46,33.33 168.56,33.5 168.79,33.73 168.79,34.27 168.48,34.58 168.48,34.7 168.56,34.79 168.59,34.91 168.62,34.98 168.69,35.01 168.82,35.04 168.92,35.1
GND on BOTTOM (solid shape): 164.26,39.58 164.47,39.39 164.75,39.4 164.83,39.39 164.89,39.34 165.01,39.19 165.21,39.16 165.31,39.16 165.31,38.66 165.28,38.6 165.27,38.53 165.23,38.46 165.16,38.44 165,38.39 164.89,38.26 164.84,38.21 164.77,38.2 164.48,38.18 164.3,37.96 164.03,37.96 163.96,38.04 163.96,38.17 164.04,38.29 164.08,38.42 164.11,38.49 164.17,38.52 164.39,38.96 163.9,38.89 163.85,38.83 163.78,38.82 163.52,38.79 163.34,38.6 163.04,38.6 162.91,38.73 162.91,39.05 163.04,39.18 163.26,39.16 163.42,39.31 163.43,39.32 163.53,39.42 163.56,39.41 163.81,39.42 164,39.58
GND on BOTTOM (solid shape): 165.94,41.77 165.94,41.58 165.87,41.31 166.07,41.12 166.32,40.87 166.32,40.64 165.79,40.11 165.76,40.11 165.65,40.13 165.54,40.11 165.51,40.1 165.39,40.22 165.37,40.24 165.11,40.34 164.89,40.16 164.83,40.1 164.75,40.1 164.62,40.13 164.49,40.11 164.46,40.1 164.43,40.14 164.43,40.15 164.38,40.23 164.32,40.3 164.27,40.38 164.32,40.47 164.27,40.96 163.89,40.64 163.89,40.63 163.78,40.52 163.14,40.52 163.1,40.56 162.96,40.84 162.67,40.95 162.54,40.95 162.49,41 162.49,41.43 162.59,41.53 162.83,41.53 163.28,41.99 164.04,41.99 164.52,41.51 164.78,41.51 164.87,41.42 165.23,41.12 165.37,41.57 165.37,41.89 165.49,42.01 165.7,42.01
GND on BOTTOM (solid shape): outline of 251 points within 147.03,47.66 150.84,61.58
GND on BOTTOM (solid shape): outline of 266 points within 171.53,50.65 179.52,58.65
GND on BOTTOM (solid shape): outline of 98 points within 165.91,20.71 167.4,24.91
GND on BOTTOM (solid shape): outline of 8398 points within 146.13,17.88 170.26,42.02
GND on GND1 (solid shape): outline of 3404 points within 0.51,0.51 330.99,112.39
GND on IN1 (solid shape): 289.15,83.7 289.15,79.36 289.09,79.29 284.74,79.29 284.66,79.37 284.66,83.69 284.72,83.74 289.1,83.74
GND on IN1 (solid shape): 49.81,3.45 49.81,1.67 49.56,1.42 48.67,1.42 48.29,1.8 48.29,2.94 47.91,3.32 44.42,3.32 43.91,2.82 43.91,1.8 43.59,1.48 41.81,1.48 41.56,1.74 41.56,4.21 42.32,4.98 48.29,4.98
GND on IN1 (solid shape): 324.3,32.01 324.3,3.36 324.05,3.11 317.81,3.11 317.66,3.26 317.66,4.07 317.96,4.38 322.31,4.38 322.64,4.71 322.64,29.8 322.18,30.26 320.35,30.26 319.99,30.62 319.99,32.57 320.17,32.75 323.56,32.75
GND on IN1 (solid shape): 64,4.1 64,1.4 63.38,1.18 62.92,0.73 62.79,0.6 62.63,0.52 61.43,0.52 61.22,0.73 61.22,3.99 61.53,4.3 63.8,4.3
GND on IN1 (solid shape): 40.82,4.43 40.82,0.51 39.49,0.51 39.26,0.57 39.08,0.73 38.78,1.07 38.39,1.3 38.39,1.31 38.21,1.49 38.21,4.19 38.6,4.59 40.66,4.59
GND on IN1 (solid shape): 86.98,111.53 86.98,109.93 86.61,109.56 86.61,105.67 86.14,105.19 86.14,102.22 85.63,101.71 82.93,101.71 82.52,102.12 82.52,104.69 83.85,104.7 84.83,105.43 84.37,106.56 84.36,111.52 84.36,111.61 84.56,111.82 86.69,111.82
GND on IN1 (solid shape): 245.65,110.83 245.65,105.4 245.64,105.4 245.64,103.49 245.18,102.36 246.15,101.61 247.19,101.61 247.55,101.26 247.55,98.71 247.18,98.35 239.87,98.35 237.04,101.17 237.04,110.96 237.17,111.08 245.39,111.08
GND on IN1 (solid shape): 16.26,44.33 16.26,41.46 15.91,41.11 13.98,41.11 13.8,40.93 4.82,40.93 4.7,41.05 4.7,42 4.95,42.24 6.99,42.24 7.49,41.73 11.11,41.73 11.13,41.72 11.3,41.72 12.97,41.34 13.93,42.75 13.93,44.33 14.03,44.43 16.16,44.43
GND on IN1 (solid shape): 328.39,69.59 328.39,65.97 328.08,65.67 320.72,65.67 319.05,66.07 318.07,64.65 318.07,64.22 315.6,64.22 315.45,64.37 315.45,64.82 319.52,68.89 320.53,68.89 321.23,68.98 321.83,69.38 321.83,69.89 328.09,69.89
GND on IN1 (solid shape): 7.59,68.22 7.59,59.24 8.39,58.44 10.91,58.44 13.61,58.44 13.87,58.18 15.48,58.18 16.1,57.56 16.1,56.03 15.84,55.78 13.93,55.78 13.93,56.25 12.95,57.67 11.28,57.27 7.75,57.27 7.24,56.75 4.97,56.75 4.86,56.87 4.86,57.27 4.58,57.27 4.54,57.31 4.54,59.47 3.61,60.4 2.6,60.4 2.53,60.46 2.53,62.93 2.71,63.1 3.63,63.1 4.52,63.99 4.52,65.66 4.73,65.87 5.87,65.87 6.44,66.44 6.44,66.7 6.62,67.4 6.44,68.1 6.44,68.48 6.57,68.6 7.21,68.6
GND on IN1 (solid shape): 321.59,92.66 325.04,96.35 326.96,91.69 326.96,91.08 327.68,90.37 330.38,90.37 330.47,90.28 330.47,88.07 330.31,87.91 323.14,87.91 321.23,89.82 317.82,89.82 316.73,88.74 315.57,88.74 315.37,88.93 315.37,91.35 315.59,91.56 321.09,91.56 321.59,92.06
GND on IN1 (solid shape): 8.2,89.08 11.53,89.97 13.5,87.15 11.68,84.39 8.42,84.99 4.92,84.99 4.54,85.37 4.54,86.7 4.29,86.95 1.24,86.95 1.11,87.08 1.11,88.92 1.27,89.08
GND on IN1 (solid shape): 318.5,51.37 318.5,50.25 318.7,50.05 322.31,50.05 323.02,50.76 326.93,50.76 327.56,50.12 327.56,46.8 325.5,44.73 325.5,38.99 323.5,33.75 321.5,38.99 321.5,48.29 320.91,48.88 317.15,48.88 315.55,50.48 315.55,51.39 315.93,51.78 318.09,51.78
GND on IN1 (solid shape): 269.9,112.04 273.16,112.67 275,109.9 273.23,107.16 270.01,107.66 269.27,107.66 267.94,106.32 267.94,98.48 267.7,98.25 264.89,98.25 264.47,98.67 264.47,101.22 264.86,101.61 265.85,101.61 266.82,102.36 266.36,103.49 266.07,103.78 266.07,110.68 267.43,112.04
GND on IN1 (solid shape): 62.95,106.92 59.73,110.77 64.55,112.18 64.55,112.18 67.56,112.18 67.62,112.04 67.64,111.9 67.64,111.82 67.67,111.8 67.67,107.8 67.64,107.77 67.64,106.57 67.18,105.44 68.15,104.69 69.19,104.69 69.5,104.38 69.5,102.38 69.49,102.38 69.49,102.12 69.09,101.72 68.4,101.72 67.4,102.72 65.61,102.72 64.36,103.97 64.36,106.19 63.63,106.92
GND on VCC (solid shape): 324.5,95.38 325.9,94.8 326.48,93.4 326.48,92.4 327.07,90.97 328.5,90.38 330.13,90.38 330.48,90.03 330.48,88.74 330.21,88.47 325.08,88.47 324.88,88.67 324.88,91.9 323.8,92.97 314.53,92.97 314.53,95.17 314.75,95.38
GND on VCC (solid shape): 28.43,27.63 28.43,25.63 32.42,21.65 32.42,21.37 32.26,21.07 32.42,20.76 32.42,19.33 32.24,19.01 32.42,18.69 32.42,13.82 32.35,13.61 32.42,13.4 32.42,9.93 32.23,9.58 32.42,9.23 32.42,7.09 33.2,6.31 61.21,6.31 61.54,6.12 61.87,6.31 63.56,6.31 63.84,6.11 64.17,6.21 64.23,6.24 64.3,6.22 64.62,6.12 64.89,6.31 65.71,6.31 66.32,5.7 66.32,2.14 66.11,1.92 64.18,1.92 64.11,1.92 63.97,1.92 63.95,1.91 63.94,1.9 63.12,1.62 62.5,1.02 39.5,1.02 38.81,1.66 37.89,1.92 37.82,1.92 11.74,1.92 10.98,2.07 10.34,2.5 8.1,4.74 7.67,5.38 7.52,6.14 7.52,9.02 7.88,9.38 15.5,9.38 15.56,9.38 15.71,9.38 15.72,9.4 15.74,9.4 16.93,9.97 17.5,11.16 17.5,11.18 17.52,11.19 17.52,11.34 17.52,11.4 17.52,19.4 17.52,19.46 17.52,27.4 17.97,27.85 28.21,27.85
GND on VCC (solid shape): 271.62,111.88 271.93,111.72 272.24,111.87 273.03,111.59 273.64,111.02 273.62,110.67 273.9,110.45 273.98,109.88 273.89,109.3 273.63,109.09 273.62,108.76 272.92,108.14 272,107.92 271.01,107.92 270.92,107.92 270.79,107.92 270.78,107.91 270.76,107.91 268.87,107.03 267.99,105.14 267.98,105.03 267.98,104.9 267.98,92.82 267.83,92.67 243.03,92.67 239.7,89.34 236.35,89.34 236.18,89.51 236.18,98.83 236.78,100.2 237.01,101.67 237.02,101.89 237.02,108.8 237.02,108.8 237.02,110.23 237.37,110.58 244.77,110.58 245.13,110.22 245.13,108.8 245.13,108.8 245.13,108.14 245.13,108.14 245.13,103.75 244.73,102.08 246.15,101.1 265.85,101.1 267.26,102.08 266.87,103.75 266.87,108.14 266.87,111.57 267.18,111.88
GND on VCC (solid shape): outline of 90 points within 50.32,58.53 120.43,84.41
GND on VCC (solid shape): 323,69.33 327.36,69.33 327.88,68.81 327.88,66.16 327.39,65.67 320.72,65.67 320.01,66.11 319.18,66.11 319.17,66.11 318.83,65.96 318.53,65.74 318.53,65.74 318.25,65.35 318.09,64.89 318.09,64.88 318.07,64.86 318.07,64.7 318.07,64.65 318.07,62.53 318.03,62.52 317.55,61.9 318.03,61.28 318.07,61.27 318.07,60.53 318.03,60.52 317.55,59.9 318.03,59.28 318.07,59.27 318.07,58.53 318.03,58.52 317.55,57.9 318.03,57.28 318.07,57.27 318.07,56.53 318.03,56.52 317.55,55.9 318.03,55.28 318.07,55.27 318.07,54.53 318.03,54.52 317.55,53.9 318.03,53.28 318.07,53.27 318.07,51.15 318.07,51.1 318.07,50.94 318.09,50.92 318.09,50.91 319.16,49.7 320.72,50.13 329.64,50.13 330.48,49.29 330.48,45.69 329.71,44.92 328.5,44.92 328.42,44.92 328.29,44.92 328.28,44.91 328.26,44.91 327.32,44.68 326.5,44.16 314.82,44.16 313.85,45.13 313.85,64.71 314.02,64.88 315.49,64.88 315.5,64.88 319.57,68.95 320.49,68.87 321.28,69.33 323,69.33
GND on VCC (solid shape): outline of 317 points within 60.62,98.05 90.66,111.88
GND on VCC (solid shape): outline of 579 points within 50.32,16.72 118.65,45.39
GND on VCC (solid shape): outline of 980 points within 1.02,39.84 43.21,89.13
GND on IN2 (solid shape): 289.15,83.7 289.15,79.36 289.09,79.29 284.74,79.29 284.66,79.37 284.66,83.69 284.72,83.74 289.1,83.74
GND on IN2 (solid shape): 49.81,3.45 49.81,1.67 49.56,1.42 48.67,1.42 48.29,1.8 48.29,2.94 47.91,3.32 44.42,3.32 43.91,2.82 43.91,1.8 43.59,1.48 41.81,1.48 41.56,1.74 41.56,4.21 42.32,4.98 48.29,4.98
GND on IN2 (solid shape): 324.3,32.01 324.3,3.36 324.05,3.11 317.81,3.11 317.66,3.26 317.66,4.07 317.96,4.38 322.31,4.38 322.64,4.71 322.64,29.8 322.18,30.26 320.35,30.26 319.99,30.62 319.99,32.57 320.17,32.75 323.56,32.75
GND on IN2 (solid shape): 64,4.1 64,1.4 63.38,1.18 62.92,0.73 62.79,0.6 62.63,0.52 61.43,0.52 61.22,0.73 61.22,3.99 61.53,4.3 63.8,4.3
GND on IN2 (solid shape): 40.82,4.43 40.82,0.51 39.49,0.51 39.26,0.57 39.08,0.73 38.78,1.07 38.39,1.3 38.39,1.31 38.21,1.49 38.21,4.19 38.6,4.59 40.66,4.59
GND on IN2 (solid shape): 245.65,110.82 245.65,105.4 245.64,105.4 245.64,103.49 245.18,102.36 246.15,101.61 247.19,101.61 247.55,101.26 247.55,98.71 247.18,98.35 239.87,98.35 237.04,101.17 237.04,110.95 237.17,111.08 245.39,111.08
GND on IN2 (solid shape): 86.98,111.53 86.98,109.93 86.61,109.56 86.61,105.67 86.14,105.19 86.14,102.22 85.63,101.71 82.93,101.71 82.52,102.12 82.52,104.69 83.85,104.7 84.83,105.43 84.37,106.56 84.36,111.52 84.36,111.61 84.56,111.82 86.69,111.82
GND on IN2 (solid shape): 16.26,44.33 16.26,42.28 15.09,41.11 13.98,41.11 13.8,40.93 4.72,40.93 4.72,42 4.96,42.24 7,42.24 7.51,41.73 11.11,41.73 11.13,41.72 11.3,41.72 12.97,41.34 13.93,42.75 13.93,44.33 14.03,44.43 16.16,44.43
GND on IN2 (solid shape): 328.39,69.59 328.39,65.97 328.08,65.67 320.72,65.67 319.05,66.07 318.07,64.65 318.07,64.22 315.6,64.22 315.45,64.37 315.45,64.82 319.52,68.89 320.53,68.89 321.23,68.98 321.83,69.38 321.83,69.89 328.09,69.89
GND on IN2 (solid shape): 8.35,68.29 8.35,62.89 7.69,62.23 7.69,59.18 8.43,58.44 13.65,58.44 13.92,58.17 15.54,58.17 16.1,57.61 16.1,56.03 15.84,55.78 13.93,55.78 13.93,56.25 12.95,57.67 11.28,57.27 7.77,57.27 7.27,56.77 4.96,56.77 4.86,56.87 4.86,57.27 4.55,57.27 4.53,57.3 4.53,59.48 3.63,60.39 2.56,60.39 2.52,60.42 2.52,63.07 2.57,63.12 3.64,63.12 4.52,63.99 4.52,65.66 4.73,65.87 5.87,65.87 6.44,66.44 6.44,66.7 6.62,67.4 6.44,68.1 6.44,68.48 6.57,68.6 8.03,68.6
GND on IN2 (solid shape): 321.59,92.66 325.04,96.35 326.96,91.69 326.96,91.08 327.68,90.37 330.38,90.37 330.47,90.28 330.47,88.07 330.31,87.91 323.14,87.91 321.23,89.82 316.37,89.82 316.03,90.16 316.03,91.19 316.4,91.56 321.09,91.56 321.59,92.06
GND on IN2 (solid shape): 8.2,89.08 11.53,89.97 13.5,87.15 11.68,84.39 8.42,84.99 4.92,84.99 4.54,85.37 4.54,86.7 4.29,86.95 1.24,86.95 1.11,87.08 1.11,88.92 1.27,89.08
GND on IN2 (solid shape): 318.5,51.37 318.5,50.25 318.7,50.05 322.31,50.05 323.02,50.76 326.93,50.76 327.56,50.12 327.56,46.8 325.5,44.73 325.5,38.99 323.5,33.75 321.5,38.99 321.5,48.29 320.91,48.88 317.15,48.88 315.55,50.48 315.55,51.39 315.93,51.78 318.09,51.78
GND on IN2 (solid shape): 269.9,112.04 273.16,112.67 275,109.9 273.23,107.16 270.01,107.66 269.27,107.66 267.94,106.32 267.94,98.48 267.7,98.25 264.89,98.25 264.47,98.67 264.47,101.22 264.86,101.61 265.85,101.61 266.82,102.36 266.36,103.49 266.07,103.78 266.07,110.68 267.43,112.04
GND on IN2 (solid shape): 62.95,106.92 59.73,110.77 64.55,112.18 64.55,112.18 67.56,112.18 67.62,112.04 67.64,111.9 67.64,111.82 67.67,111.8 67.67,107.8 67.64,107.77 67.64,106.57 67.18,105.44 68.15,104.69 69.19,104.69 69.5,104.38 69.5,102.38 69.49,102.38 69.49,102.12 69.09,101.72 68.4,101.72 67.4,102.72 65.61,102.72 64.36,103.97 64.36,106.21 63.64,106.92
GND on IN2 (solid shape): outline of 3976 points within 124.12,46.74 150.27,63.29
GND on IN3 (solid shape): 289.15,83.7 289.15,79.36 289.09,79.29 284.74,79.29 284.66,79.37 284.66,83.69 284.72,83.74 289.1,83.74
GND on IN3 (solid shape): 49.81,3.45 49.81,1.67 49.56,1.42 48.67,1.42 48.29,1.8 48.29,2.94 47.91,3.32 44.42,3.32 43.91,2.82 43.91,1.8 43.59,1.48 41.81,1.48 41.56,1.74 41.56,4.21 42.32,4.98 48.29,4.98
GND on IN3 (solid shape): 324.3,32.01 324.3,3.36 324.05,3.11 317.81,3.11 317.66,3.26 317.66,4.07 317.96,4.38 322.31,4.38 322.64,4.71 322.64,29.8 322.18,30.26 320.35,30.26 319.99,30.62 319.99,32.57 320.17,32.75 323.56,32.75
GND on IN3 (solid shape): 64,4.1 64,1.4 63.38,1.18 62.92,0.73 62.79,0.6 62.63,0.52 61.43,0.52 61.22,0.73 61.22,3.99 61.53,4.3 63.8,4.3
GND on IN3 (solid shape): 40.82,4.43 40.82,0.51 39.49,0.51 39.26,0.57 39.08,0.73 38.78,1.07 38.39,1.3 38.39,1.31 38.21,1.49 38.21,4.19 38.6,4.59 40.66,4.59
GND on IN3 (solid shape): 245.65,110.83 245.65,105.4 245.64,105.4 245.64,103.49 245.18,102.36 246.15,101.61 247.19,101.61 247.55,101.26 247.55,98.71 247.18,98.35 239.87,98.35 237.04,101.17 237.04,110.96 237.17,111.08 245.4,111.08
GND on IN3 (solid shape): 86.98,111.53 86.98,109.93 86.61,109.56 86.61,105.67 86.14,105.19 86.14,102.22 85.63,101.71 82.93,101.71 82.52,102.12 82.52,104.69 83.85,104.7 84.83,105.43 84.37,106.56 84.36,111.52 84.36,111.61 84.56,111.82 86.69,111.82
GND on IN3 (solid shape): 16.26,46.03 16.26,42.28 15.09,41.11 13.98,41.11 13.8,40.93 4.7,40.93 4.7,41.98 4.96,42.24 7.02,42.24 7.52,41.73 11.11,41.73 11.13,41.72 11.3,41.72 12.97,41.34 13.93,42.75 13.93,44.33 14.76,45.17 14.76,46.36 14.97,46.57 15.73,46.57
GND on IN3 (solid shape): 328.38,69.59 328.39,69.59 328.39,65.97 328.08,65.67 320.72,65.67 319.05,66.07 318.07,64.65 318.07,64.22 315.6,64.22 315.45,64.37 315.45,64.82 319.52,68.89 320.55,68.89 321.25,68.99 321.83,69.38 321.83,69.89 328.08,69.89
GND on IN3 (solid shape): 8.35,68.29 8.35,62.34 7.87,61.86 7.87,59.14 8.57,58.43 13.65,58.43 13.89,58.19 15.51,58.19 16.1,57.61 16.1,56.03 15.84,55.78 13.93,55.78 13.93,56.25 12.95,57.67 11.28,57.27 7.82,57.27 7.78,57.26 7.3,56.78 4.96,56.78 4.86,56.88 4.86,57.27 4.63,57.27 4.54,57.36 4.54,59.48 3.64,60.39 2.58,60.39 2.53,60.44 2.53,63.08 2.57,63.12 3.65,63.12 4.52,63.98 4.52,65.66 4.73,65.87 5.87,65.87 6.44,66.44 6.44,66.7 6.62,67.4 6.44,68.1 6.44,68.48 6.57,68.6 8.03,68.6
GND on IN3 (solid shape): 321.59,92.66 325.04,96.35 326.96,91.69 326.96,91.08 327.68,90.37 330.38,90.37 330.47,90.28 330.47,88.07 330.31,87.91 323.14,87.91 321.23,89.82 317.82,89.82 317.43,89.44 315.56,89.44 315.37,89.63 315.37,91.35 315.59,91.56 321.09,91.56 321.59,92.06
GND on IN3 (solid shape): 8.2,89.08 11.53,89.97 13.5,87.15 11.68,84.39 8.42,84.99 4.92,84.99 4.54,85.37 4.54,86.7 4.29,86.95 1.24,86.95 1.11,87.08 1.11,88.92 1.27,89.08
GND on IN3 (solid shape): 318.5,51.37 318.5,50.25 318.7,50.05 322.31,50.05 323.02,50.76 326.93,50.76 327.56,50.12 327.56,46.8 325.5,44.73 325.5,38.99 323.5,33.75 321.5,38.99 321.5,48.29 320.91,48.88 317.15,48.88 315.55,50.48 315.55,51.39 315.93,51.78 318.09,51.78
GND on IN3 (solid shape): 269.9,112.04 273.16,112.67 275,109.9 273.23,107.16 270.01,107.66 269.27,107.66 267.94,106.32 267.94,98.48 267.7,98.25 264.89,98.25 264.47,98.67 264.47,101.22 264.86,101.61 265.85,101.61 266.82,102.36 266.36,103.49 266.07,103.78 266.07,110.68 267.43,112.04
GND on IN3 (solid shape): 62.95,106.92 59.73,110.77 64.55,112.18 64.55,112.18 67.56,112.18 67.62,112.04 67.64,111.9 67.64,111.82 67.67,111.8 67.67,107.8 67.64,107.77 67.64,106.57 67.18,105.44 68.15,104.69 69.19,104.69 69.5,104.38 69.5,102.38 69.49,102.38 69.49,102.12 69.09,101.72 68.4,101.72 67.4,102.72 65.61,102.72 64.36,103.97 64.36,106.23 63.67,106.92
GND on GND2 (solid shape): outline of 3672 points within 0.51,0.51 330.99,112.39
GND on IN4 (solid shape): 289.15,83.7 289.15,79.36 289.09,79.29 284.74,79.29 284.66,79.37 284.66,83.69 284.72,83.74 289.1,83.74
GND on IN4 (solid shape): 49.81,3.45 49.81,1.67 49.56,1.42 48.67,1.42 48.29,1.8 48.29,2.94 47.91,3.32 44.42,3.32 43.91,2.82 43.91,1.8 43.59,1.48 41.81,1.48 41.56,1.74 41.56,4.21 42.32,4.98 48.29,4.98
GND on IN4 (solid shape): 324.3,32.01 324.3,3.36 324.05,3.11 317.81,3.11 317.66,3.26 317.66,4.07 317.96,4.38 322.31,4.38 322.64,4.71 322.64,29.8 322.18,30.26 320.35,30.26 319.99,30.62 319.99,32.57 320.17,32.75 323.56,32.75
GND on IN4 (solid shape): 64,4.1 64,1.4 63.38,1.18 62.92,0.73 62.79,0.6 62.63,0.52 61.43,0.52 61.22,0.73 61.22,3.99 61.53,4.3 63.8,4.3
GND on IN4 (solid shape): 40.82,4.43 40.82,0.51 39.49,0.51 39.26,0.57 39.08,0.73 38.78,1.07 38.39,1.3 38.39,1.31 38.21,1.49 38.21,4.19 38.6,4.59 40.66,4.59
GND on IN4 (solid shape): 245.65,110.82 245.65,105.4 245.64,105.4 245.64,103.49 245.18,102.36 246.15,101.61 247.19,101.61 247.55,101.26 247.55,98.71 247.18,98.35 239.87,98.35 237.04,101.17 237.04,110.97 237.14,111.07 245.39,111.07
GND on IN4 (solid shape): 86.98,111.53 86.98,109.93 86.61,109.56 86.61,105.67 86.14,105.19 86.14,102.22 85.63,101.71 82.93,101.71 82.52,102.12 82.52,104.69 83.85,104.7 84.83,105.43 84.37,106.56 84.36,111.52 84.36,111.61 84.56,111.82 86.69,111.82
GND on IN4 (solid shape): 16.26,44.33 16.26,42.28 15.09,41.11 13.98,41.11 13.8,40.93 4.7,40.93 4.7,42 4.95,42.24 7.02,42.24 7.52,41.73 11.11,41.73 11.13,41.72 11.3,41.72 12.97,41.34 13.93,42.75 13.93,44.33 14.03,44.43 16.16,44.43
GND on IN4 (solid shape): 328.39,69.58 328.39,65.98 328.08,65.67 320.72,65.67 319.05,66.07 318.07,64.65 318.07,64.22 315.6,64.22 315.45,64.37 315.45,64.82 319.52,68.89 320.55,68.89 321.25,68.99 321.83,69.38 321.83,69.89 328.08,69.89
GND on IN4 (solid shape): 8.35,68.29 8.35,62.02 7.89,61.57 7.89,59.08 8.54,58.43 13.64,58.43 13.94,58.13 15.56,58.13 16.1,57.59 16.1,56.03 15.84,55.78 13.93,55.78 13.93,56.25 12.95,57.67 11.28,57.27 7.77,57.27 7.27,56.77 5.07,56.77 4.86,56.98 4.86,57.27 4.56,57.27 4.53,57.31 4.53,59.5 3.64,60.39 2.58,60.39 2.53,60.44 2.53,63 2.63,63.1 3.65,63.1 4.52,63.97 4.52,65.66 4.73,65.87 5.87,65.87 6.44,66.44 6.44,66.7 6.62,67.4 6.44,68.1 6.44,68.48 6.57,68.6 8.03,68.6
GND on IN4 (solid shape): 321.59,92.66 325.04,96.35 326.96,91.69 326.96,91.08 327.68,90.37 330.38,90.37 330.47,90.28 330.47,88.07 330.31,87.91 323.14,87.91 321.23,89.82 317.82,89.82 316.73,88.74 315.57,88.74 315.37,88.93 315.37,91.35 315.59,91.56 321.09,91.56 321.59,92.06
GND on IN4 (solid shape): 8.2,89.08 11.53,89.97 13.5,87.15 11.68,84.39 8.42,84.99 4.92,84.99 4.54,85.37 4.54,86.7 4.29,86.95 1.24,86.95 1.11,87.08 1.11,88.92 1.27,89.08
GND on IN4 (solid shape): 318.5,51.37 318.5,50.25 318.7,50.05 322.31,50.05 323.02,50.76 326.93,50.76 327.56,50.12 327.56,46.8 325.5,44.73 325.5,38.99 323.5,33.75 321.5,38.99 321.5,48.29 320.91,48.88 317.15,48.88 315.55,50.48 315.55,51.39 315.93,51.78 318.09,51.78
GND on IN4 (solid shape): 269.9,112.04 273.16,112.67 275,109.9 273.23,107.16 270.01,107.66 269.27,107.66 267.94,106.32 267.94,98.48 267.7,98.25 264.89,98.25 264.47,98.67 264.47,101.22 264.86,101.61 265.85,101.61 266.82,102.36 266.36,103.49 266.07,103.78 266.07,110.68 267.43,112.04
GND on IN4 (solid shape): 62.95,106.92 59.73,110.77 64.55,112.18 64.55,112.18 67.56,112.18 67.62,112.04 67.64,111.9 67.64,111.82 67.67,111.8 67.67,107.8 67.64,107.77 67.64,106.57 67.18,105.44 68.15,104.69 69.19,104.69 69.5,104.38 69.5,102.38 69.49,102.38 69.49,102.12 69.09,101.72 68.4,101.72 67.4,102.72 65.61,102.72 64.36,103.97 64.36,106.22 63.66,106.92
GND on GND3 (solid shape): outline of 3465 points within 0.51,0.51 330.99,112.39
GNDA on TOP (solid shape): 32.03,46.06 32.03,45.62 31.5,45.62 31.5,45.18 32.03,45.18 32.03,44.41 31.88,44.26 30.33,44.26 30.03,44.56 30.03,45.93 30.28,46.19 31.91,46.19
GNDA on TOP (solid shape): 21.29,40.1 21.29,39.32 20.76,38.79 20.76,38.53 20.65,38.42 20.15,38.42 20.05,38.52 20.05,38.86 20.83,39.64 20.83,40 20.95,40.12 21.28,40.12
GNDA on GND1 (solid shape): 31.4,45.37 31.4,44.33 32.21,43.52 35.76,43.52 36.1,43.18 36.1,42.71 35.76,42.38 30.63,42.38 30.13,41.88 30.13,41.46 30.26,41.33 30.26,40.42 28.58,40.42 28.38,40.22 28.38,34.6 28.58,34.4 29.21,34.4 29.24,34.37 29.24,31.53 29.49,31.28 29.49,30.24 29.47,30.22 29.26,29.88 29.47,29.54 29.49,29.53 29.49,29.35 29.38,29.24 29.32,29.3 28.9,29.3 28.47,28.86 16.79,28.86 14.83,26.91 9.85,26.91 9.85,26.91 1,26.91 0.65,27.05 0.51,27.4 0.51,28.42 12.7,28.42 13.67,29.16 13.21,30.3 13.21,31.15 13.21,31.15 13.21,37.8 13.58,38.19 13.71,38.72 13.74,38.79 13.81,38.82 21.58,38.82 28.46,45.7 31.06,45.7
GNDA on IN1 (solid shape): 16.79,31.01 16.79,28.94 14.76,26.91 9.74,26.91 9.74,26.91 1,26.91 0.65,27.05 0.51,27.4 0.51,28.4 0.52,28.42 4.28,28.42 4.36,28.38 4.53,27.69 5.09,27.43 6.01,27.43 6.57,27.69 6.74,28.38 6.82,28.42 10.23,28.42 10.31,28.38 10.48,27.69 11.04,27.43 11.96,27.43 12.54,27.71 12.66,28.4 12.7,28.42 12.79,28.42 13.08,28.49 13.35,28.65 13.35,28.65 13.7,29.51 13.21,30.3 13.21,31.05 13.4,31.24 13.41,31.24 13.46,31.29 16.51,31.29
GNDA on VCC (solid shape): 31.4,45.37 31.4,44.33 32.21,43.52 35.76,43.52 36.1,43.18 36.1,42.71 35.76,42.38 30.63,42.38 30.13,41.88 30.13,41.46 30.26,41.33 30.26,40.42 28.58,40.42 28.38,40.22 28.38,34.6 28.58,34.4 29.21,34.4 29.24,34.37 29.24,31.53 29.49,31.28 29.49,30.24 29.47,30.22 29.26,29.88 29.47,29.54 29.49,29.53 29.49,29.35 29.44,29.3 28.9,29.3 28.47,28.86 16.79,28.86 15.35,27.43 12.5,27.43 12.41,27.49 12.44,27.61 12.56,27.74 12.64,27.91 12.7,27.91 13.12,27.97 13.5,28.14 13.55,28.17 13.6,28.21 14.22,29.35 13.72,30.55 13.72,37.55 14.09,38.08 14.22,38.72 14.25,38.79 14.32,38.82 21.58,38.82 28.46,45.7 31.06,45.7
GNDA on IN2 (solid shape): 16.79,31.01 16.79,28.94 14.76,26.91 9.49,26.91 9.49,26.91 1,26.91 0.65,27.05 0.51,27.4 0.51,28.4 0.52,28.42 4.28,28.42 4.36,28.38 4.53,27.69 5.09,27.43 6.01,27.43 6.57,27.69 6.74,28.38 6.82,28.42 10.23,28.42 10.31,28.38 10.48,27.69 11.04,27.43 11.96,27.43 12.54,27.71 12.65,28.35 12.65,28.36 12.65,28.42 12.73,28.42 12.79,28.42 13.08,28.49 13.34,28.65 13.35,28.65 13.7,29.51 13.21,30.3 13.21,31.05 13.4,31.24 13.41,31.24 13.46,31.29 16.51,31.29
GNDA on IN3 (solid shape): 16.79,31.01 16.79,28.94 14.76,26.91 9.49,26.91 9.49,26.91 1,26.91 0.65,27.05 0.51,27.4 0.51,28.4 0.52,28.42 4.28,28.42 4.36,28.38 4.53,27.69 5.09,27.43 6.01,27.43 6.57,27.69 6.74,28.38 6.82,28.42 10.23,28.42 10.31,28.38 10.48,27.69 11.04,27.43 11.96,27.43 12.54,27.71 12.65,28.35 12.65,28.36 12.65,28.42 12.73,28.42 12.79,28.42 13.08,28.49 13.34,28.65 13.35,28.65 13.7,29.51 13.21,30.3 13.21,31.05 13.4,31.24 13.41,31.24 13.46,31.29 16.51,31.29
GNDA on GND2 (solid shape): 31.4,45.37 31.4,44.33 32.21,43.52 35.76,43.52 36.1,43.18 36.1,42.71 35.76,42.38 30.63,42.38 30.13,41.88 30.13,41.46 30.26,41.33 30.26,40.42 28.58,40.42 28.38,40.22 28.38,34.6 28.58,34.4 29.21,34.4 29.24,34.37 29.24,31.53 29.49,31.28 29.49,30.24 29.47,30.22 29.26,29.88 29.47,29.54 29.49,29.53 29.49,29.35 29.38,29.24 29.32,29.3 28.9,29.3 28.47,28.86 16.79,28.86 14.83,26.91 9.56,26.91 1,26.91 0.65,27.05 0.51,27.4 0.51,28.42 12.7,28.42 13.66,29.1 13.31,30.23 13.26,30.26 13.21,30.3 13.21,37.8 13.58,38.19 13.71,38.72 13.74,38.79 13.81,38.82 21.58,38.82 28.46,45.7 31.06,45.7
GNDA on IN4 (solid shape): 16.79,31.01 16.79,28.94 14.76,26.91 8.99,26.91 8.99,26.91 1,26.91 0.65,27.05 0.51,27.4 0.51,28.4 0.52,28.42 4.28,28.42 4.36,28.38 4.53,27.69 5.09,27.43 6.01,27.43 6.57,27.69 6.74,28.38 6.82,28.42 10.23,28.42 10.31,28.38 10.48,27.69 11.04,27.43 11.96,27.43 12.54,27.71 12.65,28.35 12.65,28.36 12.65,28.42 12.73,28.42 12.79,28.42 13.08,28.49 13.34,28.65 13.35,28.65 13.7,29.51 13.21,30.3 13.21,31.05 13.4,31.24 13.41,31.24 13.46,31.29 16.51,31.29
GNDA on GND3 (solid shape): 31.4,45.37 31.4,44.33 32.21,43.52 35.76,43.52 36.1,43.18 36.1,42.71 35.76,42.38 30.63,42.38 30.13,41.88 30.13,41.46 30.26,41.33 30.26,40.42 28.58,40.42 28.38,40.22 28.38,34.6 28.58,34.4 29.21,34.4 29.24,34.37 29.24,31.53 29.49,31.28 29.49,30.24 29.47,30.22 29.26,29.88 29.47,29.54 29.49,29.53 29.49,29.35 29.38,29.24 29.32,29.3 28.9,29.3 28.47,28.86 16.79,28.86 14.83,26.91 9.32,26.91 9.32,26.91 1,26.91 0.65,27.05 0.51,27.4 0.51,28.42 12.7,28.42 13.67,29.16 13.21,30.3 13.21,30.52 13.21,30.52 13.21,37.8 13.58,38.19 13.71,38.72 13.74,38.79 13.81,38.82 21.58,38.82 28.46,45.7 31.06,45.7
GNDA_CHG on TOP (solid shape): 35.73,24.7 35.73,24.16 35.75,24.14 36.19,24.14 36.22,24.16 36.22,24.69 36.23,24.7 36.6,24.7 36.67,24.63 36.67,23.52 36.45,23.3 35.41,23.3 35.2,23.51 35.2,24.55 35.34,24.7 35.73,24.7
GNDA_CHG on TOP (solid shape): 33.33,22.95 33.33,21.6 33.48,21.45 34.98,21.45 35.03,21.4 35.03,18.83 35.21,18.65 36.63,18.65 36.69,18.59 36.69,18.46 36.63,18.4 34.91,18.4 34.63,18.68 32.31,18.68 32.29,18.7 32.29,21.49 32.05,21.72 32.05,22.96 32.11,23.02 32.25,23.02 32.33,22.95 32.33,21.89 32.54,21.68 32.86,21.68 33.05,21.86 33.05,22.94 33.14,23.03 33.25,23.03
GNDA_CHG on IN3 (solid shape): outline of 373 points within 32.01,12.82 41.53,23.89
GNDA_VCCSA on BOTTOM (solid shape): 140.2,3.68 140.2,2.53 140.15,2.48 139.37,2.48 139.34,2.51 139.34,3.68 139.47,3.8 140.08,3.8
VDD_1.5V on TOP (solid shape): 41.5,68.67 41.5,67.9 39.34,65.75 39.15,65.75 39.08,65.81 39.08,66.7 40.39,68 40.39,68.76 40.42,68.79 41.37,68.79
+BL_PWR_SRC on TOP (solid shape): 144.13,103.28 144.13,100.41 143.98,100.26 141.14,100.26 140.85,100.55 140.85,103.21 141.14,103.5 143.91,103.5
+BL_PWR_SRC on TOP (solid shape): 96.75,108.81 96.75,105.15 96.53,104.92 93.81,104.92 93.52,105.21 93.52,108.19 94.72,108.19 94.72,108.14 94.73,108.08 94.75,108.03 94.78,107.98 94.82,107.94 94.86,107.9 94.9,107.86 94.95,107.84 95,107.82 95.06,107.81 95.11,107.81 95.17,107.82 95.22,107.83 95.27,107.85 95.32,107.88 95.37,107.92 95.4,107.96 95.43,108 95.46,108.05 95.47,108.11 95.48,108.16 95.48,108.22 95.47,108.27 95.46,108.33 95.43,108.38 95.4,108.42 95.37,108.47 95.32,108.5 95.27,108.53 95.22,108.55 95.17,108.57 95.11,108.57 95.06,108.57 95,108.56 94.95,108.54 94.9,108.52 94.86,108.48 94.82,108.45 94.78,108.4 94.75,108.35 94.73,108.3 94.72,108.25 94.72,108.19 93.52,108.19 93.52,108.8 93.64,108.91 96.65,108.91
+BL_PWR_SRC on BOTTOM (solid shape): 96.8,109.81 96.8,108.66 96.76,108.62 96.76,107.19 96.72,107.14 95.64,107.14 95.45,107.33 95.45,108.05 95.46,108.06 95.48,108.19 95.46,108.33 95.45,108.33 95.45,109.87 95.46,109.88 96.72,109.88
+BL_PWR_SRC on BOTTOM (solid shape): 145.77,103.27 145.77,100.61 145.62,100.46 142.08,100.46 141.74,100.11 140.47,100.11 140.43,100.16 140.43,100.87 140.51,100.95 141.15,100.95 141.43,101.23 141.43,102.54 141.27,102.7 140.39,102.7 140.33,102.76 140.33,103.45 140.47,103.59 145.45,103.59
+CAMERA_VDD on BOTTOM (solid shape): 152.99,108.09 152.99,107.63 151.35,105.99 149.85,105.99 149.78,106.07 149.78,107.29 149.46,107.62 149.46,109.63 149.54,109.72 151.36,109.72
+CAMERA_VDD on BOTTOM (solid shape): 93.23,109.47 93.18,109.36 93.17,109.25 93.17,108.34 93.23,108.29 93.23,107.45 93.12,107.35 92.77,107.35 92.66,107.45 92.66,107.81 92.67,107.81 92.67,108.34 92.97,108.64 92.97,109.88 93.23,109.88
+CAMERA_VDD on IN3 (solid shape): 151.37,109.59 151.37,108.09 151.1,107.81 150.37,107.81 150.09,108.09 150.09,109.56 150.17,109.65 151.31,109.65
+CAMERA_VDD on IN3 (solid shape): 94.44,107.36 94.44,106.2 94.39,106.16 93.37,106.16 93.27,106.25 93.27,106.84 92.64,107.48 92.64,108.34 92.82,108.52 93.27,108.52
+CRT_VCC on TOP (solid shape): 7.02,76.98 10.97,76.98 10.97,76.98 11.29,76.98 11.35,76.92 11.35,76.25 11.2,76.1 7,76.1 6.95,76.05 5.49,76.05 5.42,76.12 5.42,76.99 5.5,77.07 6.94,77.07
+CRT_VCC on BOTTOM (solid shape): 9.95,60.45 9.95,59.03 9.88,58.96 8.74,58.96 8.66,59.04 8.66,60.48 8.81,60.63 9.77,60.63
+CRT_VCC on IN1 (solid shape): outline of 368 points within 6.9,60.06 23.07,81.41
+DC1_PWR_SRC on TOP (solid shape): 240.7,16.47 240.7,14.25 240.51,14.06 238.09,14.06 237.84,14.31 237.84,16.66 238.47,17.29 239.87,17.29
+DC1_PWR_SRC on TOP (solid shape): 262.68,17.54 262.68,12.62 261.24,11.19 258.98,11.19 258.85,11.31 258.85,15.96 258.56,16.25 258.56,16.85 258.38,17.04 258.02,17.04 258.02,17.04 255.12,17.04 255.12,17.04 254.86,17.04 254.85,17.04 254.6,17.04 254.44,17.21 254.44,18.66 254.59,18.82 261.4,18.82
+DC1_PWR_SRC on BOTTOM (solid shape): 222.19,10.09 222.19,9.62 219.89,7.33 219.13,7.33 218.37,6.57 215.93,6.57 215.77,6.73 215.77,7.85 219.58,11.66 220.62,11.66
+DC1_PWR_SRC on BOTTOM (solid shape): 240.62,18.59 240.62,10.37 240.71,10.27 242.18,10.27 242.42,10.03 242.42,7.61 242.19,7.38 239.37,7.38 239.22,7.53 239.22,9.73 239.11,9.84 239.11,14.33 237.74,15.7 237.74,18.61 237.99,18.85 240.35,18.85
+DC_IN on TOP (solid shape): 20.6,70.51 20.6,63.01 20.29,62.7 17.38,62.7 17.38,62.71 17.11,62.98 17.11,64.58 16.24,65.45 16.24,70.39 16.5,70.66 18.94,70.66 19.14,70.86 20.26,70.86
+DC_IN on BOTTOM (solid shape): 20.6,67.33 20.6,63.01 20.32,62.73 17.48,62.73 17.23,62.99 17.23,66.37 17.21,66.37 16.4,67.18 16.4,68.6 16.48,68.68 19.26,68.68
+DC_IN_SS on TOP (solid shape): 16.7,64.62 16.7,62.85 17.89,61.66 17.89,59.32 17.73,59.17 14.22,59.17 13.84,59.54 13.84,64.92 14.1,65.17 16.14,65.17
+DC_IN_SS on BOTTOM (solid shape): 16.06,65.81 16.06,59.47 15.97,59.38 13.81,59.38 13.72,59.47 13.72,61.2 13.38,61.54 12.23,61.54 12.04,61.73 12.04,65.82 12.24,66.03 15.84,66.03
+DCIN_JACK on TOP (solid shape): 25.77,71.19 25.77,69.27 24.98,68.48 24.98,67.26 24.71,66.99 22.42,66.99 22.32,67.08 22.32,71.28 22.54,71.49 25.47,71.49
+DCIN_JACK on BOTTOM (solid shape): 16.34,73.68 16.34,72.47 17.66,71.15 17.66,69.21 17.44,68.99 15.01,68.99 13.97,70.04 13.97,73.75 14.13,73.92 16.1,73.92
+DCIN_JACK on IN4 (solid shape): 16.31,73.65 16.31,71.71 16.67,71.34 25.6,71.34 25.84,71.09 25.84,69.34 25.27,68.77 15.32,68.77 13.98,70.1 13.98,73.79 14.13,73.94 16.03,73.94
+GFX_PWR_SRC on TOP (solid shape): 128.91,90.79 131.15,90.79 131.15,90.78 131.63,90.78 132.69,89.72 132.69,86.35 132.92,86.13 132.92,84.5 132.75,84.33 132.75,82.95 132.63,82.82 131.52,82.82 131.31,83.03 131.31,84.71 130.96,85.05 130.81,85.05 130.81,85.06 126.69,85.06 126.36,85.39 126.36,89.67 126.36,89.76 122.52,93.6 119.41,93.6 118.49,92.68 118.49,90.62 118.5,90.61 118.5,90.5 119.44,89.56 119.44,89.2 119.31,89.08 117.53,89.08 117.42,89.19 117.42,89.81 116.81,90.42 116.81,94.56 118.3,96.05 123.65,96.05
+LCDVDD on BOTTOM (solid shape): 136.55,99.97 136.55,98.92 136.31,98.68 133.5,98.68 133.32,98.85 133.32,99.87 133.59,100.14 136.38,100.14
+LCDVDD on BOTTOM (solid shape): 108.23,109.84 108.23,108.41 108.45,108.19 108.45,107.29 108.3,107.14 107.45,107.14 107.27,107.32 107.27,108.21 107.46,108.4 107.46,109.83 107.52,109.88 108.19,109.88
+LCDVDD on IN3 (solid shape): outline of 725 points within 106.38,93.08 136.59,108.34
+OZ_AVDD on TOP (solid shape): 278.9,12.2 278.9,12 276.79,9.89 276.79,9.61 276.73,9.55 275.84,9.55 275.78,9.61 275.78,10.56 275.58,10.76 275.58,11.37 275.62,11.4 276.85,11.4 277.15,11.7 277.39,11.7 277.86,12.17 278.38,12.17 278.48,12.18 278.57,12.21 278.58,12.21 278.9,12.21
+OZ_DVDD on TOP (solid shape): 279.75,11.84 279.75,10.84 280.24,10.34 280.24,9.89 280.83,9.31 280.83,8.5 280.8,8.47 279.04,8.47 278.97,8.53 278.97,10.04 279.48,10.55 279.48,11.84 279.54,11.9 279.69,11.9
+PCH_V5REF_RUN on IN2 (solid shape): outline of 1195 points within 163.63,32 181.69,36.08
+PE_VDDH on TOP (solid shape): 278.72,18.74 278.72,17.54 279.25,17.01 279.25,15.82 279.22,15.79 279.04,15.79 278.8,16.03 278.38,16.03 277.67,16.03 277.67,16.03 277.63,16.03 276.74,16.92 276.73,16.92 276.54,17.1 275.9,17.1 274.75,18.26 274.75,18.78 274.79,18.82 278.64,18.82
+PWR_SRC on TOP (solid shape): 49.28,78.73 49.28,74.54 48.99,74.25 46.89,74.25 46.59,74.56 46.59,78.65 46.85,78.91 49.1,78.91
+PWR_SRC on TOP (solid shape): 145.45,97.21 145.45,95.08 145.13,94.76 139.41,94.76 139.03,95.15 139.03,96.8 139.92,97.69 144.97,97.69
+PWR_SRC on TOP (solid shape): 39.58,72.36 39.58,71.39 38.93,70.73 35,70.73 34.9,70.84 34.9,72.34 35.15,72.6 39.34,72.6
+PWR_SRC on TOP (solid shape): 155.8,76.29 155.8,73.38 155.56,73.14 155,73.14 154.99,73.14 154.99,72.59 154.74,72.59 154.74,73.13 154.73,73.14 154.2,73.14 154.19,73.13 154.19,72.59 153.94,72.59 153.94,73.11 153.91,73.14 153.13,73.14 152.92,73.35 152.92,76.27 153.21,76.57 155.52,76.57
+PWR_SRC on TOP (solid shape): 25.12,58.63 25.54,58.63 25.54,58.11 26.05,58.11 26.05,58.63 26.34,58.63 26.34,58.11 26.85,58.11 26.85,58.63 27.27,58.63 28.9,57 28.9,52.81 28.87,52.78 26.79,52.78 23.41,56.16 21.87,56.16 21.49,56.54 21.49,57.07 22.87,57.07 23.22,57.43 22.87,57.78 21.49,57.78 21.49,58.57 21.56,58.63 25.12,58.63
+PWR_SRC on TOP (solid shape): outline of 86 points within 103.45,88.63 117.16,96.98
+PWR_SRC on TOP (solid shape): outline of 106 points within 38.38,35.27 47.95,51.98
+PWR_SRC on TOP (solid shape): outline of 253 points within 129.86,1.94 168.66,7.13
+PWR_SRC on TOP (solid shape): outline of 332 points within 180.89,1.94 192,6.49
+PWR_SRC on BOTTOM (solid shape): 217.36,5.43 217.36,2.94 217.11,2.7 214.93,2.7 214.69,2.94 214.69,5.3 215.1,5.72 217.07,5.72
+PWR_SRC on BOTTOM (solid shape): 71.85,9.49 71.85,5.8 71.72,5.67 70.07,5.67 69.75,5.36 69.75,4.53 69.56,4.34 67.47,4.34 67.28,4.53 67.28,9.53 67.46,9.72 71.62,9.72
+PWR_SRC on BOTTOM (solid shape): 143.98,100.01 143.98,97.54 144.38,97.14 144.38,96.58 144.22,96.42 142.12,96.42 141.92,96.63 141.92,97.64 142.11,97.83 142.11,100.03 142.32,100.25 143.75,100.25
+PWR_SRC on BOTTOM (solid shape): outline of 1142 points within 25.09,22.5 49.36,37.92
+PWR_SRC on IN1 (solid shape): outline of 781 points within 44.42,3.99 71.01,38.63
+PWR_SRC on VCC (solid shape): 122.23,7.58 125.86,7.58 126.17,7.43 126.47,7.58 126.75,7.58 126.76,7.53 127.14,7.2 127.52,7.53 127.52,7.58 132.13,7.58 133,6.71 133,2.17 132.75,1.92 67.07,1.92 66.83,2.16 66.83,5.7 67.45,6.31 92.08,6.31 92.32,6.22 92.56,6.31 96.77,6.31 96.95,6.2 97.16,6.2 97.25,6.24 97.33,6.3 97.34,6.31 97.43,6.31 97.47,6.26 97.5,6.24 97.79,6.16 98.05,6.31 100.72,6.31 106.05,11.64 118.16,11.64
+PWR_SRC on IN2 (solid shape): outline of 135 points within 42.92,47.05 49.56,59.84
+PWR_SRC on IN2 (solid shape): outline of 170 points within 34.96,69.49 50.13,76.86
+PWR_SRC on IN3 (solid shape): outline of 726 points within 186.59,1.97 217.23,9.2
+SATA_SIDE_PWR on BOTTOM (solid shape): 245.2,96.58 245.2,92.69 244.82,92.31 242.82,92.31 242.6,92.53 242.6,96.48 242.92,96.8 244.99,96.8
+SATA_SIDE_PWR on BOTTOM (solid shape): 264.51,95.46 264.51,93.19 264.29,92.97 262.78,92.97 262.46,93.29 262.46,95.4 262.72,95.65 264.32,95.65
+SATA_SIDE_PWR on BOTTOM (solid shape): 311.71,51.34 311.71,48.92 311.66,48.87 310.46,48.87 310.27,49.06 310.27,50.79 309.83,51.23 309.15,51.23 309.08,51.3 309.08,51.44 309.17,51.52 311.54,51.52
+SATA_SIDE_PWR on IN1 (solid shape): 245.23,96.95 245.23,93.8 244.71,93.28 243.32,93.28 243.31,93.29 243.11,93.29 242.74,93.66 242.74,94.98 242.5,95.22 242.5,96.94 242.7,97.14 245.04,97.14
+SATA_SIDE_PWR on IN1 (solid shape): 266.45,93 266.45,92.36 265.09,91 264.65,91 261.88,93.77 260.34,93.77 260.03,93.46 258.54,93.46 258.45,93.55 258.45,95.23 258.72,95.5 261.95,95.5 262.2,95.74 263.71,95.74
+SATA_SIDE_PWR on IN2 (solid shape): outline of 384 points within 242.54,91.12 264.32,96.73
+SATA_SIDE_PWR on IN3 (solid shape): 263.45,99.46 263.45,98.24 264.56,97.14 264.56,92.96 264.19,92.59 262.69,92.59 262.29,93 262.29,97.73 261.42,98.6 259.22,98.6 258.81,99.01 258.81,99.58 259.2,99.98 262.94,99.98
+SATA_SIDE_PWR on IN3 (solid shape): outline of 1262 points within 299.49,48.84 314.2,88.07
+SATA_SIDE_PWR on IN4 (solid shape): 245.1,96.65 245.1,91.92 244.87,91.69 242.78,91.69 242.52,91.95 242.52,96.63 242.84,96.94 244.8,96.94
+SATA_SIDE_PWR on IN4 (solid shape): 264.62,95.38 264.62,91.07 264.05,90.5 258.93,90.5 258.67,90.77 258.67,92.55 258.86,92.74 262.14,92.74 262.41,93.01 262.41,95.35 262.65,95.59 264.41,95.59
+SATA_SIDE_PWR on IN1: 302.14,86.78 301.22,85.86 301.22,85.02 300.66,84.46 298.82,84.46 298.42,84.87 293.34,84.87 293.27,84.8 285.6,84.8 284.99,85.41 281.75,85.41 280.89,84.55 280.89,82.37 280.28,81.77 275.26,81.77 275.16,81.86 275.16,83.62 280.4,88.86 305.42,88.86 305.42,88.86 305.61,88.86 305.8,88.66 305.8,86.93 305.65,86.78
+SATA_SIDE_PWR on IN4: 284.52,85 281.3,81.77 277.1,81.77 276.8,82.07 276.8,83.78 281.89,88.87 305.59,88.87 305.8,88.66 305.8,86.92 305.65,86.78 302.14,86.78 300.36,85 299.29,85 293.23,85
+SDC_IN on TOP (solid shape): 21.21,60.62 21.21,59.04 20.48,58.3 20.48,57.78 19.11,57.78 18.75,57.43 19.11,57.07 20.48,57.07 20.48,56.47 20.41,56.41 18,56.41 17.39,57.02 17.39,58.41 18.34,59.36 18.34,60.74 18.58,60.98 20.85,60.98
+SKT_VCC on TOP (solid shape): 285.67,11.28 286.18,11.28 286.23,11.23 286.23,9.52 286.16,9.44 285.36,9.44 285.26,9.54 285.26,9.86 285.18,9.95 285.18,9.95 283.22,11.91 283.21,11.91 283.17,11.95 282.85,11.95 282.81,11.99 282.81,12.2 282.84,12.23 284.73,12.23
+V_DDR_REF on TOP (solid shape): 38.92,63.71 38.92,62.72 39.54,62.1 39.54,60.93 39.48,60.87 38.92,60.87 38.86,60.93 38.86,61.43 38.43,61.86 38.43,62.5 38.69,62.76 38.69,63.71 38.74,63.76 38.87,63.76
+V_SM_VREF_CNT on IN2 (solid shape): outline of 504 points within 102.29,56.13 113.45,59.18
