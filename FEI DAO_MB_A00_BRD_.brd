# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BC_DAT_ECE1117: length 122.1
  TOP w0.102: v1(292.36,70.46) 292.63,70.46 292.96,70.13 R817.1 ; v1(218.76,32.79) 219.37,32.79 220.88,34.29 v2(224.78,34.29) 226.13,34.29 227.53,32.9 227.53,29 225.92,27.39 221.24,27.39 220.4,26.55 220.4,25.51 220.55,25.36 JTP1.9 ; v1(290.65,61.49) 290.15,61.99 290.15,62.33 290.51,62.69 U51.B21
  IN1 w0.084: v1(292.36,70.46) 291.52,69.62 291.52,69.38 290.7,68.55 290.7,66.56 289.82,65.68 289.82,62.85 290.15,62.52 290.15,61.99 v1(290.65,61.49)
  IN2 w0.122: v1(290.65,61.49) 290.65,61.43 289.94,60.73 289.32,60.73 288.93,60.33 288.38,60.33 286.15,58.11 286.15,57.69 284.97,56.51 283.95,56.51 283.04,55.59 283.04,55.37 281.87,54.2 277.56,54.2 276.41,53.05 272.61,53.05 270.89,51.33 264.33,51.33 263.44,50.44 258.31,50.44 257.48,51.27 255.35,51.27 253.25,49.17 244.9,49.17 243.12,47.39 241.87,47.39 227.07,32.59 218.96,32.59 v1(218.76,32.79)
BC_DAT_ECE5048: length 46.6
  TOP w0.102: U51.B45 283.69,57.35 284.02,57.02 v1(284.1,57.02) ; v1(267.37,77.56) 267.8,77.99 268.26,77.99 268.45,77.81 U46.B31 ; v1(275.77,56.98) 275.56,57.19 v2(274.24,57.19) 273.02,57.19 R814.2
  IN1 w0.084: v1(275.77,56.98) 279.1,56.98 280.33,58.22 281.28,58.22 281.98,57.52 283.6,57.52 v1(284.1,57.02)
  BOTTOM w0.102: v1(267.37,77.56) 267.82,78.01 269.12,78.01 269.8,78.7 271.56,78.7 278.31,71.94 278.31,69.73 281.45,66.6 281.45,65.39 283.52,63.32 283.52,62.01 283.24,61.73 283.24,57.88 v1(284.1,57.02)
BC_DAT_EMC4021: length 223.8
  TOP w0.102: v1(162.98,105.57) 163.43,105.13 164.01,105.13 164.95,104.19 164.95,97.11 164.67,96.83 v2(164.67,95.01) 164.67,94.49 v1(163.87,93.69) ; R821.1 295.83,60.63 v1(294.95,61.5) ; v1(291.28,60.71) 291.71,60.28 292.23,60.28 292.3,60.35 U51.B13
  IN1 w0.084: v1(291.28,60.71) 291.72,60.27 292.99,60.27 293.76,61.03 294.48,61.03 v1(294.95,61.5)
  IN2 w0.122: v1(294.95,61.5) 295.3,61.86 295.3,62.74 292.7,65.34 292.7,68.12 291.89,68.93 277.89,68.93 276.22,67.26 276.22,66.63 272.99,63.41 269.3,63.41 267.13,61.25 265.41,61.25 264.63,62.03 255.26,62.03 252.06,58.83 243.98,58.83 243.24,58.09 243.24,57.1 242.56,56.42 240.38,56.42 237.02,53.06 237.02,52.3 235.4,50.68 231.71,50.68 222.76,41.73 222.76,41.12 218.38,36.75 213.7,36.75 211.96,35.01 198,35.01 193.94,39.07 192.81,39.07 192.16,39.71 187.9,39.71 181.55,46.06 177.62,46.06 176.76,46.92 176.36,46.92 175.29,47.99 173.04,47.99 172.21,48.82 172.14,48.82 166.59,54.37 166.59,62.76 165.42,63.93 165.42,65.32 164.44,66.3 164.44,69.11 165.19,69.86 165.19,75.36 165.04,75.51 165.04,81.23 164.38,81.89 164.38,93.19 v1(163.87,93.69)
  BOTTOM w0.102: v1(162.98,105.57) 162.25,106.31 160.9,106.31 160.69,106.1 U9.7
BC_INT#_ECE1117: length 115.2
  TOP w0.102: JTP1.10 221.05,25.24 220.67,25.63 220.67,26.48 221.33,27.14 226.03,27.14 227.78,28.89 227.78,33 226.14,34.64 221.1,34.64 ; v1(219.27,33.31) 220.61,34.64 221.1,34.64 221.1,34.64 ; U51.A19 290.76,64.68 v1(290.26,65.18) ; 221.1,34.64 v2(221.04,34.64)
  IN2 w0.122: v1(290.26,65.18) 289.69,64.61 289.69,62.95 289.15,62.41 289.15,61.39 288.71,60.96 287.42,60.96 287,61.38 287,62.43 286.63,62.8 284.4,62.8 282.93,61.33 280.51,61.33 277.64,58.46 277.64,56.77 274.92,54.04 271.86,54.04 270.27,52.45 258.5,52.45 257.83,53.12 255.69,53.12 252.73,50.16 242.71,50.16 240.93,48.39 240.93,47.86 227.47,34.39 220.36,34.39 v1(219.27,33.31)
BC_INT#_ECE5048: length 32
  TOP w0.102: v1(281.16,57.08) 281.16,57.24 281.52,57.6 U51.A42 ; v1(270.95,78.04) 270.47,77.56 U46.A29
  BOTTOM w0.102: v1(281.16,57.08) 281.16,57.23 282.44,58.51 282.44,62.38 282.28,62.54 282.28,63.57 280.74,65.11 280.74,66.38 278.51,68.62 274.38,68.62 272.15,70.84 v2(272.15,74.3) 272.15,76.83 v1(270.95,78.04)
BC_INT#_EMC4021: length 215.3
  TOP w0.102: v1(163.7,105.58) 164.09,105.58 165.54,104.14 v2(165.54,102.27) 165.54,91.89 v1(162.38,88.73) ; U51.A13 v1(294.21,60.6)
  IN2 w0.122: v1(162.38,88.73) 163.37,87.73 163.37,74.79 163.69,74.47 163.69,64.17 164.43,63.43 164.6,63.43 166.09,61.94 166.09,54.17 169.88,50.37 169.88,48.34 170.48,47.75 172.58,47.75 172.83,47.5 175.09,47.5 176.16,46.43 176.55,46.43 177.41,45.56 181.3,45.56 187.65,39.22 191.96,39.22 192.6,38.57 193.72,38.57 197.78,34.51 212.17,34.51 213.91,36.25 218.59,36.25 223.26,40.92 223.26,41.42 232.01,50.18 235.61,50.18 237.52,52.09 237.52,52.86 240.59,55.92 243.31,55.92 244.62,57.24 244.62,58.01 244.94,58.33 252.26,58.33 253.34,59.41 270.19,59.41 276.98,66.2 278.36,66.2 278.6,66.44 288.51,66.44 289.19,65.77 291.15,65.77 293.71,63.22 293.71,61.1 v1(294.21,60.6)
  BOTTOM w0.102: U9.9 162.85,104.74 v1(163.7,105.58) 164.41,106.29 R385.2
BEEP: length 383.3
  TOP w0.102: U51.A16 293.92,62.1 294.2,62.37 v1(294.2,62.57) ; v1(43.02,84.22) 43.02,84.14 v2(43.63,83.53) ; R1120.2 v1(41.32,40.13)
  IN1 w0.084: v1(41.32,40.13) 42.02,40.83 42.02,51.4 45.17,54.54 45.17,71.18 43.9,72.45 43.9,79.28 43.02,80.16 v1(43.02,84.22)
  IN2 w0.122: v1(294.2,62.57) 294.2,63.27 292.37,65.09 292.37,67.95 291.67,68.65 278.03,68.65 276.47,67.09 276.47,66.51 273.11,63.14 269.42,63.14 267.28,61 265.27,61 264.48,61.78 255.36,61.78 252.16,58.58 244.08,58.58 243.5,58 243.5,56.93 242.74,56.17 240.48,56.17 237.27,52.96 237.27,52.2 235.5,50.43 231.81,50.43 223.01,41.63 223.01,41.02 218.49,36.5 213.8,36.5 212.07,34.76 197.88,34.76 193.82,38.82 192.7,38.82 192.06,39.46 187.75,39.46 181.4,45.81 177.52,45.81 176.66,46.67 176.26,46.67 175.19,47.74 172.93,47.74 172.11,48.57 172.04,48.57 166.34,54.27 166.34,62.63 165.17,63.8 165.17,65.17 164.19,66.15 164.19,74.36 164.79,74.96 164.79,81.13 164.07,81.85 164.07,88.24 162.17,90.15 162.17,92.28 160.24,94.2 159.25,94.2 153.56,99.9 137.77,99.9 137.07,100.6 136.21,100.6 135.92,100.89 131.42,100.89 130.43,101.88 112.17,101.88 110.91,100.62 105.92,100.62 103.4,103.15 101.82,103.15 101.44,102.77 101.44,101.46 101,101.01 100.45,101.01 99.7,100.26 99.7,96.41 97.52,94.23 88.78,94.23 87.41,92.85 87.19,92.85 84.26,92.85 76.58,85.18 69.98,85.18 69.4,85.75 67.44,85.75 66.5,86.69 45.48,86.69 v1(43.02,84.22)
BIA_PWM_EC: length 276.1
  TOP w0.102: v1(288.53,61.42) 288.1,61.85 288.1,62.27 288.51,62.68 U51.B25 ; v1(101.26,93.43) 101.26,92.07 v2(103.02,90.32) 105.06,88.27 105.06,86.44 104.04,85.42 D68.2
  IN2 w0.102: 174.55,41.52 172.71,43.37 172.68,43.37
  IN2 w0.122: v1(288.53,61.42) 288.05,61.89 288.05,63.34 288.78,64.07 288.78,65.62 288.23,66.17 281.15,66.17 280.03,65.05 276.76,65.05 270.87,59.16 253.44,59.16 252.36,58.07 245.05,58.07 244.89,57.91 244.89,57.14 242.78,55.04 240.06,55.04 237.77,52.75 237.77,51.99 235.71,49.93 232.12,49.93 223.51,41.32 223.51,40.81 218.69,36 214.01,36 212.27,34.26 198.65,34.26 198.64,34.26 197.67,34.26 193.61,38.32 192.5,38.32 191.85,38.97 187.54,38.97 185.54,40.97 175.11,40.97 174.55,41.52 ; 172.68,43.37 169.63,46.41 169.63,50.04 168.08,51.6 168.08,51.83 165.84,54.06 165.84,58.86 164.84,59.87 164.84,61.6 163.44,63 163.44,74.04 163.12,74.36 163.12,85.77 159.54,89.36 159.54,93.19 153.33,99.4 137.57,99.4 136.86,100.1 136.01,100.1 135.74,100.37 103.97,100.37 v1(103.05,101.28)
  IN3 w0.122: v1(103.05,101.28) 103.05,95.22 v1(101.26,93.43)
BIA_PWM_LVDS: length 6.2
  TOP w0.102: v2(100.57,90.68) LE92.2 100.57,88.11 D66.1 D68.1 103.99,87.62 R1137.1
BIA_PWM_LVDS_L: length 22.8
  TOP w0.102: LE92.1 v2(99.82,93.09) 99.82,93.27 98.33,94.76 v1(98.33,96.43)
  BOTTOM w0.102: v1(98.33,96.43) 97.9,96.85 97.15,96.85 96.34,97.67 96.34,104.69 98.6,106.95 JLVDS1.26
BIA_PWM_PCH: length 130.2
  TOP w0.102: v1(105.49,87.59) v2(105.49,86.79) 105.49,86.44 103.99,84.94 101.55,84.94 D66.2
  IN1 w0.084: v1(106.11,97.67) 106.11,88.21 v1(105.49,87.59)
  IN2 w0.122: v1(164.61,39.75) 164.06,40.29 164.06,41.04 164.57,41.55 164.57,43.56 159.77,48.36 159.77,51.09 160.74,52.05 160.74,58.02 161.38,58.67 161.38,72.32 160.9,72.81 160.9,85.53 157.68,88.76 157.68,92.58 154.69,95.56 148.53,95.56 146.07,98.03 141.74,98.03 141.11,97.4 134.7,97.4 132.97,99.13 108.94,99.13 107.49,97.67 v1(106.11,97.67)
  BOTTOM w0.102: UH4.P45 164.29,40.06 v1(164.61,39.75)
BLUE_CRT: length 225.7
  TOP w0.102: v1(12.32,74.21) 12.32,74.21 C1204.1 R1643.1 ; v1(28.62,81.98) v2(27.95,81.98) 27.65,81.98 27.07,81.39 D77.3 27.07,79.25 26.84,79.02 v1(26.84,78.1)
  IN3 w0.122: v1(129.88,40.24) 130.31,40.68 130.31,55.33 129.6,56.04 129.6,57.24 129.38,57.45 128.64,57.45 128.51,57.58 126.89,57.58 125.98,58.49 125.98,59.41 125.03,60.35 125.03,64.33 125.15,64.45 125.15,64.98 124.82,65.31 124.82,67.46 123.34,68.95 121.82,68.95 121.51,68.63 120.31,68.63 119.66,69.28 118.71,69.28 116.67,71.32 106.18,71.32 97.62,79.89 95.48,79.89 91.72,83.64 91.72,86.05 88.82,88.96 65.36,88.96 64.77,88.37 49.23,88.37 44.45,83.59 34.84,83.59 34.24,84.19 30.51,84.19 28.62,82.29 v1(28.62,81.98) ; v1(26.84,78.1) 26.4,78.55 13.73,78.55 12.49,77.3 12.49,74.38 v1(12.32,74.21)
  IN4 w0.084: v1(165.79,50.28) 165.91,50.39 165.91,52.36 164.78,53.49 161.04,53.49 158,50.44 155.13,50.44 154.65,50.93 150.71,50.93 147.38,47.6 144.86,47.6 143.72,46.45 143.72,44 141.74,42.02 141.74,41.69 140.54,40.5 140.54,39.08 140.11,38.64 134,38.64 132.97,39.67 130.45,39.67 v1(129.88,40.24)
  BOTTOM w0.102: v1(12.32,74.21) 11.6,74.93 L101.1 ; UH4.N48 164.5,41.99 164.5,43.14 165.98,44.62 RH131.2 166.04,45.7 166.53,46.19 166.53,49.54 v1(165.79,50.28)
BOARD_ID: length 11.7
  TOP w0.102: U51.B10 291.97,58.85 v1(291.9,58.78) ; R875.2 C744.1 299.85,59.62 v1(300.13,59.9) v2(300.72,59.9)
  IN1 w0.084: v1(300.13,59.9) 299.28,59.05 294.16,59.05 293.89,58.78 v1(291.9,58.78)
BOOT: length 2.8
  TOP w0.102: v2(35.11,13.08) 34.97,13.22 34.97,14.87 PR1318.1
BOOT1: length 3
  BOTTOM w0.203: PU700.20 147.29,82.64 147.67,82.26 147.67,81.81 PR749.2
BOOT1G: length 1
  BOTTOM w0.102: v2(140.47,80.01) 140.94,80.48 140.94,80.86
BOOT_1.5V: length 1.3
  TOP w0.102: PR200.2 34.79,65.47 v2(34.55,65.71)
BOOT_D: length 6
  TOP w0.102: PD1301.1 36.26,11.04 v2(37,10.3)
  TOP w0.254: PD1301.1 34.75,11.64 34.12,12.28 PC1310.1 34.12,13.4 34.32,13.6 PR1318.2
BPM#6: length 6.3
  BOTTOM w0.102: T107.1 129.86,66.66 128.77,66.66 128.3,66.19 128.3,65.64 127.88,65.22 U1.J59
BPM#7: length 4.4
  BOTTOM w0.102: T127.1 128.85,66.94 128.57,66.94 127.88,66.25 U1.J61
BREATH_LED#: length 181.6
  TOP w0.102: v1(171.6,68.7) v2(169.68,68.7) 167.14,68.7 166.52,68.08 166.52,66.29 166.2,65.97 164.01,65.97 160.61,69.38 160.61,69.91 v1(159.86,70.66) ; v1(266.04,79.21) 266.09,79.26 U46.B39
  IN1 w0.084: v1(171.6,68.7) 171.37,68.47 171.37,63.63 170.88,63.14 170.88,61.67 171.04,61.5 171.04,60.39 172.25,59.19 172.25,52.1 173.74,50.61 181.96,50.61 183.68,48.89 187.8,48.89 191.03,45.66 194.63,45.66 196.5,43.8 196.5,42.79 197.12,42.17 197.12,40.41 199.63,37.89 217.26,37.89 232.28,52.91 232.28,58.44 235.73,61.89 235.73,67.74 235.98,67.99 235.98,71.04 236.26,71.32 236.26,71.92 237.62,73.27 240.26,73.27 244.57,77.58 246.54,77.58 257.31,88.35 265.98,88.35 266.9,87.44 266.9,81.21 266.04,80.35 v1(266.04,79.21)
  BOTTOM w0.102: v1(159.86,70.66) 161.73,68.79 161.73,67.49 R955.1 162.27,65.75 162.26,65.73 Q84.1
BREATH_LED#_Q: length 3.7
  TOP w0.254: JLED1.7 162.75,61.59 162.41,61.25 162.3,61.25 162.13,61.08 v2(160.99,61.08) 160.86,60.96 160.86,60.27 R1733.2
BREATH_WHITE_LED: length 84.4
  IN2 w0.122: v1(159.87,71.31) 159.3,71.88 159.3,81.07 159.84,81.61 159.84,85.05 153.67,91.22 150.54,91.22 147.14,94.62 142.03,94.62 139.5,97.15 134.59,97.15 132.87,98.88 114.15,98.88 v1(113.05,97.77)
  BOTTOM w0.102: JLVDS1.3 110.1,108.62 110.77,107.95 110.77,107.13 112.46,105.44 112.46,102.35 113.05,101.76 v1(113.05,97.77) ; R955.2 162.03,68.09 162.03,69.22 v2(161.09,70.16) 159.95,71.31 v1(159.87,71.31)
BST1_3V: length 3.1
  TOP w0.102: PR107.1 v4(256,7.91)
  TOP w0.508: PR107.1 254.75,8.73 PC108.2
BST1_5V: length 2.7
  TOP w0.102: v4(242.32,8.66) 242.69,9.03 PC109.1
  TOP w0.508: PR108.2 PC109.1
BST_3V:
  vias: v2(252.94,9.13)
BST_5V:
  vias: v2(246.3,8.54)
BST_+V1.05S_VCCPP: length 2.4
  TOP w0.102: 123.26,9.07 124.82,7.5 v2(125.04,7.5)
BST_+V1.05SP:
  vias: v2(154.4,63.78)
BT_ACTIVE: length 242.8
  TOP w0.102: v1(186.11,8.74) v4(186.63,9.27) ; v1(317.58,21.4) JBT1.6
  IN2 w0.122: v1(186.11,8.74) 189.9,8.74 192.95,11.79 197.58,11.79 198.46,12.66 203.04,12.66 204.37,11.33 208.12,11.33 208.54,10.91 210.82,10.91 213.86,13.95 218.16,13.95 222.42,18.21 240.94,18.21 243.8,21.07 268.44,21.07 270.57,23.2 276.13,23.2 279.06,26.13 292.12,26.13 292.73,26.74 315.87,26.74 316.54,26.07 316.54,22.44 v1(317.58,21.4)
  IN3 w0.122: v1(170.46,75.39) 172.04,73.82 172.04,68 171.2,67.16 171.2,61.45 171.4,61.25 171.4,60.41 173.34,58.48 177.21,58.48 189.29,46.4 189.29,42.09 188.75,41.55 188.75,34.96 189.29,34.42 189.29,32.46 190.08,31.66 190.08,26.58 189.31,25.81 189.31,22.54 190.1,21.75 190.1,14.66 188.88,13.44 188.88,10.16 187.47,8.74 v1(186.11,8.74)
  BOTTOM w0.102: R950.1 164.1,69.66 164.24,69.8 Q78.5 164.24,70.67 163.2,71.72 163.2,75.83 163.65,76.27 169.58,76.27 v1(170.46,75.39)
BT_COEX_STATUS2: length 4.7
  TOP w0.102: v4(312.04,19.16) 313.9,19.16 R1708.2 314.95,19.62 315.17,19.4 JBT1.4
BT_DET#: length 198.8
  TOP w0.102: v1(168.63,38.39) 168.63,38.67 168.84,38.88 172.45,38.88 172.94,38.39 176.76,38.39 178.44,36.71 RH328.2 ; v1(298.58,47.1) 297.74,46.26 297.74,40.1 v2(296.55,38.91) 295.75,38.11 295.75,36.95 300.12,32.59 300.12,27.61 310.74,16.99 314.98,16.99 315.39,17.4 JBT1.2
  IN2 w0.102: 174.55,39.52 173.3,39.52 172.24,40.58 171.73,40.58 169.54,38.39 v1(168.63,38.39)
  IN2 w0.122: v1(298.58,47.1) 296.4,47.1 295.24,45.95 286.16,45.95 285.69,46.41 276.21,46.41 275.08,47.54 268.49,47.54 267.61,46.66 258.44,46.66 257.56,47.54 251.73,47.54 248.85,44.66 240.75,44.66 227.51,31.42 195.36,31.42 194.01,32.77 190.36,32.77 188.21,34.92 184.49,34.92 180.66,38.75 179.45,38.75 179.43,38.77 179.13,39.07 177.43,39.07 176.98,39.52 174.55,39.52
  BOTTOM w0.102: UH4.E40 168.31,38.07 v1(168.63,38.39)
BT_LED#: length 37.4
  IN1 w0.084: v1(241.34,64.64) 241.45,64.64 242.76,63.32 242.76,61.44 242.51,61.18 240.24,58.91 240.24,55.41 239.32,54.49 239.32,50.71 240.75,49.28 246.38,49.28 248.52,51.42 v1(248.52,53.3)
  BOTTOM w0.102: v1(241.34,64.64) 241.58,64.88 243.81,64.88 244.6,65.67 JMINI2.46 ; v1(248.52,53.3) 248.13,53.3 v2(247.78,52.96) 247.16,52.33 R1734.1 247.51,51.3 Q126.3
BT_PRI_STATUS: length 4.7
  TOP w0.102: v4(312.07,21.19) 313.8,21.19 R1710.2 315.11,20.63 315.34,20.4 JBT1.5
BT_RADIO_DIS#: length 26.5
  TOP w0.102: v1(255.81,61.31) D93.1 253.98,61.31 R1727.1 ; U46.A13 266.34,69.4 266.78,68.96 266.78,68.41 266.59,68.22 266.59,65.69 267.65,64.64 v1(267.65,64.6) 267.65,64.27 R1729.2 268.79,63.13 v2(269.74,63.13) 270.46,63.13 R1730.1 270.77,64.32 D94.1
  IN4 w0.084: v1(255.81,61.31) 258.4,63.9 266.95,63.9 v1(267.65,64.6)
BT_RADIO_DIS#_CON: length 92.9
  TOP w0.102: v1(272.36,68.64) v2(272.9,68.09) 272.9,65.28 272.43,64.81 272.19,64.81 D94.2 271.68,64.3 R1730.2 ; v1(311.99,22.76) 312.29,22.46 313.92,22.46 C1307.1 315.15,22.03 315.52,22.4 JBT1.7
  IN1 w0.084: v1(311.99,22.76) 310.86,23.89 310.86,43.57 308.65,45.78 308.65,49.45 309.02,49.82 309.02,52.97 308.48,53.52 308.48,59.62 305.96,62.14 305.96,64.41 v1(302.02,68.35)
  IN2 w0.122: v1(302.02,68.35) 301.85,68.35 300.23,69.96 293.53,69.96 292.32,71.17 277.81,71.17 275.28,68.64 v1(272.36,68.64)
BT_RADIO_DIS#_R: length 19.9
  TOP w0.102: D93.2 254.64,60.21 R1727.2 v2(252.2,58.62) 251.86,58.28 v1(251.86,56.36)
  IN1 w0.084: v1(251.86,56.36) 249.17,56.36 248.76,56.77 248.76,58.56 248.42,58.9 243.21,58.9 242.67,58.36 v1(242.67,57.3)
  BOTTOM w0.102: v1(242.67,57.3) 242.6,57.37 JMINI2.51
CAM_MIC_CBL_DET#: length 158.8
  IN3 w0.122: v1(163.86,92.42) 163.1,91.65 163.1,89.81 162.84,89.56 162.84,88.52 162.44,88.11 162.44,74.36 163.57,73.22 163.57,63.75 164.09,63.23 164.09,58.96 164.19,58.86 164.19,56.33 168.21,52.31 168.21,51.67 169.05,50.83 169.05,45.63 171.88,42.81 v1(171.88,42.79)
  IN4 w0.084: v1(163.86,92.42) 163.28,92.99 160.1,92.99 152.89,100.2 150.3,100.2 149.28,101.23 138.39,101.23 137.46,102.15 136.65,102.15 132.47,106.33 117.35,106.33 115.87,104.85 114.54,104.85 113.36,103.66 102.76,103.66 101.91,102.81 v1(101.91,102.04)
  BOTTOM w0.102: UH4.C42 169.78,39.03 170.13,39.03 170.4,39.29 170.62,39.29 171.32,40 171.32,40.51 172.04,41.23 172.04,42.63 v1(171.88,42.79) 171.88,44.04 172.43,44.6 172.43,45.36 RH331.2 173.04,45.7 173.45,45.3 v2(174.02,45.3) ; v1(101.91,102.04) 101.91,97.15 100.44,95.68 97.36,95.68 95.65,97.39 95.65,106.26 94.6,107.31 JLVDS1.34
CAP_INT#: length 196.3
  TOP w0.102: U51.A2 293.73,55.1 294.04,54.79 294.04,54.65 294.5,54.19 297.64,54.19 298,53.83 v1(298,53.63) ; JCAP2.6 142.7,56.99 143.52,57.81 144.84,57.81 145.17,57.48 145.9,57.48 146.3,57.87 146.3,61.03 v1(146.55,61.29) 147.47,62.2 R1743.2 148.75,61.73 149.38,61.73 149.6,61.52 149.6,61.19 148.74,60.32 v4(148.15,60.32)
  IN4 w0.084: v1(146.55,61.29) 147.19,60.65 150.25,60.65 150.59,61 158.28,61 161.74,57.54 163.7,57.54 170.55,50.69 171.33,50.69 172.89,49.13 181.3,49.13 182.51,47.92 182.51,47.29 190.93,38.88 193.77,38.88 198.01,34.63 217.69,34.63 219.68,36.62 230.26,36.62 233.93,40.29 254.61,40.29 256.25,41.93 261.49,41.93 263.39,43.84 268.12,43.84 271.14,46.86 274.52,46.86 275.24,46.13 280.18,46.13 280.9,46.86 282.78,46.86 283.12,46.52 287.88,46.52 288.49,47.13 288.98,47.13 289.73,46.37 295.51,46.37 296.7,47.57 296.7,51.93 298,53.22 v1(298,53.63)
CAP_R_RST#: length 9.2
  TOP w0.102: v3(290.09,67.75) 290.47,67.75 Q127.2 291.56,68.84 R888.2 ; U51.B22 290.01,62.63 289.72,62.34 v1(289.72,62.21)
  IN1 w0.084: v3(290.09,67.75) 289.43,67.08 289.43,62.5 v1(289.72,62.21)
CAP_RST#: length 196.9
  TOP w0.102: v1(288.69,70.04) 288.4,69.75 R1744.1 ; JCAP2.5 143.2,56.88 143.82,57.5 144.71,57.5 145.18,57.03 v1(145.47,57.03) ; v1(290.35,45.37) 290.58,45.15 v2(290.58,44.52)
  IN4 w0.084: v1(290.35,45.37) 289.93,44.96 289.36,44.96 288.66,45.65 286.86,45.65 286.05,44.84 281.25,44.84 280.6,45.48 270.81,45.48 264.33,39 255.07,39 254.41,39.66 234.2,39.66 230.52,35.99 219.94,35.99 217.95,34 197.75,34 193.51,38.24 190.66,38.24 181.77,47.14 181.77,47.76 181.03,48.5 172.63,48.5 171.23,49.89 170.15,49.89 163.35,56.69 161.28,56.69 157.64,60.34 152.06,60.34 149.34,57.62 146.06,57.62 v1(145.47,57.03)
  BOTTOM w0.102: v1(290.35,45.37) 288.59,47.14 288.59,52.7 288.24,53.05 288.24,55.57 289.1,56.42 289.1,65.57 288.02,66.65 288.02,69.36 v1(288.69,70.04)
CAP_SMB_CLK: length 184.6
  TOP w0.102: v4(301.8,50.17) 300.88,51.09 R877.2 v1(300.2,51.39) R841.2 ; v1(145.47,57.92) 145.26,58.14 143.44,58.14 142.2,56.9 JCAP2.7
  IN4 w0.084: v1(300.2,51.39) 300.2,50.36 295.65,45.81 289.48,45.81 289.33,45.96 282.98,45.96 282.57,46.36 281.15,46.36 280.48,45.69 270.73,45.69 264.24,39.21 255.15,39.21 254.49,39.87 234.11,39.87 230.44,36.2 219.85,36.2 217.86,34.21 197.84,34.21 193.6,38.45 190.75,38.45 181.98,47.23 181.98,47.84 181.11,48.71 172.71,48.71 171.15,50.27 170.38,50.27 163.52,57.12 161.46,57.12 158.01,60.57 151.96,60.57 149.31,57.92 v1(145.47,57.92)
CAP_SMB_DAT: length 185.5
  TOP w0.102: R838.2 v1(300.2,52.28) R874.2 300.88,52.65 300.65,52.88 v2(300.65,53.52) ; v1(145.5,58.57) 145.31,58.38 143.2,58.38 141.7,56.88 JCAP2.8
  IN4 w0.084: v1(145.5,58.57) 145.92,58.15 149.24,58.15 151.87,60.79 158.15,60.79 161.6,57.33 163.61,57.33 170.46,50.48 171.24,50.48 172.8,48.92 181.22,48.92 182.26,47.88 182.26,47.24 190.84,38.66 193.68,38.66 197.92,34.42 217.78,34.42 219.76,36.41 230.35,36.41 234.02,40.08 254.9,40.08 256.46,41.64 261.58,41.64 263.5,43.56 268.29,43.56 270.64,45.9 280.31,45.9 281.02,46.61 282.68,46.61 283.02,46.27 287.98,46.27 288.6,46.88 288.87,46.88 289.59,46.16 295.65,46.16 299.76,50.28 299.76,51.85 v1(300.2,52.28)
CARD_SMBCLK: length 10.6
  TOP w0.102: U51.A49 284.26,52.45 v1(283.99,52.18) ; v1(281.45,47.94) 281.25,48.14 281.17,48.14 281.09,48.07 280.88,47.85 278.95,47.85 R589.1
  BOTTOM w0.102: v1(283.99,52.18) 283.99,52.45 283.86,52.58 283.67,52.58 283.56,52.46 283.56,51.97 282.71,51.12 v1(282.71,49.22) 282.71,48.53 282.32,48.14 281.66,48.14 v1(281.45,47.94)
CARD_SMBDAT: length 10.2
  TOP w0.102: v1(283.72,53.11) 284.01,53.39 U51.B52 ; v1(281.45,48.57) 281.3,48.42 281.25,48.37 281.07,48.37 280.78,48.08 v1(279.82,48.08) 278.95,48.08 R590.1
  BOTTOM w0.102: v1(281.45,48.57) 281.66,48.37 282.22,48.37 282.48,48.62 282.48,51.22 283.33,52.07 283.33,52.55 283.72,52.95 v1(283.72,53.11)
CCD_OFF: length 204.2
  TOP w0.102: U46.B43 264.09,79.67 263.83,79.41 263.83,79.05 v1(264.34,78.54) ; v1(154.23,100.68) v2(154.23,101.33)
  IN2 w0.122: v1(154.23,100.68) 154.23,100.28 158.74,95.78 161.34,95.78 161.54,95.58 161.54,94.25 161.71,94.07 162.66,94.07 162.89,94.3 162.89,95.52 163.15,95.78 164.23,95.78 165.44,94.57 165.44,82.25 166.73,80.95 166.73,78.87 166.23,78.37 166.23,68.72 167.14,67.82 167.14,67.07 167.58,66.62 167.58,54.85 173.45,48.99 176.88,48.99 177.44,48.43 177.44,47.65 178.03,47.06 181.96,47.06 187.59,41.43 191.85,41.43 193.22,40.07 194.68,40.07 198.68,36.07 211.61,36.07 213.29,37.74 217.97,37.74 221.76,41.54 221.76,42.14 231.46,51.84 232.92,51.84 234.8,53.72 236.27,53.72 242.62,60.07 250.22,60.07 253.44,63.29 254.44,63.29 255.77,64.62 255.77,68.74 256.61,69.58 257.22,69.58 258.91,71.26 258.91,75.11 258.98,75.18 258.98,78.54 260.16,79.72 263.75,79.72 263.9,79.56 263.9,78.98 v1(264.34,78.54)
  BOTTOM w0.102: v1(154.23,100.68) 151.21,100.68 150.82,101.08 150.82,105.12 153.52,107.82 154.03,107.82 154.31,108.1 Q23.2
CFD_PWRBTN#_XDP: length 12
  TOP w0.102: RC6.2 91,87.31 v2(91,84.96) 91,79.4 89.88,78.28 JXDP1.11
CFG0: length 61
  TOP w0.102: v1(98.03,84.27) 97.23,83.47 95.57,83.47 94.67,84.38 v4(94.67,85.72) 94.67,86.1 RC7.1
  IN1 w0.084: v1(131.41,61.38) 131.41,63.25 130.31,64.35 130.31,71.28 128.26,73.32 128.26,77.47 v1(128.47,77.67)
  IN4 w0.084: v1(98.03,84.27) 98.03,83.57 100.98,80.62 105.54,80.62 106.87,79.29 112.9,79.29 114,78.19 115.44,78.19 116.5,79.26 125.02,79.26 126.61,77.67 v1(128.47,77.67)
  BOTTOM w0.102: U1.B50 v1(131.41,61.38)
CFG2: length 8.1
  BOTTOM w0.102: v2(137.05,66.95) 135.46,66.95 RC51.1 134.7,66.51 132.92,64.73 132.92,63.68 131.87,62.63 131.61,62.63 U1.B54
CFG4: length 5.3
  BOTTOM w0.102: U1.A51 131.82,61 v2(133.48,62.67) 133.62,62.81 133.62,63.75 134.6,64.73 RC52.1
CFG5: length 8.2
  BOTTOM w0.102: U1.C53 131.32,61.87 131.61,62.16 131.7,62.16 132.11,62.57 132.24,62.57 133.22,63.55 133.22,64.32 134.51,65.62 RC54.1 135.46,65.17 v2(137.06,65.17)
CFG6: length 9.3
  BOTTOM w0.102: U1.C55 131.17,62.98 131.49,63.3 132.08,63.3 132.59,63.81 132.59,65.11 134.88,67.4 RC53.1 135.5,67.88 v2(135.5,69.97)
CFG7: length 3.2
  TOP w0.102: v2(127.01,58.91) 127.94,58.91 128.44,59.41 RC56.1 128.44,60.41 v5(128.46,60.43)
  BOTTOM w0.102: v5(128.46,60.43) 128.6,60.29 U1.H49
CHAGER_SRC:
  vias: v1(20.87,26.47) v1(21.38,26.87) v1(21.82,25.18) v1(21.85,24.55) v1(21.82,23.75) v1(21.82,23.07) v1(21.91,26.49) v1(21.86,25.84) v2(23.87,27.71)
CHARGE_EN: length 2.9
  TOP w0.102: U46.A45 261.84,81.31 v2(261,82.14) 260.6,82.55 R3.2
CHARGER_SMBCLK: length 321.2
  TOP w0.102: v1(34.08,23.51) 34.32,23.26 34.32,23.15 34.19,23.01 PU1300.10 ; v1(284.05,54.56) 283.77,54.85 U51.B50 ; v1(282.9,52.35) 282.69,52.14 282.69,51.84 v1(282.12,51.26) 281.84,50.98 281.84,50.59 R828.2
  IN3 w0.122: v1(284.02,16.16) 283.82,16.36 283.82,18.6 283.54,18.89 283.54,28.11 283.43,28.22 283.43,31.21 282.8,31.84 282.8,38.88 283.36,39.43 283.36,43.68 283.1,43.94 283.1,44.34 283.83,45.07 283.83,49.72 282.7,50.85 282.7,52.15 v1(282.9,52.35) 282.7,52.54 282.7,54.36 282.91,54.56 v1(284.05,54.56)
  IN4 w0.084: v1(34.08,23.51) 34.28,23.7 34.28,24.57 34.66,24.96 43.85,24.96 46.43,22.38 46.43,18.1 52.17,12.37 76.95,12.37 79.99,15.41 94.02,15.41 95.1,14.32 98.42,14.32 99.35,15.25 112.56,15.25 113.79,16.48 128.48,16.48 133.24,11.72 146.7,11.72 147.23,12.25 154.24,12.25 161.61,4.87 178.19,4.87 179.28,5.96 189.92,5.96 190.85,6.89 192.35,6.89 193.43,7.97 201.57,7.97 205.72,12.12 205.72,12.69 207.48,14.45 210.17,14.45 210.67,13.95 211.91,13.95 212.99,15.04 237.59,15.04 241.83,19.28 267.19,19.28 268.41,18.07 282.86,18.07 283.83,17.1 283.83,16.35 v1(284.02,16.16)
CHARGER_SMBDAT: length 320.1
  TOP w0.102: v3(34.71,23.51) 34.55,23.34 34.55,23.14 34.69,23 PU1300.9 ; v1(282.26,52.35) 282.47,52.14 282.47,51.93 281.61,51.07 281.61,50.55 R827.2 ; U51.A47 282.14,55.1 v1(281.81,54.77)
  IN3 w0.122: v1(283.38,16.16) 283.57,16.35 283.57,18.5 283.29,18.78 283.29,28.01 283.18,28.12 283.18,31.11 282.55,31.74 282.55,38.98 283.11,39.54 283.11,43.58 282.85,43.84 282.85,44.44 283.58,45.18 283.58,49.62 282.45,50.75 282.45,52.15 v1(282.26,52.35) 282.46,52.54 282.46,54.62 282.31,54.77 v1(281.81,54.77)
  IN4 w0.084: v1(283.38,16.16) 283.62,16.4 283.62,17.01 282.77,17.86 268.32,17.86 267.11,19.07 241.92,19.07 237.68,14.83 213.08,14.83 211.99,13.74 210.58,13.74 210.08,14.24 207.57,14.24 205.93,12.61 205.93,12.04 201.66,7.76 193.51,7.76 192.43,6.68 190.93,6.68 190.01,5.75 179.37,5.75 178.28,4.66 161.53,4.66 154.15,12.04 147.32,12.04 146.79,11.5 133.16,11.5 128.39,16.27 113.87,16.27 112.64,15.04 99.44,15.04 98.51,14.11 95.02,14.11 93.93,15.2 80.08,15.2 77.04,12.16 52.08,12.16 46.22,18.02 46.22,22.3 43.76,24.75 34.75,24.75 34.49,24.49 34.49,23.73 v3(34.71,23.51)
CHG_LGATE: length 8.5
  IN1 w1.016: 28.19,18.55 28.17,18.54 25.67,18.54 24.16,17.03 20.36,17.03
  vias: v1(18.95,16.89) v1(19.59,16.89) v1(29.62,18.87) v1(30.26,18.87) v2(18.75,17.7)
CHG_UGATE: length 9.1
  IN4 w1.016: 32.11,16.14 30.76,16.14 25.62,21.28 25.62,21.8
  vias: v1(25.32,22.97) v1(25.98,22.98) v1(33.18,16.6) v1(33.18,15.96) v2(26.17,23.72)
CLK_80H: length 5.3
  BOTTOM w0.102: UH4.H47 167.13,41.79 166.83,42.1 166.83,42.45 166.83,42.45 166.83,43.05 168.84,45.06 RH314.2
CLK_BUF_BCLK: length 5
  BOTTOM w0.102: UH4.BG30 UH4.BJ30 146.85,32.99 v2(144.63,32.99) 144.63,32.99 RH91.1
CLK_BUF_CKSSCD: length 7.6
  IN3 w0.122: v1(155.74,21.14) 156.01,20.88 156.01,19.99 153.81,17.8 153.81,17.39 v3(153.62,17.2)
  BOTTOM w0.102: v1(155.74,21.14) 155.96,21.14 UH4.AK5 ; v3(153.62,17.2) 153.78,17.04 153.78,15.69 RH79.1
CLK_BUF_CKSSCD#: length 7.7
  IN3 w0.122: v1(154.25,17.2) 154.06,17.39 154.06,17.7 156.25,19.89 156.25,20.8 v3(156.66,21.21)
  BOTTOM w0.102: v1(154.25,17.2) 154.04,16.99 154.04,15.76 RH78.1 ; v3(156.66,21.21) 156.36,21.5 UH4.AK7
CLK_BUF_DMI: length 4.7
  TOP w0.102: v1(149.43,27.47) 149.43,27.47 148.94,27.96 148.69,27.96 v1(147.79,28.87) 147.52,29.14 147.52,29.5 147.15,29.87 146.84,29.87 RH75.1
  BOTTOM w0.102: v1(149.43,27.47) 149.11,27.15 UH4.BE18
CLK_BUF_DMI#: length 4.7
  TOP w0.102: v3(148.79,27.47) 148.79,27.49 147.6,28.68 147.25,29.03 147.25,29.39 147.04,29.6 146.51,29.6 146.41,29.5 146.41,29.36 RH74.1
  BOTTOM w0.102: v3(148.79,27.47) 148.79,27.14 148.65,27 UH4.BF18
CLK_BUF_DOT96: length 1.7
  TOP w0.102: v3(168.01,29.52) 168.06,29.57 RH77.1
  BOTTOM w0.102: v3(168.01,29.52) 168.01,29.54 168.31,29.84 UH4.E24
CLK_BUF_DOT96#: length 1.7
  TOP w0.102: RH76.1 167.18,29.7 v1(167.35,29.52)
  BOTTOM w0.102: v1(167.35,29.52) 167.68,29.85 UH4.G24
CLK_CPU_DMI: length 31.1
  IN1 w0.084: v3(152.62,28.53) 152.27,28.88 147.74,28.88 145.19,31.43 145.18,31.43 145.06,31.56 145.06,31.62 145.05,31.63 145.05,31.64
  IN1 w0.091: 145.05,31.64 145.05,32.01 144.19,32.88 140.61,32.88 137.47,36.01 131.47,36.01 130.03,34.57 129.65,34.57 v1(129.43,34.35)
  BOTTOM w0.102: U1.J3 128.16,36.62 128.16,36.4 128.44,36.12 128.44,35.78 128.55,35.67 128.55,34.96 128.96,34.56 129.22,34.56 v1(129.43,34.35) ; UH4.AU22 153,28.91 v3(152.62,28.53)
CLK_CPU_DMI#: length 31
  IN1 w0.084: v1(152.63,29.37) 152.36,29.1 152.36,29.1 152.35,29.09 147.83,29.09 145.27,31.64
  IN1 w0.091: 145.27,31.64 145.27,32.1 144.28,33.09 140.7,33.09 137.56,36.23 131.38,36.23 129.94,34.78 129.63,34.78 v3(129.43,34.98)
  BOTTOM w0.102: v1(152.63,29.37) 152.63,29.18 152.44,28.98 UH4.AV22 ; U1.H2 128.43,36.56 128.43,36.67 128.54,36.77 128.69,36.77 128.86,36.61 128.86,36.3 128.7,36.14 128.7,35.89 128.82,35.78 128.82,35.07 129.07,34.83 129.27,34.83 v3(129.43,34.98)
CLK_CPU_ITP: length 22.1
  IN1 w0.091: v3(156.67,25.08) 156.49,24.9 156.49,24.24 155.84,23.59 155.47,23.59 154.47,22.59 154.47,22.31 153.34,21.18 149.83,21.18 145.18,16.53 144.48,16.53 144.12,16.17 143.66,16.17 142.75,17.09 141.91,17.09 v1(141.7,16.88)
  BOTTOM w0.102: RH109.2 142,17.05 141.87,17.05 v1(141.7,16.88) 141.53,17.04 141.39,17.04 RH107.2 ; UH4.AK13 156.24,24.87 156.45,25.08 v3(156.67,25.08)
CLK_CPU_ITP#: length 22.1
  IN1 w0.091: v1(155.75,25.07) 156.14,25.07 156.28,24.92 156.28,24.33 155.75,23.8 155.38,23.8 154.25,22.68 154.25,22.4 153.25,21.4 149.74,21.4 145.09,16.75 144.39,16.75 144.03,16.39 143.75,16.39 142.83,17.3 141.91,17.3 v3(141.7,17.51)
  BOTTOM w0.102: RH108.2 142.01,17.31 141.9,17.31 v3(141.7,17.51) 141.5,17.31 141.38,17.31 RH106.2 ; v1(155.75,25.07) 156.11,25.43 UH4.AK14
CLK_DDC_CRT: length 251
  IN3 w0.122: v3(163.87,91.78) 163.35,91.25 163.35,89.69 163.14,89.48 163.14,88.4 162.68,87.95 162.68,74.52 164.06,73.14 164.06,66.47 165.05,65.48 165.05,61.96 164.67,61.58 164.67,59.66 165.23,59.1 165.23,55.64 168.46,52.41 168.46,51.77 169.3,50.93 169.3,46.19 172.82,42.68 178.11,42.68 180.47,40.31 180.47,37.44 180.22,37.19 179.68,37.19 v1(179.14,37.73)
  IN4 w0.084: v3(163.87,91.78) 164.32,92.22 164.32,92.64 163.71,93.24 160.15,93.24 152.94,100.45 150.35,100.45 149.36,101.44 138.48,101.44 137.55,102.36 136.74,102.36 132.54,106.56 117.05,106.56 115.58,105.1 114.44,105.1 113.25,103.91 102.66,103.91 101.29,102.54 101.29,101.52 99.45,99.68 95.98,99.68 95.4,99.1 94.61,99.1 87.8,92.29 81.79,92.29 80.48,90.98 77.66,90.98 76.52,92.11 72.94,92.11 71.62,90.79 68.08,90.79 64.6,87.3 42.47,87.3 39.55,84.39 29.92,84.39 27.57,82.04 27.57,80 24.65,77.07 21.82,77.07 21.37,77.53 12.92,77.53 12.78,77.39 11.18,77.39 8.59,79.98 JCRT1.15
  BOTTOM w0.102: R1645.2 7.93,80.41 JCRT1.15 ; QH6.6 v1(179.14,37.73)
CLK_KBD: length 2.4
  TOP w0.102: R845.2 280.72,59.7 v2(281.44,59.7) 281.54,59.6 U51.A38
CLK_MSE: length 2.4
  TOP w0.102: U51.A39 282.23,59.1 281.96,59.37 280.55,59.37 R851.2
CLK_PCH_14M: length 3.3
  TOP w0.102: RH183.1 165.85,40.9 v2(165.88,40.9) 166.15,40.64 166.15,40.29 v1(166.64,39.8)
  BOTTOM w0.102: v1(166.64,39.8) 166.37,40.06 UH4.K45
CLK_PCI_5048: length 157.3
  TOP w0.102: U46.A28 270.6,77.06 271.14,76.51 273.96,76.51 274.41,76.97 274.41,77.95 R795.1 273.83,78.24 v1(273.47,77.89)
  IN3 w0.122: v1(235.27,65.16) 235.9,64.54 235.9,61.12 230.28,55.51 230.28,47.41 220.76,37.88 215.01,37.88 208.98,43.91 195.17,43.91 194.16,44.92 192.21,44.92 190.66,46.47 v1(190.66,47.62)
  BOTTOM w0.102: RH160.2 169.59,46.82 169.59,47.14 169.79,47.34 CH110.1 169.31,48.53 169.31,49.4 169.59,49.68 171.79,49.68 173.16,48.31 175.16,48.31 176.24,47.23 181.67,47.23 182.81,48.37 187.72,48.37 188.47,47.62 v1(190.66,47.62) ; v1(235.27,65.16) 235.22,65.21 235.22,66.53 235.55,66.86 235.55,67.64 238.05,70.14 240.94,70.14 242.58,71.78 242.58,79.18 244.12,80.73 255.54,80.73 256.28,79.99 257.03,79.99 259.72,77.3 261.44,77.3 261.84,77.71 266.25,77.71 266.55,78.01 266.55,79.72 266.86,80.02 v2(270.54,80.02) 271.34,80.02 v1(273.47,77.89)
CLK_PCI_LOOPBACK: length 31.2
  TOP w0.102: RH105.2 164.63,43.66 161.38,43.66 161.26,43.79 161.26,43.98 161.38,44.1 163.7,44.1 163.82,44.23 163.82,44.42 163.7,44.55 160.37,44.55 160.24,44.68 160.24,44.88 160.37,45.01 163.62,45.01 163.75,45.14 163.75,45.36 163.62,45.49 160.37,45.49 160.24,45.62 160.24,45.83 160.37,45.96 v2(162.69,45.96) 164.15,45.96 164.28,45.83 164.28,44.55 164.41,44.42 166.08,44.42 166.86,43.65 CH111.1 168,41.35 168,40.79 v1(167.59,40.38)
  BOTTOM w0.102: v1(167.59,40.38) 167.27,40.06 UH4.H45
CLK_PCI_MEC: length 136
  TOP w0.102: RH102.2 CH109.1 v2(172.81,45.73) 173.25,45.73 v1(173.47,45.96) ; v1(285.03,65.43) 285.03,65.86 285.39,66.21 R885.1 285.74,65.81 285.51,65.58 285.51,64.46 285.76,64.22 U51.A29
  IN1 w0.084: v1(173.47,45.96) 174.14,46.62 181.74,46.62 183.83,44.53 v1(187.99,44.53)
  IN4 w0.084: v1(285.03,65.43) 283.63,64.03 283.63,62.67 282.77,61.81 280.52,61.81 279.9,62.43 276.92,62.43 276.36,61.88 273.53,61.88 270.39,58.74 253.56,58.74 252.83,58.01 249.23,58.01 247.73,56.51 245.24,56.51 242.99,54.26 237.98,54.26 236.48,52.77 233.08,52.77 216.9,36.59 198.81,36.59 190.87,44.53 v1(187.99,44.53)
CLK_PCI_TPM_TCM: length 134.2
  TOP w0.102: v1(170.83,48.31) 170.58,48.05 CH112.1
  IN4 w0.084: v1(170.83,48.31) 171.39,47.75 174.91,47.75 175.38,47.28 180.67,47.28 190.58,37.37 193.42,37.37 197.47,33.33 218.66,33.33 220.65,35.31 230.81,35.31 234.48,38.98 254.13,38.98 254.79,38.32 264.67,38.32 265.18,38.83 v1(273.2,38.83)
  BOTTOM w0.102: RH311.1 170.74,47.06 171.1,47.42 171.1,48.04 v1(170.83,48.31) ; U39.21 U37.21 268.79,51.53 268.93,51.4 RE5.1 270.9,50.89 271.94,50.89 v4(272.24,50.58) 272.31,50.52 273.83,50.52 274.11,50.24 274.11,47.77 273.2,46.86 v1(273.2,38.83)
CLK_PCIE_LAN: length 181.9
  TOP w0.102: U31.44 283.46,80.93 283.41,80.88 282.96,80.88 v1(282.84,81)
  IN1 w0.091: v1(279.31,39.4) 279.31,39.4 279.53,39.61 279.53,39.87 279.4,39.99 272.61,39.99 271.02,38.4 254.86,38.4 253.71,39.55 239.1,39.55 232.08,32.53 219.57,32.53 218.17,31.14 199.41,31.14 191.33,39.22 190.21,39.22 187.36,42.07 183.78,42.07 182.07,43.79 175.92,43.79 174.95,44.75 168.48,44.75 167.71,43.98 165.82,43.98 165.41,43.57 164.1,43.57 163.69,43.98 161.95,43.98 161.82,43.85 160.14,43.85 159.94,43.66 159.94,43.28 159.7,43.03 159.3,43.03 159.24,42.97 v3(159.24,42.8)
  IN3 w0.122: v1(279.31,39.4) 279.51,39.59 279.51,40.14 278.74,40.9 278.74,41.57 277.49,42.82 277.49,48.18 278.28,48.97 278.28,56.49 278.97,57.17 278.97,64 277.76,65.2 277.76,76.86 281.67,80.77 282.62,80.77 v1(282.84,81)
  BOTTOM w0.102: UH4.AB47 160.01,41.57 160.01,41.95 159.36,42.61 159.36,42.68 v3(159.24,42.8)
CLK_PCIE_LAN#: length 181.8
  TOP w0.102: v3(282.84,80.36) 283.09,80.61 283.38,80.61 283.46,80.53 U31.45
  IN1 w0.091: v1(159.24,43.43) 159.42,43.25 159.61,43.25 159.73,43.37 159.73,43.74 160.05,44.07 161.73,44.07 161.86,44.2 163.77,44.2 164.18,43.79 165.32,43.79 165.73,44.2 167.62,44.2 168.39,44.97 175.04,44.97 176.01,44 182.15,44 183.87,42.28 187.45,42.28 190.3,39.43 191.42,39.43 199.5,31.35 218.08,31.35 219.48,32.74 231.99,32.74 239.01,39.76 253.8,39.76 254.94,38.62 270.93,38.62 272.52,40.21 279.49,40.21 279.74,39.96 279.74,39.44 279.79,39.4 v1(279.95,39.4)
  IN3 w0.122: v3(282.84,80.36) 282.68,80.52 281.77,80.52 278.01,76.76 278.01,65.3 279.21,64.1 279.21,57.07 278.53,56.38 278.53,48.87 277.74,48.08 277.74,42.92 278.99,41.67 278.99,41.01 279.75,40.24 279.75,39.59 v1(279.95,39.4)
  BOTTOM w0.102: UH4.AB49 160.06,42.28 159.64,42.7 159.64,43.33 159.54,43.43 v1(159.24,43.43)
CLK_PCIE_MINI1: length 150.6
  IN1 w0.084: v1(160.72,37.14) 160.72,37.19 160.95,37.42 161.19,37.42 161.48,37.71 161.48,38.66 161.8,38.98 162.87,38.98 163.23,39.34 163.23,40 163.68,40.46 164.1,40.46 165.1,41.46 168,41.46 168.46,41.93 169.21,41.93 169.21,41.93 169.46,41.93 169.46,41.93 169.49,41.93
  IN1 w0.091: v3(295.13,36.3) 295.32,36.49 295.32,36.77 295.07,37.02 284.73,37.02 283.85,37.89 278.92,37.89 277.29,36.27 270.4,36.27 269.23,35.1 264.76,35.1 264.32,34.66 260.64,34.66 260.35,34.94 237.4,34.94 231.26,28.8 198.22,28.8 189.86,37.16 189.36,37.16 186.57,39.95 182.83,39.95 181.69,41.08 175.1,41.08 174.26,41.93 169.49,41.93
  BOTTOM w0.102: v1(160.72,37.14) 161.11,37.52 UH4.Y39 ; v3(295.13,36.3) 295.34,36.1 295.34,35.78 295,35.44 JMINI1.13
CLK_PCIE_MINI1#: length 150.9
  IN1 w0.084: 169.49,42.14 169.47,42.14 169.46,42.14 169.13,42.14 169.13,42.13 168.38,42.13 167.91,41.67 165.02,41.67 164.01,40.66 163.59,40.66 163.02,40.09 163.02,39.43 162.78,39.19 161.72,39.19 161.28,38.75 161.28,37.8 161.11,37.63 160.89,37.63 160.69,37.83 v3(160.69,37.83)
  IN1 w0.091: v1(295.77,36.3) 295.53,36.54 295.53,36.86 295.15,37.23 284.82,37.23 283.94,38.11 278.83,38.11 277.2,36.48 270.31,36.48 269.14,35.32 264.67,35.32 264.23,34.87 260.72,34.87 260.44,35.15 237.31,35.15 231.17,29.01 198.31,29.01 189.95,37.37 189.45,37.37 186.65,40.16 182.91,40.16 181.78,41.3 175.19,41.3 174.35,42.14 169.49,42.14
  BOTTOM w0.102: JMINI1.11 295.8,35.54 295.61,35.74 295.61,36.15 v1(295.77,36.3) ; v3(160.69,37.83) 161.02,38.16 UH4.Y40
CLK_PCIE_MINI2: length 136.7
  IN1 w0.084: 169.31,42.84 169.3,42.82 169.3,42.82 169.25,42.78 169.14,42.78 169.14,42.78 168.43,42.78 167.77,42.12 164.81,42.12 164.28,41.59 162.51,41.59 162.34,41.41 162.34,40.68 162.5,40.52 v1(162.67,40.52)
  IN1 w0.091: 169.31,42.84 169.83,43.36 171.95,43.36 172.68,42.62 174.53,42.62 174.83,42.31 181.48,42.31 183.15,40.64 186.85,40.64 189.64,37.85 190.15,37.85 198.23,29.76 218.74,29.76 220.13,31.16 232.65,31.16 237.11,35.62 262.41,35.62 262.51,35.52 263.38,35.52 v3(263.56,35.34)
  IN3 w0.122: v1(261.08,56.62) 261.28,56.43 261.28,44.39 262.47,43.2 262.47,35.97 262.91,35.53 263.37,35.53 v3(263.56,35.34)
  BOTTOM w0.102: v1(162.67,40.52) 162.36,40.52 UH4.V46 ; v1(261.08,56.62) 261.27,56.81 261.27,57.28 261,57.55 JMINI2.13
CLK_PCIE_MINI2#: length 136.9
  IN1 w0.084: 169.16,42.99 169.14,42.99 169.14,42.98 168.34,42.98 167.68,42.33 164.73,42.33 164.19,41.79 162.43,41.79 162.13,41.5 162.13,40.62 161.9,40.38 v3(161.71,40.38)
  IN1 w0.091: 169.16,42.99 169.75,43.57 172.04,43.57 172.77,42.83 174.61,42.83 174.92,42.53 181.56,42.53 183.24,40.85 186.94,40.85 189.73,38.06 190.24,38.06 198.32,29.98 218.65,29.98 220.05,31.37 232.56,31.37 237.02,35.84 262.5,35.84 262.6,35.74 263.31,35.74 v1(263.56,35.98)
  IN3 w0.122: v1(263.56,35.98) 263.35,35.77 263.01,35.77 262.72,36.07 262.72,43.3 261.53,44.49 261.53,56.43 v1(261.72,56.62)
  BOTTOM w0.102: v1(261.72,56.62) 261.53,56.81 261.53,57.28 261.8,57.55 JMINI2.11 ; UH4.V45 161.86,40.38 v3(161.71,40.38)
CLK_PCIE_MMI: length 154.8
  TOP w0.102: U38.2 277.88,15.1 277.77,15.22 277.45,15.22 276.45,16.22 275.79,16.22 273.41,18.59 273.41,20.71 273.83,21.12 273.83,21.77 v3(273.62,21.98)
  IN1 w0.091: v1(275.61,37.14) 275.81,37.34 275.81,37.48 275.71,37.58 275.08,37.58 275,37.66 254.21,37.66 253,38.86 239.38,38.86 232.36,31.84 219.85,31.84 218.46,30.45 198.51,30.45 190.43,38.53 189.93,38.53 187.13,41.32 183.48,41.32 181.81,43 175.15,43 174.09,44.06 168.75,44.06 167.99,43.3 166.12,43.3 165.7,42.87 163.83,42.87 163.4,43.3 162.75,43.3 162.04,42.59 160.9,42.59 160.65,42.85 160.52,42.85 v1(160.42,42.75)
  IN3 w0.122: v3(273.62,21.98) 273.79,22.16 273.79,24.23 274.15,24.59 274.15,35.09 275.8,36.74 275.8,36.95 v1(275.61,37.14)
  BOTTOM w0.102: UH4.AA47 160.69,41.35 160.32,41.73 160.32,41.91 160.52,42.12 160.52,42.64 v1(160.42,42.75)
CLK_PCIE_MMI#: length 154.6
  TOP w0.102: v1(274.25,21.98) 274.09,21.82 274.09,21.01 273.68,20.6 273.68,18.7 275.9,16.48 276.56,16.48 277.56,15.48 277.74,15.48 277.85,15.6 U38.1
  IN1 w0.091: v1(276.24,37.14) 276.02,37.37 276.02,37.57 275.8,37.79 275.16,37.79 275.09,37.87 254.29,37.87 253.09,39.08 239.29,39.08 232.27,32.06 219.76,32.06 218.37,30.66 198.6,30.66 190.52,38.74 190.01,38.74 187.22,41.54 183.57,41.54 181.89,43.21 175.24,43.21 174.18,44.27 168.66,44.27 167.91,43.51 166.04,43.51 165.61,43.09 163.91,43.09 163.49,43.51 162.66,43.51 161.95,42.81 160.99,42.81 160.42,43.38 v3(160.42,43.38)
  IN3 w0.122: v1(274.25,21.98) 274.04,22.19 274.04,24.13 274.39,24.49 274.39,34.99 276.05,36.64 276.05,36.95 v1(276.24,37.14)
  BOTTOM w0.102: UH4.AA48 160.69,41.91 160.82,42.04 160.82,42.97 v3(160.42,43.38)
CLK_SIO_14M: length 147.5
  TOP w0.102: v1(273.41,78.75) 272.29,78.75 R794.1 270.06,79.22 269.9,79.06 U46.A32
  IN1 w0.084: v1(272.83,82.06) 272.83,79.33 v1(273.41,78.75)
  IN3 w0.122: v1(236.5,73.43) 236.33,73.25 236.33,72.02 236.14,71.83 236.14,67.52 235.01,66.39 235.01,65.72 234.8,65.52 234.8,64.73 235.01,64.53 235.01,61.15 229.61,55.75 229.61,48.14 220.08,38.62 215.17,38.62 209.24,44.55 195.51,44.55 194.51,45.55 192.66,45.55 v1(191.17,47.05)
  IN4 w0.084: v1(236.5,73.43) 241.32,73.43 242.52,72.22 245.32,72.22 247.74,74.65 247.74,78.38 251.87,82.51 256.61,82.51 257.6,83.5 271.39,83.5 v1(272.83,82.06)
  BOTTOM w0.102: v1(191.17,47.05) 190.9,46.78 187.88,46.78 187.61,47.05 183.44,47.05 v2(183.17,46.78) 182.86,46.47 176.03,46.47 174.8,47.7 172.9,47.7 172.74,47.86 172.36,47.86 171.93,47.43 171.93,46.85 RH313.1
CLK_TP_SIO: length 80.8
  TOP w0.102: v1(281.74,60.21) 281.86,60.1 U51.A37 ; L55.2 223.23,30.84 R902.2 C751.1 220.83,31.32 220.53,31.62 v2(220.53,32.17) 220.66,32.29 221.42,32.29 221.84,32.71 v1(221.84,33.32)
  IN2 w0.122: v1(221.84,33.32) 222.66,34.14 227.57,34.14 241.18,47.76 241.18,48.26 242.84,49.92 252.84,49.92 255.76,52.84 257.74,52.84 258.39,52.19 270.38,52.19 271.99,53.79 275.02,53.79 277.89,56.66 277.89,58.35 279.13,59.59 281.12,59.59 v1(281.74,60.21)
CLK_XDP: length 121.9
  TOP w0.102: JXDP1.14 88.72,76.78 88.61,76.67 88.08,76.67 84.75,73.34 84.75,67.45 85.52,66.68 91.28,66.68 91.8,66.16 91.8,63.8 89.37,61.37 89.37,25.67 87.23,23.52 87.23,21.37 v1(87.04,21.19)
  IN3 w0.122: v3(139.49,16.86) 139.29,17.05 138.35,17.05 137.82,17.59 134.54,17.59 132.86,19.27 124.63,19.27 123.94,19.96 109.05,19.96 108.06,20.95 96.42,20.95 95.87,20.41 87.5,20.41 87.24,20.66 87.24,20.98 v1(87.04,21.19)
  BOTTOM w0.102: v3(139.49,16.86) 139.67,17.04 139.78,17.04 RH107.1
CLK_XDP#: length 121.1
  TOP w0.102: v3(87.67,21.19) 87.49,21.37 87.49,23.41 89.49,25.41 89.64,25.56 89.64,61.26 92.07,63.69 92.07,66.27 91.39,66.95 85.63,66.95 85.02,67.56 85.02,73.23 88.19,76.4 88.6,76.4 88.73,76.28 JXDP1.15
  IN3 w0.122: v1(139.49,17.5) 139.29,17.3 138.45,17.3 137.92,17.83 134.64,17.83 132.96,19.51 124.73,19.51 124.04,20.21 109.16,20.21 108.17,21.2 96.31,21.2 95.77,20.65 87.6,20.65 87.49,20.77 87.49,21 v3(87.67,21.19)
  BOTTOM w0.102: v1(139.49,17.5) 139.68,17.31 139.78,17.31 RH106.1
CLK_XDP_ITP: length 83.7
  IN3 w0.102: 147.55,34.1 147.56,34.1 147.57,34.09 151.8,34.09 152.16,33.73 152.16,33.31 152.42,33.06 153.65,33.06 154.02,32.69 154.02,32.23 154.66,31.58 154.66,26.13 154.15,25.61 152.49,25.61 152.21,25.89 151.68,25.89 151.38,25.59 151.38,25.2 151.06,24.88 148.36,24.88 147.54,24.06 147.54,24 147.55,23.99 147.55,23.97 ; v5(125.91,65.31) 126.14,65.31 126.3,65.46 126.78,65.46 127.33,64.91 127.33,64.23 127.02,63.92 127.02,59.83 127.22,59.62 130.01,59.62 130.45,59.17 130.45,58.36 130.56,58.26 130.56,57.08 130.46,56.98 130.46,56.41 131.53,55.34 131.53,54.33 131.54,54.32 131.54,54.3
  IN3 w0.122: 131.54,54.3 131.54,38.04 133.71,35.87 137.6,35.87 139.37,34.1 147.55,34.1 ; v3(143.9,16.87) 144.09,17.06 145.12,17.06 147.55,19.5 147.55,23.97
  BOTTOM w0.102: v3(143.9,16.87) 143.72,17.04 143.6,17.04 RH109.1 ; v5(125.91,65.31) 125.64,65.31 125.57,65.23 125.57,64.9 125.67,64.8 U1.N59
CLK_XDP_ITP#: length 83.7
  IN3 w0.102: 147.55,33.86 147.56,33.86 147.57,33.87 151.71,33.87 151.94,33.63 151.94,33.22 152.33,32.83 153.55,32.83 153.79,32.59 153.79,32.13 154.43,31.49 154.43,26.22 154.05,25.84 152.59,25.84 152.31,26.12 151.59,26.12 151.15,25.68 151.15,25.29 150.97,25.11 148.26,25.11 147.32,24.16 147.32,24 147.31,23.99 147.31,23.97 ; 131.29,54.3 131.29,54.32 131.3,54.33 131.3,55.25 130.23,56.31 130.23,57.08 130.33,57.17 130.33,58.16 130.23,58.27 130.23,59.08 129.91,59.39 127.13,59.39 126.79,59.73 126.79,64.02 127.1,64.33 127.1,64.82 126.68,65.24 126.39,65.24 126.05,64.89 126.05,64.7 126.16,64.59 126.34,64.59 v5(126.54,64.78)
  IN3 w0.122: 147.55,33.86 139.27,33.86 137.5,35.63 133.6,35.63 131.29,37.94 131.29,54.3 ; 147.31,23.97 147.31,19.6 145.02,17.31 144.09,17.31 v1(143.9,17.5)
  BOTTOM w0.102: v1(143.9,17.5) 143.7,17.31 143.6,17.31 RH108.1 ; U1.N58 125.85,64.19 126.44,64.78 v5(126.54,64.78)
CLKRUN#: length 201.2
  TOP w0.102: v1(268,72.32) 268.01,72.31 U46.B20 ; U51.A32 284.26,64.07 284.12,64.22 282.23,64.22 281.83,63.81 v1(281.01,63.81)
  IN1 w0.084: v1(268,72.32) 268.64,71.68 270.9,71.68 276.09,66.5 277.13,66.5 279.4,64.24 280.58,64.24 v1(281.01,63.81)
  IN2 w0.122: v1(164.39,17) 165.54,15.85 169.01,15.85 174.89,9.97 178.63,9.97 179.17,9.43 187.65,9.43 190.05,11.83 191.42,11.83 191.87,12.28 197.33,12.28 198.2,13.16 203.24,13.16 204.57,11.83 211.4,11.83 213.76,14.2 218.06,14.2 222.32,18.46 240.84,18.46 243.7,21.32 267.87,21.32 v1(270.61,24.06)
  IN3 w0.122: v1(268,72.32) 268.2,72.32 271.2,69.32 271.2,67.22 271.39,67.03 271.39,64.02 272.04,63.37 272.04,59.6 270.79,58.35 v1(270.79,56.47) 269.91,55.59 269.91,48.8 272.99,45.72 272.99,43.44 271.18,41.63 271.18,40.42 269.47,38.71 269.47,25.2 v1(270.61,24.06)
  BOTTOM w0.102: RH137.2 165.11,16.01 165.11,16.53 v2(164.93,16.7) 164.68,16.7 164.39,17 v1(164.39,17) 164.39,17.34 164.68,17.63 164.68,18.61 164.96,18.89 164.96,19.29 164.66,19.6 UH4.N3 ; U39.15 U37.15 268.67,55.43 269.72,56.47 v1(270.79,56.47)
CODEC_CAP2: length 3
  TOP w0.254: C965.1 28.72,42.87 v2(29.27,42.33) 29.64,41.96 U72.22
CODEC_VN: length 2.5
  TOP w0.254: U72.34 27.24,35.66 27.08,35.5 v2(26.6,35.5) C964.1
CODEC_VREF: length 3.7
  TOP w0.254: U72.21 30.14,41.74 30.28,41.88
  TOP w0.508: 30.28,41.88 30.49,42.09 v2(31.41,42.09) 31.83,42.5 C966.1
CODEC_VREG: length 3.9
  TOP w0.254: U72.37 28.64,33.53 28.28,33.17
  TOP w0.508: 28.28,33.17 27.83,32.73 v2(26.52,32.73) C963.1
COEX1_BT_ACTIVE: length 3.3
  TOP w0.102: JBT1.3 315.07,18.4 314.8,18.66 R702.1 v2(314.36,17.55)
COEX2_WLAN_ACTIVE: length 110.3
  TOP w0.102: v1(296.22,37.12) 297.88,35.46 v2(297.9,35.46) 300.67,32.69 300.67,28.08 304.5,24.24 313.92,24.24 R1709.1 C1306.1 315.04,22.92 315.52,23.4 JBT1.8
  IN1 w0.084: v1(256.53,39.76) 257.21,39.08 270.74,39.08 273.8,42.14 278.99,42.14 282.22,38.91 284.26,38.91 284.98,38.19 295.15,38.19 v1(296.22,37.12)
  IN3 w0.122: v1(256.53,39.76) 256.1,40.19 256.1,41.58 256.57,42.05 256.57,46.6 256.92,46.95 256.92,47.76 256.7,47.99 256.7,57.02 v1(257.17,57.49)
  BOTTOM w0.102: R700.1 C600.1 270.08,64.89 269.64,64.45 269.64,63.62 267.7,61.68 266.1,61.68 265.47,61.06 260.39,61.06 258.67,59.33 258.67,57.82 258.34,57.49 v1(257.17,57.49)
COMP: length 5.8
  TOP w0.102: v1(149.56,81.95) v2(148.9,81.95)
  TOP w0.254: v1(149.56,81.95) 149.56,82.43 149.86,82.73 PR742.1
  BOTTOM w0.203: PC723.1 148.19,82.75 147.5,83.44 PU700.18
  BOTTOM w0.254: v1(149.56,81.95) PC727.1 148.74,82.7 PC723.1
CONTACTLESS_DET#: length 6.1
  BOTTOM w0.102: UH4.C40 169.71,37.89 169.77,37.83 170.14,37.83 170.38,37.59 170.66,37.59 170.69,37.61 v2(172.81,37.61) 174,36.43 RH256.2
CPU1.5V_S3_GATE: length 230.2
  TOP w0.102: v1(277.27,61.9) 277.74,61.43 279.88,61.43 R889.2 280.62,61.91 281.94,60.6 U51.A36 ; RC79.1 104.48,9.94 105.66,9.94 106.55,10.83 v2(106.55,12.09) 106.55,12.83 v1(106.89,13.17)
  IN2 w0.122: v1(277.27,61.9) 276.27,61.9 274.6,60.23 274.6,56.11 272.88,54.38 271.75,54.38 271.65,54.28 251.02,54.28 247.2,50.45 242.64,50.45 240.68,48.5 240.68,47.96 227.36,34.64 214.45,34.64 212.8,33 196.92,33 v1(194.15,35.77)
  IN3 w0.122: v1(194.15,35.77) 189.78,35.77 189.27,35.27 189.27,34.79 189.7,34.37 189.7,32.43 190.33,31.79 190.33,26.38 189.62,25.66 189.62,22.62 190.39,21.84 190.39,14.6 189.13,13.33 189.13,10.05 186.69,7.62 178.65,7.62 177.81,8.47 175.2,8.47 174.94,8.2 161.32,8.2 159.15,10.37 154.3,10.37 153.8,9.87 147.27,9.87 146.55,10.6 140.67,10.6 139.99,11.27 131.94,11.27 130.13,13.09 127.1,13.09 126.25,13.93 116.95,13.93 115.74,12.72 110.4,12.72 109.44,13.68 107.39,13.68 v1(106.89,13.17)
CPU_DETECT#: length 312.2
  TOP w0.102: U46.A3 261.34,69.41 260.47,68.54 v1(260.47,68.52) R763.2 ; v2(130.24,63.94) 130.43,63.75 v5(130.43,63.29)
  IN1 w0.084: v1(94.57,96.35) 95.06,95.86 95.06,84.74 97.26,82.53 110.82,82.53 113.03,80.32 115.4,80.32 117.16,78.56 125.67,78.56 126.35,77.88 126.35,71.67 126.68,71.35 126.68,70.19 126.19,69.71 126.19,67.46 125.24,66.51 125.24,65.38 126.85,63.77 126.85,62.67 127,62.52 127,62.25 127.26,61.99 129.13,61.99 v5(130.43,63.29)
  IN2 w0.122: v1(94.57,96.35) 94.57,99.22 100.35,105 103.33,105 105.73,102.6 134.92,102.6 136.42,101.1 137.28,101.1 137.98,100.4 153.76,100.4 159.4,94.76 160.47,94.76 161.41,93.82 162.76,93.82 163.14,94.2 163.14,95.22 163.44,95.52 164.14,95.52 165.19,94.47 165.19,82.14 166.49,80.84 166.49,78.98 165.98,78.47 165.98,68.46 166.89,67.55 166.89,66.97 167.34,66.52 167.34,54.75 173.35,48.74 176.78,48.74 177.2,48.33 177.2,47.54 177.93,46.81 181.86,46.81 187.48,41.18 191.75,41.18 193.11,39.82 194.25,39.82 198.25,35.82 211.72,35.82 213.39,37.49 218.07,37.49 222.01,41.43 222.01,42.04 231.56,51.59 233.03,51.59 234.88,53.45 236.35,53.45 240.18,57.27 241.16,57.27 243.46,59.57 251.75,59.57 255.06,62.89 259.62,62.89 260.18,63.45 260.18,68.23 v1(260.47,68.52)
  BOTTOM w0.102: U1.C57 130.58,63.43 v5(130.43,63.29)
CPU_DPLL: length 4.2
  BOTTOM w0.102: U1.AG3 119.2,36.59 118.85,36.24 118.85,34.1 v2(119.02,33.93) 119.12,33.83 RC16.1
CPU_DPLL#: length 3.6
  BOTTOM w0.102: RC17.1 119.72,33.19 119.72,34.22 119.2,34.74 U1.AG1
CPU_VTT_ON: length 209
  TOP w0.102: U46.B17 268.09,70.35 268.47,69.97 v1(268.47,68.58) 268.47,68.33 R789.2 ; v1(193.6,40.8) v4(193.13,40.33)
  TOP w0.254: PR503.1 127.49,7.93 v1(127.14,7.58)
  IN1 w0.084: v1(193.6,40.8) 193.6,40.64 198.67,35.57 218.22,35.57 240.03,57.38 240.03,59 242.55,61.52 242.55,63.24 241.76,64.03 241.36,64.03 240.83,64.56 240.83,66.16 242.97,68.3 242.97,69.29 243.56,69.88 254.02,69.88 254.64,69.26 257.72,69.26 258.59,70.13 263.09,70.13 263.51,69.72 263.51,69.02 263.17,68.69 263.17,68.34 263.7,67.81 267.71,67.81 v1(268.47,68.58)
  IN3 w0.122: v1(127.14,7.58) 127.14,7.6 130.56,11.02 139.89,11.02 140.56,10.35 146.45,10.35 147.22,9.57 154.12,9.57 155.24,8.46 157.26,8.46 158.54,7.17 171.04,7.17 171.38,6.83 174.05,6.83 175.34,5.54 177.39,5.54 178.59,6.73 187.06,6.73 190.01,9.69 190.01,12.57 192.41,14.97 192.41,18.41 195.74,21.74 195.74,38.67 v1(193.6,40.8)
CRT_IREF: length 2.4
  TOP w0.102: v2(163.49,40.38) 163.67,40.2 v1(163.67,39.78) 163.88,39.78 164.25,39.4 RH126.1
  BOTTOM w0.102: v1(163.67,39.78) 163.32,39.43 UH4.T43
CS_1.5V: length 3
  TOP w0.203: PR201.2 38.47,68.72 v2(38.47,67.9) 38.47,67.42 38.41,67.35 PU200.13
CSSN_1: length 3.8
  TOP w0.254: PR1305.1 21.49,55.6 PR1303.1 21.18,55.92 21.18,57.24 21.37,57.43 PR1301.2
CSSP_1: length 3.7
  TOP w0.254: PR1304.1 20.54,55.64 PR1303.2 20.8,55.92 20.8,57.17 20.54,57.43 PR1301.3
D_CLKRUN#: length 12.6
  TOP w0.102: U46.A19 270.29,72.56 270.43,72.41 271.37,72.41 271.83,72.88 v2(276.24,72.88) 277.89,72.88 R777.2
D_DLDRQ1#: length 15.6
  TOP w0.102: R782.2 277.78,75.68 277.08,74.98 v2(275.05,74.98) 272.22,74.98 271.45,74.21 v1(271.04,74.21) ; v1(267.37,74.75) 267.8,74.32 268.26,74.32 268.28,74.31 U46.B24
  IN1 w0.084: v1(271.04,74.21) 270.6,74.65 269.94,74.65 269.41,75.18 267.46,75.18 267.37,75.09 v1(267.37,74.75)
