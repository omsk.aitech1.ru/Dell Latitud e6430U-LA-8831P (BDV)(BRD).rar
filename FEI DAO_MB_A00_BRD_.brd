# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D19: length 68.7
  IN1 w0.084: v3(104.66,39.69) 104.66,39.65 103.23,38.23 101.95,38.23 97.1,33.38 74.66,33.38 73.78,32.5 66.48,32.5 65.3,31.33 57.6,31.33 57.48,31.45 57.48,32.06 57.35,32.18 56.53,32.18 56.43,32.28 56.43,32.42 56.53,32.51 57.29,32.51 57.38,32.61 57.38,32.75 57.29,32.85 55.87,32.85 54.87,33.85 53.08,33.85 v1(52.22,34.71)
  BOTTOM w0.102: v1(52.22,34.71) 52.74,35.22 53.88,35.22 54.25,34.85 JDIMM2.53 ; v3(104.66,39.69) 104.66,39.91 105.74,40.99 108.71,40.99 108.95,41.23 109.49,41.23 U1.BF12
DDR_B_D20: length 69.1
  IN1 w0.084: v3(61.12,29.65) 67.16,29.65 68.11,30.6 72.46,30.6 73.22,29.85 73.51,29.85 73.59,29.93 73.59,30.5 73.69,30.6 73.83,30.6 73.93,30.5 73.93,29.93 74.01,29.85 74.18,29.85 74.26,29.93 74.26,30.5 74.36,30.6 74.5,30.6 74.6,30.5 74.6,29.93 74.68,29.85 74.85,29.85 74.93,29.93 74.93,30.05 75.02,30.13 75.18,30.13 75.27,30.05 75.27,29.93 75.35,29.85 82.01,29.85 82.1,29.93 82.1,31.27 82.2,31.37 82.33,31.37 82.43,31.27 82.43,29.93 82.52,29.85 82.68,29.85 82.77,29.93 82.77,31.27 82.87,31.37 83.01,31.37 83.1,31.27 83.1,29.93 83.19,29.85 83.36,29.85 83.44,29.93 83.44,31.27 83.54,31.37 83.68,31.37 83.77,31.27 83.77,29.93 83.86,29.85 84.03,29.85 84.11,29.93 84.11,30.35 84.21,30.45 84.35,30.45 84.44,30.35 84.44,29.93 84.53,29.85 85.64,29.85 87.16,31.37 97.76,31.37 103.52,37.12 104.93,37.12 105.49,37.68 105.49,38.1 105.81,38.42 106.27,38.42 v1(106.69,38.01)
  BOTTOM w0.102: JDIMM2.40 62.14,30.95 61.12,29.93 v3(61.12,29.65) ; U1.BF8 109.33,39.09 108.72,39.09 107.64,38.01 v1(106.69,38.01)
DDR_B_D21: length 69.3
  IN1 w0.084: v3(59.6,29.65) 60.03,30.08 65.71,30.08 66.52,30.89 74.62,30.89 74.71,30.97 74.71,31.5 74.79,31.58 74.96,31.58 75.04,31.5 75.04,30.52 75.14,30.42 75.28,30.42 75.38,30.52 75.38,31.5 75.46,31.58 75.63,31.58 75.71,31.5 75.71,30.23 75.81,30.13 75.95,30.13 76.05,30.23 76.05,31.5 76.13,31.58 76.3,31.58 76.38,31.5 76.38,30.23 76.48,30.13 76.62,30.13 76.72,30.23 76.72,31.5 76.8,31.58 76.97,31.58 77.05,31.5 77.05,30.61 77.15,30.51 77.29,30.51 77.39,30.61 77.39,30.76 77.51,30.89 78.58,30.89 79.35,31.65 97.44,31.65 104.39,38.6 105.45,38.6 105.46,38.61 106.19,38.61 v1(107.27,39.69)
  BOTTOM w0.102: U1.BD10 110.28,40.36 107.94,40.36 v1(107.27,39.69) ; v3(59.6,29.65) 60.29,30.34 60.86,30.34 62.07,31.55 JDIMM2.42
DDR_B_D22: length 67.5
  IN1 w0.084: v1(61.12,32.37) 61.12,32.84 61,32.96 59.47,32.96 59.35,33.08 59.35,33.25 59.47,33.36 62,33.36 62.08,33.45 62.08,33.68 62.16,33.76 62.33,33.76 62.42,33.68 62.42,33.45 62.5,33.36 62.67,33.36 62.75,33.45 62.75,33.68 62.84,33.76 63,33.76 63.09,33.68 63.09,33.45 63.17,33.36 63.34,33.36 63.42,33.45 63.42,33.68 63.51,33.76 63.67,33.76 63.76,33.68 63.76,33.45 63.84,33.36 64.01,33.36 64.09,33.45 64.09,33.68 64.18,33.76 64.34,33.76 64.43,33.68 64.43,33.45 64.51,33.36 64.68,33.36 64.76,33.45 64.76,33.68 64.85,33.76 65.01,33.76 65.1,33.68 65.1,33.45 65.18,33.36 65.35,33.36 65.43,33.45 65.43,33.68 65.52,33.76 65.69,33.76 65.77,33.68 65.77,33.45 65.85,33.36 66.02,33.36 66.1,33.45 66.1,33.68 66.19,33.76 66.36,33.76 66.44,33.68 66.44,33.45 66.52,33.36 66.69,33.36 66.77,33.45 66.77,33.68 66.86,33.76 67.03,33.76 67.11,33.68 67.11,33.45 67.19,33.36 67.36,33.36 67.45,33.45 67.45,33.68 67.53,33.76 67.7,33.76 67.78,33.68 67.78,33.45 67.86,33.36 68.03,33.36 68.12,33.45 68.12,33.68 68.2,33.76 68.37,33.76 68.45,33.68 68.45,33.45 68.54,33.36 68.7,33.36 68.79,33.45 68.79,33.68 68.87,33.76 69.04,33.76 69.12,33.68 69.12,33.45 69.21,33.36 73.43,33.36 74.3,34.24 96.55,34.24 101.45,39.14 102.45,39.14 103.63,40.32 104.77,40.32 105.84,41.4 106.71,41.4 v3(106.98,41.67)
  BOTTOM w0.102: v1(61.12,32.37) 61.12,32.88 62.2,33.95 JDIMM2.50 ; v3(106.98,41.67) 107.65,42.34 110.28,42.34 U1.BD14
DDR_B_D23: length 68.7
  IN1 w0.084: v1(107.63,41.67) 107.18,41.21 105.92,41.21 104.83,40.12 103.89,40.12 103.62,39.85 103.62,39.47 102.98,38.84 101.55,38.84 96.67,33.95 74.42,33.95 73.54,33.08 64.32,33.08 64.24,32.99 64.24,32.02 64.14,31.92 64,31.92 63.91,32.02 63.91,32.99 63.82,33.08 63.65,33.08 63.57,32.99 63.57,32.02 63.47,31.92 63.33,31.92 63.23,32.02 63.23,32.99 63.15,33.08 62.98,33.08 62.9,32.99 62.9,32.02 62.8,31.92 62.66,31.92 62.56,32.02 62.56,32.99 62.48,33.08 62.31,33.08 62.23,32.99 62.23,32.02 62.13,31.92 61.99,31.92 61.89,32.02 61.89,32.95 61.79,33.06 61.65,33.06 61.55,32.95 61.55,32.06 61.42,31.94 60.03,31.94 v3(59.6,32.37)
  BOTTOM w0.102: U1.BE13 109.58,42.14 108.1,42.14 v1(107.63,41.67) ; JDIMM2.52 61.67,34.55 59.6,32.48 v3(59.6,32.37)
DDR_B_D24: length 65.3
  IN1 w0.084: v1(52.22,37.25) 52.65,36.82 56.42,36.82 57.62,35.62 61.01,35.62 61.7,34.92 73.48,34.92 73.86,35.3 76.76,35.3 77.46,36.01 96.81,36.01 101.08,40.27 102.09,40.27 102.96,41.14 104.01,41.14 v3(104.67,41.79)
  BOTTOM w0.102: U1.BF16 109,43.25 108.76,43.01 105.76,43.01 104.67,41.93 v3(104.67,41.79) ; JDIMM2.57 53.42,36.05 v1(52.22,37.25)
DDR_B_D25: length 66
  IN1 w0.084: v3(104.02,41.79) 103.82,41.59 103.11,41.59 102.09,40.58 100.98,40.58 96.69,36.29 72.87,36.29 72.53,35.95 70.01,35.95 69.69,35.63 61.41,35.63 61.11,35.92 58.41,35.92 58.3,36.02 58.3,37.91 58.18,38.03 57.92,38.03 57.79,37.91 57.79,36.4 57.66,36.27 57.37,36.27 57.24,36.4 57.24,37.12 57.12,37.25 v1(53.75,37.25)
  BOTTOM w0.102: U1.BE17 109.62,43.81 109.27,43.46 108.87,43.46 108.67,43.25 105.38,43.25 104.02,41.9 v3(104.02,41.79) ; v1(53.75,37.25) 53.75,37.03 54.12,36.65 JDIMM2.59
DDR_B_D26: length 63.5
  IN1 w0.084: v1(53.75,38.77) 53.75,39.08 53.87,39.21 54.13,39.21 54.22,39.13 54.22,38.72 54.32,38.63 54.45,38.63 54.55,38.72 54.55,39.13 54.64,39.21 54.8,39.21 54.89,39.13 54.89,38.72 54.99,38.63 55.12,38.63 55.22,38.72 55.22,39.13 55.31,39.21 55.47,39.21 55.56,39.13 55.56,39.02 55.66,38.92 55.8,38.92 55.89,39.02 55.89,39.13 55.98,39.21 62.02,39.21 62.28,38.95 73.28,38.95 73.48,39.15 96.69,39.15 100.27,42.74 102.14,42.74 103.61,44.2 104.78,44.2 v3(105.29,43.7)
  BOTTOM w0.102: v1(53.75,38.77) 54.03,39.05 JDIMM2.67 ; v3(105.29,43.7) 106.48,44.89 108.95,44.89 109.03,44.98 109.31,44.98 109.62,44.67 U1.BE18
DDR_B_D27: length 64.6
  IN1 w0.084: v3(103.96,43.7) 103.37,43.7 102.1,42.43 100.38,42.43 99.17,41.22 96.81,38.87 73.78,38.87 73.58,38.66 62.13,38.66 61.89,38.91 56.19,38.91 55.62,38.34 52.65,38.34 v1(52.22,38.77)
  BOTTOM w0.102: JDIMM2.69 53.1,39.65 v1(52.22,38.77) ; U1.BE21 109.63,45.78 109.31,45.46 108.94,45.46 108.8,45.32 105.41,45.32 103.96,43.87 v3(103.96,43.7)
DDR_B_D28: length 65.2
  IN1 w0.084: v3(105.33,41.79) 104.46,40.93 103.13,40.93 102.16,39.96 101.17,39.96 96.93,35.72 87.24,35.72 87.16,35.63 87.16,35.54 87.07,35.45 86.9,35.45 86.82,35.54 86.82,35.63 86.74,35.72 86.57,35.72 86.49,35.63 86.49,35.1 86.4,35.02 86.23,35.02 86.15,35.1 86.15,35.62 86.07,35.71 85.9,35.71 85.82,35.62 85.82,35.1 85.73,35.02 85.56,35.02 85.48,35.1 85.48,35.62 85.4,35.71 85.23,35.71 85.14,35.62 85.14,35.1 85.06,35.02 84.89,35.02 84.81,35.1 84.81,35.62 84.73,35.71 84.56,35.71 84.47,35.62 84.47,35.1 84.39,35.02 84.22,35.02 84.14,35.1 84.14,35.62 84.05,35.71 83.89,35.71 83.8,35.62 83.8,35.1 83.72,35.02 83.55,35.02 83.47,35.1 83.47,35.62 83.38,35.71 83.22,35.71 83.13,35.62 83.13,35.1 83.05,35.02 82.88,35.02 82.8,35.1 82.8,35.62 82.71,35.71 82.55,35.71 82.46,35.62 82.46,35.1 82.38,35.02 82.21,35.02 82.13,35.1 82.13,35.62 82.04,35.71 81.88,35.71 81.79,35.62 81.79,35.1 81.71,35.02 81.54,35.02 81.46,35.1 81.46,35.62 81.37,35.71 81.21,35.71 81.12,35.62 81.12,35.1 81.04,35.02 73.98,35.02 73.6,34.64 61.39,34.64 v1(61.12,34.91)
  BOTTOM w0.102: U1.BE14 109.64,42.7 109.33,43 109.03,43 108.82,42.78 106.31,42.78 v3(105.33,41.79) ; JDIMM2.56 62.12,35.75 61.27,34.91 v1(61.12,34.91)
DDR_B_D29: length 64.9
  IN1 w0.084: v1(105.98,41.79) 104.91,40.73 103.46,40.73 102.38,39.65 101.27,39.65 96.35,34.73 91.83,34.73 91.75,34.81 91.75,35.27 91.66,35.35 91.5,35.35 91.41,35.27 91.41,34.81 91.33,34.73 91.16,34.73 91.08,34.81 91.08,35.27 90.99,35.35 90.83,35.35 90.74,35.27 90.74,34.81 90.66,34.73 90.49,34.73 90.41,34.81 90.41,35.27 90.32,35.35 90.15,35.35 90.07,35.27 90.07,34.81 89.99,34.73 89.82,34.73 89.74,34.81 89.74,35.27 89.65,35.35 89.48,35.35 89.4,35.27 89.4,34.81 89.32,34.73 89.15,34.73 89.06,34.81 89.06,35.27 88.98,35.35 88.81,35.35 88.73,35.27 88.73,34.81 88.65,34.73 88.48,34.73 88.39,34.81 88.39,35.24 88.29,35.34 88.15,35.34 88.05,35.24 88.05,34.83 87.96,34.73 87.82,34.73 87.72,34.83 87.72,35.27 87.64,35.35 87.47,35.35 87.39,35.27 87.39,34.81 87.3,34.73 74.1,34.73 73.72,34.35 60.16,34.35 v3(59.6,34.91)
  BOTTOM w0.102: v3(59.6,34.91) 60.55,35.86 61.74,35.86 62.24,36.35 JDIMM2.58 ; U1.BG14 109.01,42.54 106.73,42.54 v1(105.98,41.79)
DDR_B_D30: length 63
  IN1 w0.084: v3(105.9,43.7) 105.12,42.92 103.12,42.92 102.02,41.82 100.58,41.82 96.21,37.45 88.14,37.45 88.09,37.5 88.09,37.95 88.01,38.03 87.85,38.03 87.72,37.91 87.72,37.54 87.64,37.45 87.47,37.45 87.39,37.54 87.39,37.86 87.3,37.94 87.13,37.94 87.05,37.86 87.05,37.54 86.97,37.45 86.8,37.45 86.71,37.54 86.71,37.86 86.63,37.94 86.46,37.94 86.38,37.86 86.38,37.54 86.3,37.45 86.13,37.45 86.04,37.54 86.04,37.86 85.96,37.94 85.79,37.94 85.71,37.86 85.71,37.54 85.63,37.45 85.46,37.45 85.37,37.54 85.37,37.86 85.29,37.94 85.12,37.94 85.04,37.86 85.04,37.54 84.95,37.45 84.79,37.45 84.7,37.54 84.7,37.86 84.62,37.94 84.45,37.94 84.37,37.86 84.37,37.54 84.28,37.45 84.12,37.45 84.03,37.54 84.03,37.86 83.95,37.94 83.78,37.94 83.7,37.86 83.7,37.54 83.61,37.45 83.45,37.45 83.36,37.54 83.36,37.86 83.28,37.94 83.11,37.94 83.03,37.86 83.03,37.54 82.94,37.45 82.78,37.45 82.69,37.54 82.69,37.86 82.61,37.94 82.44,37.94 82.36,37.86 82.36,37.54 82.27,37.45 82.1,37.45 82.02,37.54 82.02,37.86 81.94,37.94 81.77,37.94 81.69,37.86 81.69,37.54 81.6,37.45 81.43,37.45 81.35,37.54 81.35,37.86 81.27,37.94 81.1,37.94 81.02,37.86 81.02,37.54 80.93,37.45 74.57,37.45 74.07,37.96 v1(61.12,37.96)
  BOTTOM w0.102: U1.BG18 106.87,44.67 v3(105.9,43.7) ; v1(61.12,37.96) 61.12,38.11 62.36,39.35 JDIMM2.68
DDR_B_D31: length 62.4
  IN1 w0.084: v1(104.61,43.69) 104.06,43.14 103.07,43.14 102.06,42.13 100.48,42.13 96.93,38.58 77.6,38.58 77.52,38.49 77.52,37.99 77.42,37.89 77.28,37.89 77.18,37.99 77.18,38.49 77.1,38.58 76.93,38.58 76.84,38.49 76.84,37.98 76.75,37.88 76.61,37.88 76.51,37.98 76.51,38.49 76.43,38.58 76.26,38.58 76.17,38.49 76.17,38 76.08,37.91 75.94,37.91 75.84,38 75.84,38.49 75.76,38.58 75.59,38.58 75.5,38.49 75.5,37.99 75.41,37.89 75.27,37.89 75.17,37.99 75.17,38.49 75.08,38.58 74.13,38.58 73.92,38.38 61.99,38.38 61.76,38.6 60.24,38.6 v3(59.6,37.96)
  BOTTOM w0.102: v1(104.61,43.69) 106.01,45.09 108.86,45.09 108.99,45.23 U1.BF19 ; v3(59.6,37.96) 61.59,39.95 JDIMM2.70
DDR_B_D32: length 67.6
  IN1 w0.084: v3(52.22,60.55) 52.71,61.04 53.75,61.04 56.23,63.52 61.98,63.52 62.11,63.64 66.09,63.64 66.38,63.36 98.51,63.36 98.6,63.28 98.6,62.58 98.68,62.5 98.85,62.5 98.93,62.58 98.93,63.28 99.01,63.36 99.18,63.36 99.27,63.28 99.27,62.58 99.35,62.5 99.56,62.5 99.64,62.58 99.64,63.2 99.73,63.28 99.9,63.28 99.98,63.2 99.98,62.58 100.06,62.5 103.33,62.5 v1(104.42,61.41)
  BOTTOM w0.102: JDIMM2.129 52.73,60.05 v3(52.22,60.55) ; v1(104.42,61.41) 105.39,60.43 108.76,60.43 109.06,60.13 110.29,60.13 U1.BD50
DDR_B_D33: length 69.3
  IN1 w0.084: v3(53.75,60.55) 55.55,62.36 63.42,62.36 63.85,62.78 65.74,62.78 66.03,62.49 88.24,62.49 89.48,61.24 96.92,61.24 97.32,61.64 97.55,61.64 97.64,61.55 97.64,60.91 97.73,60.82 97.87,60.82 97.97,60.91 97.97,61.55 98.05,61.64 98.22,61.64 98.31,61.55 98.31,60.9 98.4,60.8 98.54,60.8 98.64,60.9 98.64,61.55 98.72,61.64 98.94,61.64 99.03,61.54 99.03,60.9 99.14,60.79 99.29,60.79 99.4,60.9 99.4,61.54 99.48,61.63 99.65,61.63 99.73,61.54 99.73,60.88 99.83,60.78 99.97,60.78 100.07,60.88 100.07,61.54 100.15,61.63 100.32,61.63 100.4,61.54 100.4,60.89 100.5,60.79 100.64,60.79 100.74,60.89 100.74,61.54 100.82,61.63 100.99,61.63 101.07,61.54 101.07,60.88 101.17,60.78 101.31,60.78 101.41,60.88 101.41,61.54 101.49,61.63 101.66,61.63 101.74,61.54 101.74,60.82 101.88,60.68 106.33,60.68 v1(107.21,59.8)
  BOTTOM w0.102: v1(107.21,59.8) 107.94,59.06 U1.BF48 ; JDIMM2.131 53.84,60.65 v3(53.75,60.55)
DDR_B_D34: length 65.7
  IN1 w0.084: v1(52.22,64.15) 53.14,65.07 58.1,65.07 59.74,66.71 68.22,66.71 69.41,67.89 72.94,67.89 74.22,66.6 85.12,66.6 85.76,65.96 100.49,65.96 101.91,64.54 103.15,64.54 v3(103.55,64.13)
  BOTTOM w0.102: JDIMM2.141 52.72,63.65 v1(52.22,64.15) ; v3(103.55,64.13) 103.55,64.08 105.36,62.28 108.36,62.28 108.71,61.93 109.43,61.93 109.5,61.86 110.42,61.86 U1.BD53
DDR_B_D35: length 67.2
  IN1 w0.084: v3(53.75,64.15) 53.75,63.47 53.87,63.35 54.2,63.35 54.32,63.47 54.32,64.63 54.45,64.76 61.58,64.76 61.97,65.14 68.55,65.14 69.78,66.37 72.97,66.37 73.6,65.74 84.76,65.74 85.98,64.52 86.34,64.52 86.43,64.61 86.43,65.02 86.51,65.1 86.68,65.1 86.76,65.02 86.76,64.61 86.85,64.52 87.01,64.52 87.1,64.61 87.1,65.02 87.18,65.1 87.35,65.1 87.43,65.02 87.43,64.61 87.52,64.52 87.68,64.52 87.77,64.61 87.77,65.02 87.85,65.1 88.02,65.1 88.1,65.02 88.1,64.61 88.19,64.52 88.35,64.52 88.44,64.61 88.44,65.02 88.52,65.1 88.69,65.1 88.77,65.02 88.77,64.61 88.86,64.52 89.03,64.52 89.11,64.61 89.11,64.78 89.21,64.88 89.35,64.88 89.44,64.78 89.44,64.61 89.53,64.52 100.49,64.52 101.35,63.66 102.78,63.66 103.08,63.36 106.51,63.36 106.99,62.88 v1(106.99,61.64)
  BOTTOM w0.102: v3(53.75,64.15) 53.85,64.25 JDIMM2.143 ; U1.BF52 109.51,61.07 107.56,61.07 v1(106.99,61.64)
DDR_B_D36: length 69.9
  IN1 w0.084: v3(59.8,62.78) 60.24,63.21 63.47,63.21 63.61,63.36 65.98,63.36 66.26,63.07 92.73,63.07 92.81,62.99 92.81,62.3 92.9,62.21 93.07,62.21 93.15,62.3 93.15,62.99 93.23,63.07 93.4,63.07 93.48,62.99 93.48,62.3 93.57,62.21 93.74,62.21 93.82,62.3 93.82,62.99 93.9,63.07 94.11,63.07 94.2,62.99 94.2,62.3 94.28,62.21 94.45,62.21 94.53,62.3 94.53,62.99 94.62,63.07 94.79,63.07 94.87,62.99 94.87,62.3 94.95,62.21 95.12,62.21 95.2,62.3 95.2,62.99 95.29,63.07 95.46,63.07 95.54,62.99 95.54,62.3 95.62,62.21 95.79,62.21 95.88,62.3 95.88,62.99 95.96,63.07 96.13,63.07 96.21,62.99 96.21,62.3 96.29,62.21 96.46,62.21 96.55,62.3 96.55,62.99 96.63,63.07 96.8,63.07 96.88,62.99 96.88,62.3 96.96,62.21 97.13,62.21 97.22,62.3 97.22,62.99 97.3,63.07 97.47,63.07 97.55,62.99 97.55,62.3 97.64,62.21 97.8,62.21 97.89,62.3 97.89,62.99 97.97,63.07 98.18,63.07 98.31,62.95 98.31,62.34 98.44,62.21 102.98,62.21 v1(103.78,61.41)
  BOTTOM w0.102: v1(103.78,61.41) 104.96,60.22 108.64,60.22 108.93,59.93 110.33,59.93 U1.BD49 ; JDIMM2.130 63.4,60.35 62.26,60.35 62.18,60.42 62.18,60.73 60.71,62.21 60.37,62.21 v3(59.8,62.78)
DDR_B_D37: length 68.7
  IN1 w0.084: v1(107.83,59.79) 107.83,59.82 106.64,61.01 102.21,61.01 102.09,61.14 102.09,61.8 101.96,61.92 97.1,61.92 96.97,61.8 96.97,61.7 96.85,61.58 96.68,61.58 96.56,61.7 96.56,61.83 96.46,61.92 96.32,61.92 96.23,61.83 96.23,61.63 96.13,61.53 95.99,61.53 95.89,61.63 95.89,61.84 95.81,61.92 95.6,61.92 95.5,61.83 95.5,61.63 95.4,61.53 95.26,61.53 95.16,61.63 95.16,61.8 95.04,61.92 94.83,61.92 94.75,61.84 94.75,61.61 94.67,61.53 94.5,61.53 94.41,61.61 94.41,61.84 94.33,61.92 94.16,61.92 94.08,61.84 94.08,61.61 94,61.53 93.83,61.53 93.74,61.61 93.74,61.84 93.66,61.92 93.49,61.92 93.41,61.84 93.41,61.61 93.32,61.53 93.16,61.53 93.07,61.61 93.07,61.84 92.99,61.92 92.78,61.92 92.73,61.87 92.73,61.65 92.61,61.53 92.44,61.53 92.32,61.65 92.32,62.7 92.24,62.79 92.07,62.79 91.99,62.7 91.99,61.63 91.89,61.53 91.75,61.53 91.65,61.63 91.65,62.7 91.57,62.79 91.4,62.79 91.32,62.7 91.32,61.63 91.22,61.53 91.08,61.53 90.98,61.63 90.98,62.7 90.9,62.79 90.73,62.79 90.65,62.7 90.65,61.63 90.55,61.53 90.41,61.53 90.31,61.63 90.31,62.7 90.23,62.79 90.02,62.79 89.93,62.7 89.93,61.63 89.83,61.53 89.69,61.53 89.6,61.63 89.6,62.7 89.51,62.79 89.27,62.79 89.19,62.7 89.19,62.28 89.09,62.18 88.95,62.18 88.86,62.28 88.86,62.7 88.77,62.79 87.56,62.79 87.55,62.78 66.15,62.78 65.86,63.07 63.73,63.07 63.44,62.78 v3(61.33,62.78)
  BOTTOM w0.102: U1.BE49 109.62,59.62 109.28,59.28 108.35,59.28 v1(107.83,59.79) ; v3(61.33,62.78) 61.31,62.76 61.31,62.04 62.4,60.95 JDIMM2.132
DDR_B_D38: length 64.6
  IN1 w0.084: v3(59.8,65.21) 61.01,66.42 65.79,66.42 65.87,66.33 65.87,66.11 65.97,66.01 66.11,66.01 66.21,66.11 66.21,66.33 66.29,66.42 67.18,66.42 67.26,66.33 67.26,65.8 67.35,65.72 67.51,65.72 67.6,65.8 67.6,66.33 67.68,66.42 68.34,66.42 69.53,67.6 72.75,67.6 74.04,66.31 85,66.31 85.64,65.68 97.66,65.68 97.74,65.59 97.74,65.18 97.83,65.1 98,65.1 98.08,65.18 98.08,65.59 98.16,65.68 98.33,65.68 98.41,65.59 98.41,65.18 98.5,65.1 98.67,65.1 98.75,65.18 98.75,65.59 98.83,65.68 99,65.68 99.09,65.59 99.09,65.18 99.17,65.1 99.39,65.1 99.47,65.18 99.47,65.59 99.55,65.68 99.72,65.68 99.81,65.59 99.81,65.18 99.89,65.1 100.04,65.1 100.17,65.22 100.17,65.51 100.28,65.62 100.43,65.62 100.53,65.51 100.53,65.22 100.66,65.1 100.89,65.1 101.74,64.25 102.71,64.25 103.23,63.73 103.81,63.73 v1(104.21,64.13)
  BOTTOM w0.102: v3(59.8,65.21) 61.67,63.35 JDIMM2.140 ; v1(104.21,64.13) 105.86,62.48 108.49,62.48 108.82,62.15 109.6,62.15 109.69,62.06 110.3,62.06 U1.BD54
DDR_B_D39: length 66.2
  IN1 w0.084: v3(61.33,65.21) 61.54,65.43 68.43,65.43 69.66,66.66 73.2,66.66 73.83,66.03 84.88,66.03 85.52,65.39 89.77,65.39 89.86,65.3 89.86,64.89 89.94,64.81 90.11,64.81 90.19,64.89 90.19,65.3 90.28,65.39 90.44,65.39 90.53,65.3 90.53,64.89 90.61,64.81 90.78,64.81 90.86,64.89 90.86,65.3 90.95,65.39 91.11,65.39 91.2,65.3 91.2,64.89 91.28,64.81 91.45,64.81 91.53,64.89 91.53,65.3 91.62,65.39 91.78,65.39 91.87,65.3 91.87,64.89 91.95,64.81 92.12,64.81 92.2,64.89 92.2,65.3 92.29,65.39 92.45,65.39 92.54,65.3 92.54,64.89 92.62,64.81 92.79,64.81 92.87,64.89 92.87,65.3 92.96,65.39 93.13,65.39 93.21,65.3 93.21,64.89 93.29,64.81 93.46,64.81 93.54,64.89 93.54,65.3 93.63,65.39 93.8,65.39 93.88,65.3 93.88,64.89 93.96,64.81 94.13,64.81 94.21,64.89 94.21,65.3 94.3,65.39 94.47,65.39 94.55,65.3 94.55,64.89 94.63,64.81 94.8,64.81 94.89,64.89 94.89,65.3 94.97,65.39 95.18,65.39 95.26,65.3 95.26,64.89 95.35,64.81 95.52,64.81 95.6,64.89 95.6,65.3 95.68,65.39 95.85,65.39 95.93,65.3 95.93,64.89 96.02,64.81 96.23,64.81 96.31,64.89 96.31,65.3 96.4,65.39 96.56,65.39 96.65,65.3 96.65,64.89 96.73,64.81 96.9,64.81 96.98,64.89 96.98,65.3 97.07,65.39 97.24,65.39 97.32,65.3 97.32,64.89 97.4,64.81 100.71,64.81 101.57,63.95 102.76,63.95 103.16,63.55 107.2,63.55 107.64,63.11 v1(107.64,61.64)
  BOTTOM w0.102: v1(107.64,61.64) 108.01,61.27 109.3,61.27 109.57,61.54 U1.BE53 ; v3(61.33,65.21) 61.31,65.2 61.31,64.67 62.03,63.95 JDIMM2.142
DDR_B_D40: length 69.9
  IN1 w0.084: v3(52.22,66.69) 52.65,66.26 56.2,66.26 58.43,68.5 68.5,68.5 68.96,68.96 74.69,68.96 75.48,68.17 93.48,68.17 93.56,68.08 93.56,67.12 93.66,67.03 93.8,67.03 93.9,67.12 93.9,68.08 93.98,68.17 94.15,68.17 94.23,68.08 94.23,67.12 94.33,67.03 94.47,67.03 94.57,67.12 94.57,68.08 94.65,68.17 94.82,68.17 94.9,68.08 94.9,67.12 95,67.03 95.14,67.03 95.24,67.12 95.24,67.3 95.34,67.39 95.47,67.39 95.57,67.3 95.57,67.12 95.67,67.03 101.29,67.03 102.72,65.6 104.97,65.6 106.44,64.13 v1(106.6,64.13)
  BOTTOM w0.102: v1(106.6,64.13) 106.6,64.08 107.56,63.12 109.45,63.12 U1.BF56 ; JDIMM2.147 53.46,65.45 v3(52.22,66.69)
DDR_B_D41: length 71.5
  IN1 w0.084: v3(53.75,66.69) 56.21,66.69 58.33,68.8 68.4,68.8 68.84,69.24 74.81,69.24 75.6,68.45 95.14,68.45 95.22,68.37 95.22,67.78 95.32,67.68 95.46,67.68 95.56,67.78 95.56,68.37 95.64,68.45 95.81,68.45 95.89,68.37 95.89,67.41 95.99,67.31 96.13,67.31 96.23,67.41 96.23,68.37 96.31,68.45 96.48,68.45 96.56,68.37 96.56,67.41 96.66,67.31 96.8,67.31 96.9,67.41 96.9,68.37 96.98,68.45 97.15,68.45 97.23,68.37 97.23,67.41 97.33,67.31 97.47,67.31 97.57,67.41 97.57,68.37 97.65,68.45 97.82,68.45 97.9,68.37 97.9,67.41 98,67.31 98.14,67.31 98.24,67.41 98.24,68.2 98.34,68.3 98.48,68.3 98.57,68.2 98.57,67.41 98.67,67.31 101.43,67.31 102.86,65.89 105.11,65.89 106.18,64.82 106.56,64.82 v1(107.26,64.13)
  BOTTOM w0.102: U1.BE57 109.74,63.56 109.5,63.32 108.01,63.32 107.26,64.08 v1(107.26,64.13) ; v3(53.75,66.69) 54.38,66.05 JDIMM2.149
DDR_B_D42: length 70
  IN1 w0.084: v1(111.34,64.34) 111.69,64.7 111.69,66.51 110.81,67.4 109.94,67.4 109.67,67.13 103.29,67.13 100.81,69.62 90.94,69.62 90.86,69.69 90.86,69.79 90.77,69.88 90.63,69.88 90.53,69.79 90.53,69.71 90.43,69.62 90.29,69.62 90.19,69.71 90.19,70.19 90.11,70.27 89.94,70.27 89.86,70.19 89.86,69.71 89.76,69.62 89.62,69.62 89.52,69.71 89.52,70.19 89.44,70.27 89.27,70.27 89.19,70.19 89.19,69.71 89.09,69.62 88.95,69.62 88.85,69.71 88.85,70.19 88.77,70.27 88.6,70.27 88.52,70.19 88.52,69.72 88.42,69.63 88.28,69.63 88.18,69.72 88.18,70.19 88.1,70.27 77.81,70.27 76.37,71.71 69.54,71.71 68.53,70.71 58.11,70.71 55.86,68.46 v3(53.75,68.46)
  BOTTOM w0.102: v1(111.34,64.34) 111.21,64.47 U1.BC59 ; JDIMM2.157 53.76,68.45 v3(53.75,68.46)
DDR_B_D43: length 70.3
  IN1 w0.084: v3(52.22,68.46) 52.65,68.89 55.88,68.89 58.87,71.88 64.4,71.88 65.09,72.57 76.85,72.57 77.73,71.69 100.28,71.69 104.04,67.93 109.28,67.93 109.61,68.27 v1(112.07,68.27)
  BOTTOM w0.102: v3(52.22,68.46) 52.81,69.05 JDIMM2.159 ; U1.AY60 112.54,65.96 112.45,66.05 112.45,66.55 111.69,67.32 111.69,67.89 v1(112.07,68.27)
DDR_B_D44: length 71.2
  IN1 w0.084: v3(105.51,64.13) 104.33,65.32 102.33,65.32 100.91,66.74 93.29,66.74 93.19,66.84 93.19,67.49 93.09,67.59 92.96,67.59 92.86,67.49 92.86,66.84 92.76,66.74 92.62,66.74 92.52,66.84 92.52,67.8 92.44,67.88 92.27,67.88 92.19,67.8 92.19,66.84 92.09,66.74 91.95,66.74 91.85,66.84 91.85,67.8 91.77,67.88 91.6,67.88 91.52,67.8 91.52,66.84 91.42,66.74 91.28,66.74 91.18,66.84 91.18,67.8 91.1,67.88 90.93,67.88 90.85,67.8 90.85,66.84 90.75,66.74 90.61,66.74 90.51,66.84 90.51,67.8 90.43,67.88 90.26,67.88 90.18,67.8 90.18,66.84 90.08,66.74 89.94,66.74 89.84,66.84 89.84,67.8 89.76,67.88 89.59,67.88 89.51,67.8 89.51,66.84 89.41,66.74 89.27,66.74 89.17,66.84 89.17,67.8 89.09,67.88 88.92,67.88 88.83,67.8 88.83,67.54 88.74,67.44 88.6,67.44 88.5,67.54 88.5,67.8 88.42,67.88 75.36,67.88 74.58,68.67 69.09,68.67 68.61,68.19 60.23,68.19 v1(59.8,67.76)
  BOTTOM w0.102: v1(59.8,67.76) 59.8,67.16 60.74,66.22 61.04,66.22 62.11,65.15 JDIMM2.146 ; v3(105.51,64.13) 105.51,64.08 106.68,62.91 109.16,62.91 109.48,62.59 109.48,62.59 109.67,62.41 U1.BE54
DDR_B_D45: length 70.1
  IN1 w0.084: v3(61.32,67.76) 68.59,67.76 69.21,68.38 74.46,68.38 75.24,67.59 80.72,67.59 80.81,67.51 80.81,67.18 80.89,67.09 81.06,67.09 81.14,67.18 81.14,67.51 81.22,67.59 81.39,67.59 81.48,67.51 81.48,67.18 81.56,67.09 81.73,67.09 81.81,67.18 81.81,67.51 81.89,67.59 82.06,67.59 82.15,67.51 82.15,67.18 82.23,67.09 82.4,67.09 82.48,67.18 82.48,67.51 82.57,67.59 82.73,67.59 82.82,67.51 82.82,67.18 82.9,67.09 83.07,67.09 83.15,67.18 83.15,67.51 83.24,67.59 83.4,67.59 83.49,67.51 83.49,67.18 83.57,67.09 83.74,67.09 83.82,67.18 83.82,67.51 83.91,67.59 84.07,67.59 84.16,67.51 84.16,67.18 84.24,67.09 84.41,67.09 84.49,67.18 84.49,67.51 84.58,67.59 84.74,67.59 84.83,67.51 84.83,67.18 84.91,67.09 85.08,67.09 85.16,67.18 85.16,67.51 85.25,67.59 85.42,67.59 85.5,67.51 85.5,66.92 85.6,66.82 85.74,66.82 85.83,66.92 85.83,67.51 85.92,67.59 86.09,67.59 86.17,67.51 86.17,66.55 86.27,66.45 86.41,66.45 86.5,66.55 86.5,67.51 86.59,67.59 86.76,67.59 86.84,67.51 86.84,66.55 86.94,66.45 87.08,66.45 87.18,66.55 87.18,67.51 87.26,67.59 87.43,67.59 87.51,67.51 87.51,66.55 87.61,66.45 87.75,66.45 87.85,66.55 87.85,67.51 87.93,67.59 88.1,67.59 88.18,67.51 88.18,66.55 88.28,66.45 88.42,66.45 88.52,66.55 88.52,67.05 88.61,67.15 88.75,67.15 88.85,67.05 88.85,66.55 88.95,66.45 100.69,66.45 102.12,65.03 103.96,65.03 v1(104.86,64.13)
  BOTTOM w0.102: v3(61.32,67.76) 61.32,67.43 61.2,67.3 60.99,67.3 60.86,67.17 60.86,66.83 60.99,66.7 61.63,66.7 61.75,66.57 61.75,65.94 61.94,65.75 JDIMM2.148 ; U1.BG54 108.91,62.71 106.23,62.71 104.86,64.08 v1(104.86,64.13)
DDR_B_D46: length 70.1
  IN1 w0.084: v3(59.8,71.44) 60.23,71.01 68.43,71.01 69.42,72 76.49,72 77.93,70.56 90.42,70.56 90.5,70.47 90.5,70.27 90.6,70.17 90.74,70.17 90.84,70.27 90.84,70.47 90.92,70.56 91.09,70.56 91.17,70.47 91.17,70 91.27,69.9 91.41,69.9 91.51,70 91.51,70.47 91.59,70.56 91.76,70.56 91.84,70.47 91.84,70 91.94,69.9 92.08,69.9 92.18,70 92.18,70.47 92.26,70.56 92.43,70.56 92.51,70.47 92.51,70 92.61,69.9 92.75,69.9 92.85,70 92.85,70.47 92.93,70.56 93.1,70.56 93.18,70.47 93.18,70 93.28,69.9 93.42,69.9 93.52,70 93.52,70.47 93.6,70.56 93.77,70.56 93.85,70.47 93.85,70 93.95,69.9 94.09,69.9 94.19,70 94.19,70.47 94.27,70.56 94.44,70.56 94.52,70.47 94.52,70 94.62,69.9 94.76,69.9 94.86,70 94.86,70.22 94.96,70.32 95.1,70.32 95.2,70.22 95.2,70 95.29,69.9 100.93,69.9 103.41,67.41 109.56,67.41 109.73,67.59 111.18,67.59 112.58,66.18 v1(112.58,64.82)
  BOTTOM w0.102: U1.BA58 112.1,64.34 v1(112.58,64.82) ; v3(59.8,71.44) 60.23,71.01 60.94,71.01 61.88,70.07 61.88,69.54 62.67,68.75 JDIMM2.158
DDR_B_D47: length 68.3
  IN1 w0.084: v1(112.09,67.61) 111.9,67.8 109.59,67.8 109.43,67.64 103.6,67.64 100.39,70.84 87.9,70.84 87.8,70.95 87.8,71.08 87.7,71.18 87.56,71.18 87.46,71.08 87.46,70.94 87.36,70.84 87.22,70.84 87.13,70.94 87.13,71.32 87.04,71.4 86.87,71.4 86.79,71.32 86.79,70.94 86.69,70.84 86.55,70.84 86.45,70.94 86.45,71.32 86.37,71.4 86.2,71.4 86.12,71.32 86.12,70.94 86.02,70.84 85.88,70.84 85.78,70.94 85.78,71.32 85.7,71.4 85.53,71.4 85.45,71.32 85.45,70.95 85.37,70.86 85.2,70.86 85.11,70.95 85.11,71.32 85.03,71.4 84.86,71.4 84.78,71.32 84.78,70.95 84.69,70.86 84.53,70.86 84.44,70.95 84.44,71.32 84.36,71.4 84.19,71.4 84.11,71.32 84.11,70.95 84.02,70.86 83.86,70.86 83.77,70.95 83.77,71.32 83.69,71.4 83.52,71.4 83.44,71.32 83.44,70.95 83.35,70.86 83.19,70.86 83.1,70.95 83.1,71.32 83.02,71.4 82.85,71.4 82.77,71.32 82.77,70.95 82.68,70.86 82.52,70.86 82.43,70.95 82.43,71.32 82.35,71.4 82.18,71.4 82.1,71.32 82.1,70.95 82.01,70.86 81.84,70.86 81.76,70.95 81.76,71.32 81.68,71.4 81.51,71.4 81.43,71.32 81.43,70.95 81.34,70.86 81.17,70.86 81.09,70.95 81.09,71.32 81.01,71.4 77.49,71.4 76.61,72.29 69.23,72.29 68.39,71.44 v3(61.32,71.44)
  BOTTOM w0.102: v1(112.09,67.61) 112.09,67.2 112.68,66.61 112.68,66.12 112.75,66.05 112.75,65.58 112.9,65.43 112.9,65.18 U1.AW59 ; JDIMM2.160 62.67,69.35 62.2,69.82 62.2,70.18 61.32,71.06 v3(61.32,71.44)
DDR_B_D48: length 76.6
  IN1 w0.084: v1(113.09,66.95) 112.49,67.55 112.49,68.46 112.28,68.67 109.68,68.67 109.15,68.13 104.54,68.13 100.48,72.18 82.79,72.18 82.71,72.27 82.71,72.8 82.61,72.89 82.47,72.89 82.38,72.8 82.38,72.27 82.29,72.18 82.12,72.18 82.04,72.27 82.04,72.98 81.96,73.06 81.79,73.06 81.71,72.98 81.71,72.27 81.62,72.18 81.45,72.18 81.37,72.27 81.37,72.98 81.29,73.06 81.12,73.06 81.03,72.98 81.03,72.27 80.95,72.18 80.78,72.18 80.7,72.27 80.7,72.98 80.62,73.06 56.41,73.06 53.87,70.53 52.7,70.53 v3(52.22,71)
  BOTTOM w0.102: v3(52.22,71) 52.98,70.25 JDIMM2.163 ; v1(113.09,66.95) 113.5,66.55 113.5,66.09 113.42,66.01 113.42,64.56 U1.AW58
DDR_B_D49: length 77.4
  IN1 w0.084: v1(113.09,67.6) 112.68,68.01 112.68,68.65 112.38,68.95 109.57,68.95 109.09,68.47 104.61,68.47 100.6,72.47 86.54,72.47 86.43,72.57 86.43,73.23 86.34,73.33 86.2,73.33 86.1,73.23 86.1,72.57 86.02,72.49 85.85,72.49 85.76,72.57 85.76,73.27 85.68,73.35 85.51,73.35 85.43,73.27 85.43,72.57 85.34,72.49 85.18,72.49 85.09,72.57 85.09,73.27 85.01,73.35 84.84,73.35 84.76,73.27 84.76,72.57 84.67,72.49 84.51,72.49 84.42,72.57 84.42,73.27 84.34,73.35 84.17,73.35 84.09,73.27 84.09,72.57 84,72.49 83.84,72.49 83.75,72.57 83.75,73.27 83.67,73.35 83.5,73.35 83.42,73.27 83.42,72.57 83.33,72.49 83.17,72.49 83.08,72.57 83.08,73.27 83,73.35 73.47,73.35 72.57,74.25 65.9,74.25 65,73.35 56.1,73.35 v3(53.75,71)
  BOTTOM w0.102: JDIMM2.165 53.9,70.85 v3(53.75,71) ; U1.AU58 113.63,64.56 113.63,65.91 113.71,65.98 113.71,66.99 v1(113.09,67.6)
DDR_B_D50: length 76.8
  IN1 w0.084: v3(52.22,74.56) 52.85,73.94 54.18,73.94 56.84,76.6 63.74,76.6 65.12,77.98 74.03,77.98 75.9,76.12 101.3,76.12 106.07,71.35 110.32,71.35 110.91,71.94 113.54,71.94 114.21,71.26 114.21,68.86 114.89,68.18 v1(115.07,68.18)
  BOTTOM w0.102: U1.AN61 115.93,67.32 v1(115.07,68.18) ; v3(52.22,74.56) 52.93,73.85 JDIMM2.175
DDR_B_D51: length 74.4
  IN1 w0.084: v1(115.07,68.83) 114.52,69.39 114.52,71.36 113.66,72.22 110.79,72.22 110.2,71.64 106.19,71.64 101.41,76.41 76.01,76.41 74.15,78.27 65,78.27 63.71,76.98 56.81,76.98 54.39,74.56 v3(53.75,74.56)
  BOTTOM w0.102: v1(115.07,68.83) 116.26,67.65 116.26,65.54 115.93,65.22 U1.AN59 ; JDIMM2.177 53.86,74.45 v3(53.75,74.56)
DDR_B_D52: length 74.8
  IN1 w0.084: v3(59.8,73.95) 59.8,73.96 60.36,74.52 65.35,74.52 65.66,74.83 72.81,74.83 73.71,73.93 93.03,73.93 93.11,73.84 93.11,73.14 93.21,73.04 93.35,73.04 93.45,73.14 93.45,73.84 93.53,73.93 93.7,73.93 93.78,73.84 93.78,73.14 93.88,73.04 94.02,73.04 94.12,73.14 94.12,73.84 94.2,73.93 94.37,73.93 94.45,73.84 94.45,73.14 94.55,73.04 94.69,73.04 94.79,73.14 94.79,73.84 94.87,73.93 95.04,73.93 95.13,73.84 95.13,73.14 95.22,73.04 95.36,73.04 95.46,73.14 95.46,73.84 95.54,73.93 95.71,73.93 95.8,73.84 95.8,73.14 95.89,73.04 96.03,73.04 96.13,73.14 96.13,73.72 96.23,73.82 96.37,73.82 96.47,73.72 96.47,73.14 96.56,73.04 100.84,73.04 104.84,69.04 108.85,69.04 109.37,69.56 v1(113.09,69.56)
  BOTTOM w0.102: v1(113.09,69.56) 114.17,68.49 114.17,65.96 114.29,65.83 114.29,65.57 113.96,65.24 U1.AU59 ; JDIMM2.164 62.55,70.55 61.91,71.19 61.91,71.83 59.8,73.94 v3(59.8,73.95)
DDR_B_D53: length 76.6
  IN1 w0.084: v3(61.32,73.98) 61.55,74.21 65.45,74.21 65.78,74.54 72.69,74.54 73.59,73.64 86.67,73.64 86.75,73.56 86.75,72.85 86.85,72.76 86.99,72.76 87.08,72.85 87.08,73.56 87.17,73.64 87.34,73.64 87.42,73.56 87.42,72.85 87.52,72.76 87.66,72.76 87.75,72.85 87.75,73.56 87.84,73.64 88.01,73.64 88.09,73.56 88.09,72.85 88.19,72.76 88.33,72.76 88.43,72.85 88.43,73.56 88.51,73.64 88.68,73.64 88.76,73.56 88.76,72.85 88.86,72.76 89,72.76 89.1,72.85 89.1,73.56 89.18,73.64 89.35,73.64 89.43,73.56 89.43,72.85 89.53,72.76 89.67,72.76 89.77,72.85 89.77,73.56 89.85,73.64 90.02,73.64 90.1,73.56 90.1,72.85 90.2,72.76 90.34,72.76 90.44,72.85 90.44,73.56 90.52,73.64 90.69,73.64 90.77,73.56 90.77,72.85 90.87,72.76 91.01,72.76 91.11,72.85 91.11,73.56 91.19,73.64 91.36,73.64 91.44,73.56 91.44,72.85 91.54,72.76 91.68,72.76 91.78,72.85 91.78,73.56 91.86,73.64 92.03,73.64 92.11,73.56 92.11,72.85 92.21,72.76 92.35,72.76 92.45,72.85 92.45,73.38 92.55,73.48 92.69,73.48 92.78,73.38 92.78,72.85 92.88,72.76 100.72,72.76 104.72,68.75 108.97,68.75 109.49,69.28 112.73,69.28 v1(113.09,68.91)
  BOTTOM w0.102: U1.AU61 113.96,68.05 v1(113.09,68.91) ; v3(61.32,73.98) 61.32,72.87 62.22,71.98 62.22,71.42 62.49,71.15 JDIMM2.166
DDR_B_D54: length 78.7
  IN1 w0.084: v1(115.07,67.53) 113.91,68.69 113.91,71.16 113.42,71.65 111.03,71.65 110.44,71.06 105.95,71.06 101.63,75.38 99.23,75.38 99.13,75.48 99.13,75.64 99.03,75.74 98.89,75.74 98.79,75.64 98.79,75.47 98.71,75.38 98.54,75.38 98.46,75.47 98.46,75.75 98.37,75.83 98.21,75.83 98.12,75.75 98.12,75.47 98.04,75.38 97.87,75.38 97.79,75.47 97.79,75.75 97.7,75.83 97.54,75.83 97.45,75.75 97.45,75.47 97.37,75.38 97.2,75.38 97.12,75.47 97.12,75.75 97.03,75.83 96.86,75.83 96.78,75.75 96.78,75.47 96.7,75.38 96.53,75.38 96.45,75.47 96.45,75.75 96.36,75.83 96.19,75.83 96.11,75.75 96.11,75.47 96.03,75.38 95.86,75.38 95.78,75.47 95.78,75.75 95.69,75.83 95.52,75.83 95.44,75.75 95.44,75.47 95.36,75.38 95.19,75.38 95.1,75.47 95.1,75.75 95.02,75.83 94.85,75.83 94.77,75.75 94.77,75.47 94.69,75.38 94.52,75.38 94.43,75.47 94.43,75.75 94.35,75.83 94.18,75.83 94.1,75.75 94.1,75.47 94.02,75.38 93.85,75.38 93.76,75.47 93.76,75.75 93.68,75.83 93.51,75.83 93.43,75.75 93.43,75.47 93.34,75.38 93.18,75.38 93.09,75.47 93.09,75.75 93.01,75.83 92.84,75.83 92.76,75.75 92.76,75.47 92.67,75.38 92.51,75.38 92.42,75.47 92.42,75.75 92.34,75.83 92.17,75.83 92.09,75.75 92.09,75.47 92,75.38 91.84,75.38 91.75,75.47 91.75,75.75 91.67,75.83 91.5,75.83 91.42,75.75 91.42,75.47 91.33,75.38 91.17,75.38 91.08,75.47 91.08,75.75 91,75.83 75.78,75.83 73.91,77.7 65.24,77.7 63.76,76.22 60.25,76.22 v3(59.8,75.76)
  BOTTOM w0.102: JDIMM2.174 62.37,73.55 60.69,75.24 60.32,75.24 v3(59.8,75.76) ; v1(115.07,67.53) 115.72,66.88 115.72,66 115.6,65.88 115.6,64.57 U1.AN58
DDR_B_D55: length 76.9
  IN1 w0.084: v3(61.32,75.76) 61.47,75.91 63.86,75.91 64.64,76.69 74.51,76.69 75.66,75.54 80.62,75.54 80.7,75.46 80.7,75.19 80.8,75.09 80.94,75.09 81.04,75.19 81.04,75.46 81.12,75.54 81.29,75.54 81.37,75.46 81.37,75.19 81.46,75.1 81.62,75.1 81.71,75.19 81.71,75.46 81.79,75.54 81.96,75.54 82.04,75.46 82.04,75.19 82.13,75.1 82.3,75.1 82.38,75.19 82.38,75.46 82.46,75.54 82.63,75.54 82.71,75.46 82.71,75.19 82.8,75.1 82.97,75.1 83.05,75.19 83.05,75.46 83.13,75.54 83.3,75.54 83.38,75.46 83.38,75.19 83.47,75.1 83.64,75.1 83.72,75.19 83.72,75.46 83.8,75.54 83.97,75.54 84.06,75.46 84.06,75.19 84.14,75.1 84.31,75.1 84.39,75.19 84.39,75.46 84.47,75.54 84.64,75.54 84.73,75.46 84.73,75.19 84.81,75.1 84.98,75.1 85.06,75.19 85.06,75.46 85.15,75.54 85.31,75.54 85.4,75.46 85.4,75.19 85.48,75.1 85.65,75.1 85.73,75.19 85.73,75.46 85.82,75.54 85.98,75.54 86.07,75.46 86.07,75.19 86.15,75.1 86.32,75.1 86.4,75.19 86.4,75.46 86.49,75.54 86.65,75.54 86.74,75.46 86.74,75.19 86.82,75.1 86.99,75.1 87.07,75.19 87.07,75.46 87.16,75.54 87.32,75.54 87.41,75.46 87.41,75.19 87.49,75.1 87.66,75.1 87.74,75.19 87.74,75.46 87.83,75.54 87.99,75.54 88.08,75.46 88.08,75.19 88.16,75.1 88.33,75.1 88.41,75.19 88.41,75.45 88.51,75.54 88.65,75.54 88.75,75.45 88.75,75.19 88.83,75.1 89,75.1 89.08,75.19 89.08,75.45 89.18,75.54 89.32,75.54 89.42,75.45 89.42,75.19 89.52,75.09 89.65,75.09 89.75,75.19 89.75,75.45 89.85,75.54 89.99,75.54 90.08,75.45 90.08,75.19 90.18,75.09 90.32,75.09 90.42,75.19 90.42,75.45 90.52,75.54 90.66,75.54 90.76,75.45 90.76,75.19 90.86,75.09 101.52,75.09 105.83,70.78 110.56,70.78 111.15,71.36 113.3,71.36 113.6,71.06 113.6,67.91 114.63,66.88 v1(115.07,66.88)
  BOTTOM w0.102: v3(61.32,75.76) 61.32,75.11 62.28,74.15 JDIMM2.176 ; U1.AR58 115.38,64.55 115.38,65.96 115.5,66.08 115.5,66.44 v1(115.07,66.88)
DDR_B_D56: length 83.1
  IN1 w0.084: v1(117.18,68.17) 117.11,68.17 116.12,69.16 116.12,72.73 109.7,79.15 106.25,79.15 104.86,77.76 94.13,77.76 94.02,77.87 94.02,78.7 93.92,78.8 76.95,78.8 75.43,80.32 65.14,80.32 63.83,79.01 57.75,79.01 56.26,77.53 52.34,77.53 52.22,77.41 v3(52.22,77.1)
  BOTTOM w0.102: JDIMM2.181 54.2,75.65 53.45,76.41 52.92,76.41 v3(52.22,77.1) ; U1.AK58 117.59,64.55 117.59,65.83 117.81,66.05 117.81,67.54 v1(117.18,68.17)
DDR_B_D57: length 84.1
  IN1 w0.084: v1(117.18,67.54) 115.83,68.89 115.83,72.62 109.58,78.87 106.38,78.87 104.99,77.48 93.84,77.48 93.73,77.58 93.73,78.38 93.64,78.48 93.5,78.48 93.4,78.38 93.4,77.58 93.3,77.48 93.16,77.48 93.06,77.58 93.06,78.42 92.98,78.51 92.81,78.51 92.73,78.42 92.73,77.58 92.63,77.48 92.49,77.48 92.39,77.58 92.39,78.42 92.31,78.51 92.14,78.51 92.06,78.42 92.06,77.58 91.96,77.48 91.82,77.48 91.72,77.58 91.72,78.42 91.64,78.51 75.57,78.51 74.74,79.33 64.56,79.33 63.95,78.73 57.87,78.73 56.24,77.1 v3(53.75,77.1)
  BOTTOM w0.102: JDIMM2.183 54.19,76.25 53.75,76.69 v3(53.75,77.1) ; v1(117.18,67.54) 117.6,67.12 117.6,66.12 117.38,65.9 117.38,64.57 U1.AL58
DDR_B_D58: length 85.3
  IN1 w0.084: v3(52.22,79.26) 52.96,80 56.18,80 59.17,83 67.52,83 68.08,82.44 76.59,82.44 77.65,81.38 97.06,81.38 97.24,81.2 110.52,81.2 120.12,71.6 120.12,67.88 v1(119.13,66.89)
  BOTTOM w0.102: v1(119.13,66.89) 119.46,66.56 119.46,64.68 U1.AG58 ; JDIMM2.191 52.83,78.65 v3(52.22,79.26)
DDR_B_D59: length 84.2
  IN1 w0.084: v1(119.14,67.56) 119.83,68.25 119.83,71.48 110.4,80.91 103.92,80.91 103.55,80.54 97.42,80.54 97.32,80.64 97.32,80.72 97.22,80.82 97.08,80.82 96.98,80.72 96.98,80.64 96.9,80.56 96.73,80.56 96.65,80.64 96.65,81.01 96.56,81.09 96.39,81.09 96.31,81.01 96.31,80.64 96.23,80.56 96.06,80.56 95.97,80.64 95.97,81.01 95.89,81.09 95.72,81.09 95.64,81.01 95.64,80.64 95.56,80.56 95.39,80.56 95.3,80.64 95.3,81.01 95.22,81.09 95.05,81.09 94.97,81.01 94.97,80.64 94.89,80.56 94.72,80.56 94.63,80.64 94.63,81.01 94.55,81.09 77.53,81.09 76.47,82.15 67.96,82.15 67.42,82.69 59.27,82.69 56.26,79.67 54.16,79.67 v3(53.75,79.26)
  BOTTOM w0.102: JDIMM2.193 53.75,79.25 v3(53.75,79.26) ; U1.AG59 118.87,65.14 118.87,65.42 118.67,65.62 118.67,67.1 v1(119.14,67.56)
DDR_B_D60: length 84.8
  IN1 w0.084: v1(115.07,69.49) 115.07,71.5 113.86,72.71 110.59,72.71 110,72.13 106.39,72.13 101.62,76.9 86.49,76.9 86.41,76.98 86.41,77.06 86.31,77.16 86.17,77.16 86.08,77.06 86.08,76.98 85.99,76.9 85.82,76.9 85.74,76.98 85.74,77.72 85.64,77.82 85.5,77.82 85.41,77.72 85.41,76.98 85.32,76.9 85.15,76.9 85.07,76.98 85.07,77.82 84.97,77.92 84.83,77.92 84.73,77.82 84.73,76.98 84.65,76.9 84.48,76.9 84.4,76.98 84.4,77.82 84.3,77.92 84.16,77.92 84.06,77.82 84.06,76.98 83.98,76.9 83.81,76.9 83.73,76.98 83.73,77.82 83.63,77.92 83.49,77.92 83.39,77.82 83.39,76.98 83.31,76.9 83.14,76.9 83.06,76.98 83.06,77.82 82.96,77.92 82.82,77.92 82.72,77.82 82.72,76.98 82.64,76.9 82.47,76.9 82.39,76.98 82.39,77.82 82.29,77.92 82.15,77.92 82.05,77.82 82.05,76.98 81.97,76.9 81.8,76.9 81.72,76.98 81.72,77.82 81.62,77.92 81.48,77.92 81.38,77.82 81.38,76.98 81.3,76.9 81.13,76.9 81.05,76.98 81.05,77.28 80.95,77.38 80.81,77.38 80.71,77.28 80.71,76.98 80.63,76.9 76.36,76.9 74.5,78.76 64.8,78.76 63.92,77.88 60.22,77.88 v3(59.8,78.3)
  BOTTOM w0.102: v1(115.07,69.49) 115.15,69.4 115.17,69.4 116.49,68.08 U1.AM60 ; JDIMM2.180 62.47,75.35 60.93,76.89 60.93,77.33 59.95,78.3 v3(59.8,78.3)
DDR_B_D61: length 84.8
  IN1 w0.084: v1(117.19,66.9) 115.52,68.57 115.52,71.46 113.98,73 110.47,73 109.88,72.41 106.51,72.41 101.74,77.19 91.54,77.19 91.43,77.3 91.43,78.03 91.33,78.13 91.19,78.13 91.09,78.03 91.09,77.3 90.99,77.2 90.86,77.2 90.76,77.3 90.76,78.14 90.67,78.22 90.51,78.22 90.42,78.14 90.42,77.3 90.32,77.2 90.19,77.2 90.09,77.3 90.09,78.14 90,78.22 89.84,78.22 89.75,78.14 89.75,77.3 89.65,77.2 89.52,77.2 89.42,77.3 89.42,78.14 89.33,78.22 89.17,78.22 89.08,78.14 89.08,77.3 88.98,77.2 88.84,77.2 88.75,77.3 88.75,78.14 88.66,78.22 88.49,78.22 88.41,78.14 88.41,77.3 88.31,77.2 88.17,77.2 88.08,77.3 88.08,78.14 87.99,78.22 87.82,78.22 87.74,78.14 87.74,77.3 87.64,77.2 87.5,77.2 87.41,77.3 87.41,78.14 87.32,78.22 87.15,78.22 87.07,78.14 87.07,77.3 86.97,77.2 86.83,77.2 86.73,77.3 86.73,78.14 86.65,78.22 86.48,78.22 86.4,78.14 86.4,77.55 86.3,77.45 86.16,77.45 86.06,77.55 86.06,78.14 85.98,78.22 81.24,78.22 80.21,77.19 76.48,77.19 74.62,79.05 64.68,79.05 63.94,78.3 61.32,78.3 v3(61.32,78.3)
  BOTTOM w0.102: v3(61.32,78.3) 61.32,76.92 62.3,75.95 JDIMM2.182 ; v1(117.19,66.9) 116.69,66.4 116.69,65.59 117.05,65.24 U1.AL59
DDR_B_D62: length 83.2
  IN1 w0.084: v1(119.14,68.22) 119.54,68.63 119.54,71.36 110.28,80.63 104.04,80.63 103.66,80.25 94.44,80.25 94.35,80.35 94.35,80.49 94.25,80.59 94.11,80.59 94.01,80.49 94.01,80.35 93.91,80.25 93.77,80.25 93.68,80.35 93.68,80.72 93.59,80.81 93.42,80.81 93.34,80.72 93.34,80.35 93.24,80.25 93.1,80.25 93.01,80.35 93.01,80.72 92.92,80.81 92.75,80.81 92.67,80.72 92.67,80.35 92.57,80.25 92.43,80.25 92.33,80.35 92.33,80.72 92.25,80.81 92.08,80.81 92,80.72 92,80.35 91.9,80.25 91.76,80.25 91.66,80.35 91.66,80.72 91.58,80.81 91.41,80.81 91.33,80.72 91.33,80.35 91.23,80.25 91.09,80.25 90.99,80.35 90.99,80.72 90.91,80.81 90.74,80.81 90.66,80.72 90.66,80.35 90.56,80.25 90.42,80.25 90.32,80.35 90.32,80.72 90.24,80.81 90.07,80.81 89.99,80.72 89.99,80.35 89.89,80.25 89.75,80.25 89.65,80.35 89.65,80.72 89.57,80.81 89.4,80.81 89.32,80.72 89.32,80.35 89.22,80.25 89.08,80.25 88.98,80.35 88.98,80.72 88.9,80.81 88.73,80.81 88.65,80.72 88.65,80.65 88.55,80.55 88.41,80.55 88.31,80.65 88.31,80.72 88.23,80.81 77.41,80.81 76.35,81.86 67.84,81.86 67.37,82.33 60.28,82.33 v3(59.8,81.86)
  BOTTOM w0.102: v3(59.8,81.86) 60.76,80.89 60.88,80.89 61.82,79.96 61.82,79.61 62.48,78.95 JDIMM2.192 ; U1.AF61 119.7,65.78 119.7,67.66 v1(119.14,68.22)
DDR_B_D63: length 84.3
  IN1 w0.084: v1(119.14,68.86) 119.14,71.35 110.16,80.34 104.16,80.34 103.78,79.96 88.69,79.96 88.61,80.05 88.61,80.17 88.51,80.26 88.37,80.26 88.28,80.17 88.28,80.05 88.19,79.96 88.02,79.96 87.94,80.05 87.94,80.21 87.84,80.31 87.7,80.31 87.61,80.21 87.61,80.05 87.52,79.96 87.35,79.96 87.27,80.05 87.27,80.43 87.19,80.51 87.02,80.51 86.93,80.43 86.93,80.05 86.85,79.96 86.68,79.96 86.6,80.05 86.6,80.43 86.52,80.51 86.35,80.51 86.26,80.43 86.26,80.05 86.18,79.96 86.01,79.96 85.93,80.05 85.93,80.43 85.84,80.51 85.68,80.51 85.59,80.43 85.59,80.05 85.51,79.96 85.34,79.96 85.26,80.05 85.26,80.43 85.17,80.51 85.01,80.51 84.92,80.43 84.92,80.05 84.84,79.96 84.67,79.96 84.59,80.05 84.59,80.43 84.5,80.51 84.34,80.51 84.25,80.43 84.25,80.05 84.17,79.96 84,79.96 83.92,80.05 83.92,80.43 83.83,80.51 83.67,80.51 83.58,80.43 83.58,80.05 83.5,79.96 83.33,79.96 83.25,80.05 83.25,80.43 83.16,80.51 83,80.51 82.91,80.43 82.91,80.05 82.83,79.96 82.66,79.96 82.58,80.05 82.58,80.43 82.49,80.51 82.32,80.51 82.24,80.43 82.24,80.05 82.16,79.96 81.99,79.96 81.91,80.05 81.91,80.43 81.82,80.51 81.65,80.51 81.57,80.43 81.57,80.05 81.49,79.96 81.32,79.96 81.23,80.05 81.23,80.43 81.15,80.51 80.98,80.51 80.9,80.43 80.9,80.05 80.82,79.96 77.85,79.96 76.33,81.48 65.36,81.48 65.27,81.56 65.27,81.96 65.19,82.05 65.02,82.05 64.94,81.96 64.94,81.56 64.85,81.48 64.69,81.48 64.6,81.56 64.6,81.96 64.52,82.05 64.35,82.05 64.27,81.96 64.27,81.56 64.18,81.48 61.7,81.48 v3(61.32,81.86)
  BOTTOM w0.102: v1(119.14,68.86) 118.47,68.18 U1.AH60 ; v3(61.32,81.86) 61.32,81.07 62.15,80.25 62.15,79.79 62.39,79.55 JDIMM2.194
DDR_B_DQS0: length 83.6
  IN1 w0.091: v1(59.22,21.01) 59.41,21.01 59.59,20.84 59.59,20.51 59.8,20.3 69.19,20.3 71.2,18.28 80.47,18.28 83.8,21.61 96.91,21.61 97.98,22.68 109.57,22.68 113.06,26.18 113.06,26.68 112.35,27.39 112.35,27.57 112.49,27.71 112.67,27.71 113.39,27 113.66,27 114.07,27.42 114.07,27.69 113.34,28.42 113.34,28.6 113.49,28.74 113.67,28.74 114.4,28.01 114.67,28.01 114.96,28.31 114.96,28.58 114.62,28.92 114.62,29.05 114.82,29.24 114.95,29.24 115.29,28.9 115.56,28.9 115.86,29.2 115.86,29.47 115.51,29.81 115.51,29.94 115.71,30.13 115.84,30.13 116.18,29.79 116.45,29.79 116.75,30.09 116.75,31.83 116.58,32 116.35,32 v3(116.11,32.24)
  BOTTOM w0.102: v3(116.11,32.24) 116.27,32.08 116.56,32.08 116.63,32.15 116.63,33.28 116.63,33.28 116.63,34.34 116.79,34.49 116.79,35.77 116.67,35.88 U1.AM2 ; JDIMM2.12 62.33,22.55 62.26,22.48 61.82,22.48 61.35,22.01 59.78,22.01 59.42,21.65 59.42,21.21 v1(59.22,21.01)
DDR_B_DQS1: length 73.1
  IN1 w0.091: v1(112.88,33.58) 112.88,33.56 112.45,33.13 112.45,32.74 112.27,32.56 102.4,32.56 96.2,26.36 75.52,26.36 74.61,25.45 63.56,25.45 62.84,26.17 54.34,26.17 54.24,26.26 54.24,27.09 53.87,27.47 52.99,27.47 52.79,27.26 51.97,27.26 51.84,27.14 v3(51.84,26.83)
  BOTTOM w0.102: v1(112.88,33.58) 113.03,33.58 113.31,33.86 113.31,35.09 113.2,35.19 113.2,36.01 U1.AV1 ; JDIMM2.29 54.05,27.65 53.9,27.5 52.3,27.5 52.08,27.28 52.08,27.07 v3(51.84,26.83)
DDR_B_DQS2: length 67.9
  IN1 w0.091: v1(106.68,40.58) 106.25,40.15 105.82,40.15 104.92,39.26 104.53,39.26 102.97,37.69 102.12,37.69 96.74,32.32 74.3,32.32 73.99,32.01 66.68,32.01 65.51,30.83 57.18,30.83 54.66,33.35 52.38,33.35 52.07,33.05 52.07,32.78 v3(51.84,32.55)
  BOTTOM w0.102: v3(51.84,32.55) 52.04,32.75 52.04,32.99 52.25,33.2 53.63,33.2 53.78,33.05 JDIMM2.47 ; v1(106.68,40.58) 106.87,40.38 107.36,40.38 107.76,40.79 108.8,40.79 109.03,41.02 109.29,41.02 109.59,40.72 U1.BE11
DDR_B_DQS3: length 64.7
  IN1 w0.091: v1(59.98,36.43) 60.13,36.43 60.27,36.57 60.27,36.88 60.53,37.15 61.9,37.15 62.09,36.95 62.09,36.72 62.22,36.59 62.42,36.59 62.55,36.72 62.55,36.95 62.74,37.15 63.16,37.15 63.35,36.95 63.35,36.42 63.48,36.3 63.68,36.3 63.81,36.42 63.81,36.95 64,37.15 64.42,37.15 64.61,36.95 64.61,36.78 64.74,36.65 64.94,36.65 65.07,36.78 65.07,36.95 65.26,37.15 65.68,37.15 65.87,36.95 65.87,36.42 66,36.3 66.2,36.3 66.33,36.42 66.33,36.95 66.52,37.15 66.94,37.15 67.13,36.95 67.13,36.74 67.26,36.61 67.46,36.61 67.59,36.74 67.59,36.95 67.78,37.15 68.28,37.15 68.81,36.62 72.26,36.62 72.6,36.96 96.41,36.96 100.78,41.33 102.17,41.33 103.44,42.59 107.27,42.59 107.39,42.71 107.39,43.49 v3(107.18,43.69)
  BOTTOM w0.102: v3(107.18,43.69) 107.4,43.9 107.4,44.14 107.61,44.36 110.32,44.36 U1.BD18 ; v1(59.98,36.43) 60.18,36.63 60.18,37.04 60.58,37.44 61.34,37.44 61.66,37.77 61.66,37.9 61.92,38.15 JDIMM2.64
DDR_B_DQS4: length 66.8
  IN1 w0.091: v3(52.6,62.46) 52.5,62.36 52.5,61.81 52.59,61.72 53.47,61.72 55.93,64.18 61.7,64.18 61.83,64.31 68.67,64.31 69.61,65.25 72.51,65.25 72.7,65.05 72.7,64.89 72.83,64.77 73.03,64.77 73.16,64.89 73.16,65.05 73.35,65.25 84.56,65.25 85.78,64.03 100.29,64.03 101.15,63.16 104.68,63.16 105.58,62.26 105.58,61.7 v1(105.69,61.59)
  BOTTOM w0.102: v3(52.6,62.46) 52.35,62.21 52.35,62.07 52.47,61.95 53.78,61.95 53.86,62.03 53.86,62.26 54.05,62.45 JDIMM2.137 ; v1(105.69,61.59) 105.52,61.43 105.52,60.96 105.61,60.87 109.23,60.87 109.62,60.48 U1.BE51
DDR_B_DQS5: length 67.9
  IN1 w0.091: v1(110.93,66.09) 110.93,66.26 110.86,66.33 110.8,66.33 110.78,66.35 103.13,66.35 100.53,68.95 86.81,68.95 86.62,69.14 86.62,69.23 86.51,69.34 86.36,69.34 86.25,69.23 86.25,69.14 86.06,68.95 85.73,68.95 85.54,69.14 85.54,69.38 85.43,69.49 85.28,69.49 85.18,69.38 85.18,69.14 84.98,68.95 84.66,68.95 84.46,69.14 84.46,69.51 84.37,69.6 84.19,69.6 84.1,69.51 84.1,69.14 83.91,68.95 83.58,68.95 83.39,69.14 83.39,69.51 83.3,69.6 83.11,69.6 83.02,69.51 83.02,69.14 82.83,68.95 82.5,68.95 82.31,69.14 82.31,69.51 82.22,69.6 82.04,69.6 81.94,69.51 81.94,69.14 81.75,68.95 81.43,68.95 81.23,69.14 81.23,69.51 81.14,69.6 80.96,69.6 80.87,69.51 80.87,69.14 80.68,68.95 76.25,68.95 74.85,70.35 69.25,70.35 68.52,69.62 64.76,69.62 64.35,70.03 59.92,70.03 59.83,69.94 59.83,69.64 59.94,69.54 v3(60.18,69.54)
  BOTTOM w0.102: U1.BA61 111.98,65.58 111.86,65.46 111.7,65.46 111.58,65.58 111.58,65.91 111.71,66.04 111.92,66.04 112.02,66.14 112.02,66.28 111.8,66.5 111.34,66.5 111.17,66.33 111.01,66.33 110.93,66.26 v1(110.93,66.09) ; v3(60.18,69.54) 59.96,69.54 59.83,69.41 59.83,69.11 60.12,68.82 61.29,68.82 62.05,68.06 62.05,67.33 62.1,67.28 62.18,67.28 62.45,67.55 JDIMM2.154
DDR_B_DQS6: length 76.7
  IN1 w0.091: v3(52.6,72.78) 52.36,72.54 52.36,71.99 52.46,71.89 53.69,71.89 56.62,74.82 59.62,74.82 60,75.2 63.85,75.2 64.84,76.19 72.99,76.19 74.58,74.6 101.31,74.6 105.63,70.28 111.64,70.28 111.99,70.63 112.86,70.63 v1(113.09,70.87)
  BOTTOM w0.102: U1.AR59 115.05,65.01 115.05,65.24 114.73,65.56 114.73,66.02 114.64,66.11 114.64,68.86 114.44,69.06 114.43,69.06 114.38,69.11 114.37,69.11 114.13,69.35 114.13,70.31 113.8,70.64 113.32,70.64 v1(113.09,70.87) ; v3(52.6,72.78) 52.35,72.53 52.35,72.34 52.43,72.27 53.79,72.27 54.17,72.65 JDIMM2.171
DDR_B_DQS7: length 83.6
  IN1 w0.091: v3(60.18,80.11) 59.9,80.11 59.84,80.05 59.84,79.98 59.82,79.96 59.82,79.72 59.86,79.68 61.97,79.68 63.28,80.99 76.05,80.99 77.57,79.47 94.54,79.47 94.73,79.28 94.73,78.54 94.82,78.45 95.1,78.45 95.19,78.54 95.19,79.28 95.38,79.47 95.8,79.47 95.99,79.28 95.99,78.54 96.08,78.45 96.36,78.45 96.45,78.54 96.45,79.28 96.64,79.47 97.06,79.47 97.25,79.28 97.25,78.61 97.38,78.48 97.58,78.48 97.71,78.61 97.71,79.28 97.9,79.47 98.32,79.47 98.51,79.28 98.51,78.74 98.64,78.61 98.84,78.61 98.97,78.74 98.97,79.28 99.16,79.47 103.99,79.47 104.37,79.85 109.95,79.85 117.78,72.01 117.78,69.52 117.58,69.31 117.3,69.31 117.18,69.19 v1(117.18,68.81)
  BOTTOM w0.102: v1(117.18,68.81) 117.18,69.18 117.31,69.31 117.61,69.31 118.03,68.89 118.03,65.83 U1.AK61 ; v3(60.18,80.11) 59.9,80.11 59.85,80.06 59.85,79.94 59.78,79.88 59.78,79.8 60.26,79.32 61.33,79.32 62.05,78.61 62.05,77.81 62.29,77.57 62.37,77.57 62.56,77.75 JDIMM2.188
DDR_B_DQS#0: length 83.6
  IN1 w0.091: v3(59.98,21.01) 59.76,20.79 59.76,20.59 59.88,20.47 69.26,20.47 71.28,18.45 80.4,18.45 83.73,21.79 96.84,21.79 97.91,22.85 109.5,22.85 112.89,26.25 112.89,26.6 112.18,27.32 112.18,27.64 112.42,27.89 112.75,27.89 113.46,27.17 113.59,27.17 113.9,27.49 113.9,27.62 113.17,28.35 113.17,28.67 113.41,28.92 113.74,28.92 114.47,28.18 114.6,28.18 114.79,28.38 114.79,28.51 114.45,28.85 114.45,29.12 114.75,29.42 115.02,29.42 115.36,29.07 115.49,29.07 115.68,29.27 115.68,29.4 115.34,29.74 115.34,30.01 115.64,30.31 115.91,30.31 116.25,29.97 116.38,29.97 116.58,30.16 116.58,31.76 116.51,31.82 116.35,31.82 v1(116.11,31.58)
  BOTTOM w0.102: v1(116.11,31.58) 116.11,31.65 116.33,31.86 116.64,31.86 116.84,32.06 116.84,33.19 116.85,33.19 116.85,34.25 117,34.4 117,35.86 116.88,35.97 116.88,36.2 116.98,36.3 116.98,36.75 117.1,36.87 117.17,36.87 U1.AL3 ; v3(59.98,21.01) 59.75,21.01 59.63,21.13 59.63,21.56 59.87,21.8 61.44,21.8 61.91,22.27 62.13,22.27 62.24,22.16 62.24,22.05 62.34,21.95 JDIMM2.10
DDR_B_DQS#1: length 73
  IN1 w0.091: v3(112.88,32.93) 112.34,32.39 102.47,32.39 96.28,26.19 75.59,26.19 74.68,25.28 63.49,25.28 62.77,25.99 54.27,25.99 54.07,26.19 54.07,27.02 53.79,27.3 53.07,27.3 v1(52.6,26.83)
  BOTTOM w0.102: JDIMM2.27 54.05,27.05 53.82,27.28 52.39,27.28 52.29,27.19 52.29,26.97 52.43,26.83 v1(52.6,26.83) ; U1.AV3 113.62,36.46 113.62,36.01 113.42,35.8 113.42,35.28 113.52,35.17 113.52,33.77 113.34,33.59 113.34,33.39 v3(112.88,32.93)
DDR_B_DQS#2: length 67.9
  IN1 w0.091: v3(106.32,39.58) 106.32,39.87 106.21,39.98 105.89,39.98 105,39.09 104.61,39.09 103.04,37.52 102.19,37.52 96.82,32.15 74.37,32.15 74.06,31.83 66.76,31.83 65.58,30.66 57.11,30.66 54.59,33.18 52.45,33.18 52.25,32.97 52.25,32.69 52.46,32.48 52.53,32.48 v1(52.6,32.55)
  BOTTOM w0.102: v3(106.32,39.58) 106.29,39.58 106.16,39.7 106.16,40.04 106.29,40.17 107.45,40.17 107.85,40.57 109.01,40.57 U1.BG11 ; JDIMM2.45 54.07,32.45 53.77,32.76 53.59,32.94 53.55,32.98 52.34,32.98 52.25,32.9 52.25,32.67 52.46,32.46 52.57,32.46 52.6,32.5 v1(52.6,32.55)
DDR_B_DQS#3: length 64.7
  IN1 w0.091: v3(60.74,36.43) 60.55,36.43 60.44,36.54 60.44,36.81 60.6,36.97 61.83,36.97 61.92,36.88 61.92,36.65 62.15,36.42 62.49,36.42 62.72,36.65 62.72,36.88 62.81,36.97 63.09,36.97 63.18,36.88 63.18,36.35 63.41,36.12 63.75,36.12 63.98,36.35 63.98,36.88 64.07,36.97 64.35,36.97 64.44,36.88 64.44,36.71 64.67,36.48 65.01,36.48 65.24,36.71 65.24,36.88 65.33,36.97 65.61,36.97 65.7,36.88 65.7,36.35 65.93,36.12 66.27,36.12 66.5,36.35 66.5,36.88 66.59,36.97 66.87,36.97 66.96,36.88 66.96,36.67 67.19,36.44 67.53,36.44 67.76,36.67 67.76,36.88 67.85,36.97 68.21,36.97 68.74,36.45 72.33,36.45 72.67,36.79 96.49,36.79 100.86,41.16 102.24,41.16 103.51,42.42 107.35,42.42 107.6,42.68 107.6,43.69 107.66,43.74 107.77,43.74 v1(107.82,43.69)
  BOTTOM w0.102: U1.BD17 110.26,43.91 110.03,44.14 107.7,44.14 107.61,44.05 107.61,43.9 v1(107.82,43.69) ; v3(60.74,36.43) 60.51,36.43 60.4,36.54 60.4,36.95 60.67,37.23 61.43,37.23 61.88,37.68 61.88,37.81 62.01,37.93 62.17,37.93 62.24,37.86 62.24,37.71 62.4,37.55 JDIMM2.62
