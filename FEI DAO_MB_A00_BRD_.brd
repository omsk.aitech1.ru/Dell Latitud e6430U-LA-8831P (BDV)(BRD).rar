# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CHASSIS: length 15.7
  TOP w0.508: R1114.2 R1113.2 R1112.2 R1111.2 314.11,70.9 v1(314.02,70.8)
  BOTTOM w0.508: C1104.2 v1(314.02,70.8)
GNDA: length 32.5
  TOP w0.127: v4(18.45,35.99) v1(18.45,35.35) ; v4(18.44,32.43) v1(18.44,33.09)
  TOP w0.254: U72.33 26.58,36.16 v1(26.45,36.03) ; U72.26 27.39,39.66 26.89,40.15 v1(26.89,40.47) ; v1(25.81,38) 26.15,37.66 v4(26.42,37.66) U72.30
  TOP w0.508: v1(29.55,43.85) 30.02,43.38 C966.2 ; C979.2 34.79,43.79 35.04,43.53 v1(35.04,42.91) 35.07,42.89 C980.2 ; C965.2 29.27,44.9 v1(29.63,44.53) ; v1(16.15,38.33) 16.35,38.53 C981.1 ; C957.2 v1(28.53,29.47) ; C983.1 v1(18.38,29.6) ; v1(22.97,33.03) 23.27,32.73 C963.2 ; v1(25.84,29.22) 25.66,29.04 C956.2 ; v1(15.4,38.36) 15.4,38.92 13.35,40.97 10.41,40.97 9.39,39.95 JHP1.5 ; C955.2 v1(27.29,29.22) ; v1(23.07,35.49) 23.08,35.5 C964.2 ; C1180.2 27.45,44.8 v1(28.03,44.22)
  BOTTOM w0.508: v1(16.44,33.33) D81.1 ; v1(18.44,33.09) C1213.2 ; C982.1 v1(17.63,29.69) ; C1212.2 18.87,34.93 v1(18.45,35.35) 18.89,35.8 C1211.2 ; v1(16.44,37.4) D82.1
  vias: v1(3.54,27.66) v1(8.2,27.66) v1(14.74,30.57) v1(14.74,29.83) v1(20.43,38.69) v1(30.36,45.43) v1(30.38,44.79) v1(30.99,44.56)
GNDA_CHG: length 28.4
  TOP w0.102: 35.29,24.09 v2(34.09,24.09)
  TOP w0.254: v1(30.23,22.64) 30.22,22.63 PC1333.1 PC1335.2
  TOP w0.508: PR1329.2 PC1323.2 v1(39.99,23.58) ; v1(36.67,13.09) PC1305.2 PC1303.1 ; PC1328.2 v1(40.13,20.71) ; PC1324.2 40.47,22.47 40.8,22.14 PC1325.2 v1(40.14,21.75) ; PC1326.2 v1(41.33,16.65) ; PC1307.2 PR1317.2 39.98,18.06 v1(40.16,18.23) ; v1(40.21,19.97) 40.21,19.5 PC1327.2 ; PC1309.2 v1(35.59,13.42)
  IN3 w0.508: 32.67,22.18 32.21,22.64 v1(30.23,22.64)
  IN4 w0.508: v1(35.59,13.42) 35.03,12.86 35.03,8 v1(30.42,3.39)
  BOTTOM w0.508: PC1316.2 v1(30.42,3.39)
  vias: v1(32.64,21.07) v1(32.62,19.01) v1(33.69,20.03) v1(34.73,21.09) v1(34.73,18.96) v1(35.74,23.56)
GNDA_VCCSA: length 12.7
  IN3 w0.254: v3(139.93,3.34) 140.2,3.61 145.85,3.61 v1(147.29,2.17)
  BOTTOM w0.254: PU7.1 145.56,5.67 146.73,4.51 PC90.2 146.73,3.77 147.29,3.21 v1(147.29,2.17)
VCC_AXG_SENSE: length 95.7
  TOP w0.254: RC99.2 RC76.2 150.14,58.81 149.61,58.28 149.61,57.69 149.12,57.2 148.7,57.2 v1(148.65,57.15) ; PC703.1 136.31,88.17 v1(135.74,88.74)
  IN1 w0.084: 132.68,56.42 132.21,56.42 131.13,57.49 129.76,57.49 129.26,58 129.25,58 v1(129.24,58.01)
  IN1 w0.254: v1(135.74,88.74) 137.34,88.74 139.39,86.7 140.66,86.7 141.14,87.18 141.14,88.15 140.89,88.4 140.89,92.28 142.25,93.64 145.21,93.64 147.25,91.6 151.47,91.6 151.8,91.27 153.95,91.27 157.23,88 157.23,74.92 154.3,72 154.3,63.54 150.37,59.61 150.37,58.72 148.92,57.27 148.77,57.27 v1(148.65,57.15) 148.18,56.68 147.49,56.68 147.34,56.52 143.85,56.52 143.41,56.97 140.33,56.97 139.33,55.97 133.13,55.97 132.68,56.42
  BOTTOM w0.102: v1(129.24,58.01) 129.57,57.68 U1.F45
  BOTTOM w0.254: PR702.2 137.65,91.25 PR704.2 137.01,89.75 135.92,89.75 v2(135.74,89.57) v1(135.74,88.74)
VCC_VAL_SENSE: length 37.5
  TOP w0.102: v2(139.52,76.45) 139.24,76.17 RC120.2 138.5,76.17 RC71.1 137.15,77.04 v1(136.98,76.86)
  IN2 w0.102: v5(127.89,57.08) 127.89,57.16 127.46,57.6 127.13,57.6 126.87,57.86 126.87,58.42 128.29,59.84 128.49,59.84 128.87,60.22 128.87,61.48 129.29,61.9 129.29,64.48 130.49,65.67 130.49,69.75
  IN2 w0.122: 130.49,69.75 130.49,70.27 128.03,72.72 128.03,76.26 131.12,79.35 134.34,79.35 136.83,76.86 v1(136.98,76.86)
  BOTTOM w0.102: U1.H43 127.89,56.92 v5(127.89,57.08)
VCCP: length 5
  TOP w0.102: v2(142.3,80.08) 142.3,80.26 142.72,80.68 v1(142.72,80.69)
  TOP w0.254: v1(142.72,80.69) 143.06,81.04 PC715.1
  BOTTOM w0.203: PU700.26 144.19,81.36 143.52,80.69 v1(142.72,80.69)
  BOTTOM w0.254: v1(142.72,80.69) 142.27,80.25 PR717.1
VCCP_PWRCTRL: length 2.3
  BOTTOM w0.102: RC140.2 104.95,46.12 RC141.1 v2(105.83,48.03)
VCCPWRGOOD_0_R: length 15.1
  TOP w0.102: v1(132.34,67.8) v4(131.58,68.56) 131.36,68.78 RC25.2 129.14,68.95 RC130.1
  IN1 w0.084: v1(132.81,59.48) 132.99,59.66 132.99,67.15 v1(132.34,67.8)
  BOTTOM w0.102: v1(132.81,59.48) 132.81,59.15 132.17,58.51 131.45,58.51 U1.B46
VCCSA_SENSE: length 65
  TOP w0.254: v1(136.2,14.45) 136.2,14.19 135.84,13.84 134.96,13.84 134.46,14.34 134.46,15.36 133.99,15.83 133.99,18.14 130.53,21.6 129.98,21.6 127.41,24.17 127.41,24.71 128.05,25.35 128.05,29.44 127.58,29.91 125.43,29.91 124.92,30.41 v2(124.92,36.74) 124.92,40.06 v5(124.43,40.55)
  IN1 w0.254: v1(136.2,14.45) 136.2,14.21 137.56,12.85 138.65,12.85 140.09,11.41 145.37,11.41 146.75,10.04 148.22,10.04 149.33,8.93 149.33,4.81 147.22,2.7 143.24,2.7 142.59,2.05 141.64,2.05 v1(141.52,2.17)
  BOTTOM w0.102: U1.U10 124.17,40.29 v5(124.43,40.55)
  BOTTOM w0.254: v1(141.52,2.17) PR88.2
VCCSA_VID_0: length 64
  IN2 w0.122: v1(142.2,16.02) 141.79,16.43 140.95,16.43 139.95,17.43 139.95,18.36 138.16,20.15 138.16,29.72 137.09,30.78 137.09,35.56 134.47,38.17 v3(134.47,40.27)
  IN4 w0.084: v3(134.47,40.27) 134.47,41.28 133.08,42.68 131.78,42.68 131.35,42.25 128.39,42.25 127.21,43.43 124.43,43.43 124.24,43.62 124.24,46.21 123.31,47.14 123.31,55.45 124,56.13 124,56.13 124.13,56.27 125.67,56.27 126.98,57.58 129.33,57.58 129.6,57.31 130.18,57.31 130.43,57.57 130.43,58.14 129.82,58.75 v5(129.82,58.93)
  BOTTOM w0.102: v5(129.82,58.93) 130.03,59.13 U1.D48
  BOTTOM w0.254: v1(142.2,16.02) 142.4,15.82 PR91.2
VCCSA_VID_1: length 68.1
  TOP w0.102: v2(143.16,15.33) 143.11,15.37 v1(143.11,16)
  IN2 w0.122: v1(134.5,41.97) 135.22,41.25 135.22,38.03 137.4,35.85 137.4,30.85 138.4,29.85 138.4,20.35 139.22,19.53 140.87,19.53 142.21,18.2 142.21,16.91 v1(143.11,16)
  IN4 w0.084: v5(129.87,60.4) 129.87,60.16 131.43,58.6 131.43,56.48 131.01,56.06 127.7,56.06 127.69,56.05 124.2,56.05 123.53,55.38 123.53,47.41 124,46.94 124.94,46.94 125.21,46.66 125.21,44.69 125.53,44.37 128.61,44.37 129.75,43.23 133.24,43.23 v1(134.5,41.97)
  BOTTOM w0.102: v5(129.87,60.4) 129.93,60.4 130.41,59.92 U1.D49
  BOTTOM w0.254: v1(143.11,16) 143.11,15.51 PR90.2
VCCSAPWROK: length 14.5
  TOP w0.254: v1(144.43,13.74) 143.92,14.25 139.17,14.25 v4(138.64,14.77) 138.47,14.94 138.47,19.12 137.7,19.9 v1(137.7,21.14)
  BOTTOM w0.254: U50.2 137.76,21.21 v1(137.7,21.14) ; PR80.1 144.5,13.66 v1(144.43,13.74)
VCCSENSE: length 42.5
  TOP w0.254: RC66.2 147.96,52.94 RC67.2 RC75.1 149.26,53.26 148.51,52.51 v1(148.51,52.22)
  IN3 w0.254: v1(148.51,52.22) 148.51,53.69 149.48,54.66 149.48,59.33 153.57,63.42 153.57,66.11 155.45,67.99 155.45,75.31 153.12,77.65 153.12,81.73 v1(153.19,81.81)
  BOTTOM w0.254: v1(153.19,81.81) 153.26,81.81 154.08,82.64 v2(154.08,82.78) 154.08,83.11 153.59,83.6 PR736.2 152.27,83.6 PR740.2 152.25,83.97 152.35,84.07 PC737.1
VCCSENSE_R: length 23.3
  TOP w0.254: RC67.1 v2(148.37,55.23) 148.37,55.74 v1(148.28,55.83)
  IN1 w0.102: 134.13,54.78 131.97,54.78 130.21,56.54 129.66,56.54 v5(129.15,57.04)
  IN1 w0.254: 134.13,54.78 134.4,54.51 139.28,54.51 140.86,56.08 142.72,56.08 143.07,55.74 148.19,55.74 v1(148.28,55.83)
  BOTTOM w0.102: U1.F43 129.57,56.62 v5(129.15,57.04)
VDD_1.5V: length 11.9
  TOP w0.508: PR201.1 37.23,70.05 v1(37.24,70.06) ; v1(43.59,67.71) 44.02,68.15 v2(44.02,68.53) 44.02,69.43 PR202.2
  BOTTOM w0.508: v1(43.59,67.71) 40.89,67.71 v1(40.37,67.19) 39.29,67.19 38.7,67.78 38.7,68.48 37.24,69.94 v1(37.24,70.06)
VDD_PWRGD: length 5.3
  BOTTOM w0.102: v2(166.97,103.15) 165.36,103.15 R389.2 163.48,102.68 163.41,102.74 U9.13
VSS_AXG_SENSE: length 90.2
  TOP w0.254: RC76.1 150.22,57.44 RC100.1 149.57,56.91 149.24,56.58 v1(148.89,56.58) ; PC706.2 141.03,86.19 140.56,86.66 v1(140.56,87.46)
  IN1 w0.084: 132.68,55.78 132.36,55.78 131.03,57.11 129.65,57.11 129.2,57.55 129.02,57.55 v5(128.58,58)
  IN1 w0.254: 132.68,55.78 132.87,55.59 139.49,55.59 140.52,56.61 143.24,56.61 143.68,56.17 147.49,56.17 147.63,56.31 148.62,56.31 v1(148.89,56.58) 149.08,56.77 149.05,56.77 150.75,58.47 150.75,59.48 154.66,63.39 154.66,71.85 157.59,74.77 157.59,88.15 154,91.74 151.99,91.74 151.66,92.07 147.44,92.07 145.4,94.11 141.98,94.11 140.37,92.49 140.37,87.65 v1(140.56,87.46)
  BOTTOM w0.102: U1.G45 128.92,57.65 v5(128.58,58)
  BOTTOM w0.203: v2(140.71,86.22) 141.09,85.84 PU700.39
  BOTTOM w0.254: v1(140.56,87.46) 140.56,86.37 v2(140.71,86.22)
VSS_NCTF_1: length 0.7
  BOTTOM w0.254: UH4.A4 171.02,19.59
VSS_NCTF_2: length 0.6
  BOTTOM w0.254: UH4.A44 170.53,39.65 170.96,40.08
VSS_NCTF_3: length 0.7
  BOTTOM w0.254: UH4.A45 171.02,40.74
VSS_NCTF_4: length 0.6
  BOTTOM w0.254: 170.93,41.26 170.53,40.85 UH4.A46
VSS_NCTF_5: length 0.7
  BOTTOM w0.254: UH4.A5 171.02,20.19
VSS_NCTF_6: length 0.7
  BOTTOM w0.254: UH4.A6 171.02,20.79
VSS_NCTF_7: length 0.7
  BOTTOM w0.254: UH4.B3 170.5,19.07
VSS_NCTF_8: length 0.7
  BOTTOM w0.254: UH4.B47 170.5,41.86
VSS_NCTF_9: length 0.7
  BOTTOM w0.254: UH4.BD1 149.04,18.16
VSS_NCTF_10: length 0.7
  BOTTOM w0.254: 149.04,42.77 UH4.BD49
VSS_NCTF_11: length 0.7
  BOTTOM w0.254: UH4.BE1 148.44,18.16
VSS_NCTF_12: length 0.7
  BOTTOM w0.254: 148.44,42.77 UH4.BE49
VSS_NCTF_13: length 0.7
  BOTTOM w0.254: UH4.BF1 147.84,18.16
VSS_NCTF_14: length 0.7
  BOTTOM w0.254: 147.84,42.77 UH4.BF49
VSS_NCTF_15: length 0.7
  BOTTOM w0.254: UH4.BG2 147.38,18.61
VSS_NCTF_16: length 0.6
  BOTTOM w0.254: 147.42,42.27 UH4.BG48
VSS_NCTF_17: length 0.7
  BOTTOM w0.254: UH4.BH3 146.92,19.07
VSS_NCTF_18: length 0.7
  BOTTOM w0.254: 146.92,41.86 UH4.BH47
VSS_NCTF_19: length 0.7
  BOTTOM w0.254: UH4.BJ4 146.41,19.59
VSS_NCTF_20: length 0.6
  BOTTOM w0.254: 146.45,40.1 UH4.BJ44
VSS_NCTF_21: length 0.7
  BOTTOM w0.254: UH4.BJ45 146.42,40.73
VSS_NCTF_22: length 0.7
  BOTTOM w0.254: UH4.BJ46 146.43,41.31
VSS_NCTF_23: length 0.7
  BOTTOM w0.254: 146.41,20.19 UH4.BJ5
VSS_NCTF_24: length 0.7
  BOTTOM w0.254: 146.41,20.79 UH4.BJ6
VSS_NCTF_25: length 0.7
  BOTTOM w0.254: UH4.C2 170.05,18.61
VSS_NCTF_26: length 0.7
  BOTTOM w0.254: UH4.C48 170.05,42.31
VSS_NCTF_27: length 0.7
  BOTTOM w0.254: UH4.D1 169.59,18.16
VSS_NCTF_28: length 0.7
  BOTTOM w0.254: UH4.D49 169.59,42.77
VSS_NCTF_29: length 0.7
  BOTTOM w0.254: UH4.E1 168.99,18.16
VSS_NCTF_30: length 0.7
  BOTTOM w0.254: UH4.E49 168.99,42.77
VSS_NCTF_31: length 0.7
  BOTTOM w0.254: UH4.F1 168.39,18.16
VSS_NCTF_32: length 0.7
  BOTTOM w0.254: UH4.F49 168.39,42.77
VSS_VAL_SENSE: length 37.1
  TOP w0.102: v2(138.52,78.92) RC121.2 RC71.2 137.39,77.95 v1(136.95,77.51)
  IN2 w0.102: v5(127.26,57.18) 126.93,57.18 126.55,57.57 126.55,58.61 128.04,60.09 128.04,60.7 128.55,61.22 128.55,61.59 128.99,62.03 128.99,64.6 130.21,65.82 130.21,69.75
  IN2 w0.122: 130.21,69.75 130.21,70.19 127.79,72.61 127.79,76.36 131.02,79.6 134.45,79.6 136.54,77.51 v1(136.95,77.51)
  BOTTOM w0.102: v5(127.26,57.18) 127.26,56.91 U1.K43
VSSAXG_VAL_SENSE: length 27.3
  TOP w0.102: v5(127.34,57.99) 127.76,58.41 128.53,58.41 128.64,58.52 130.17,58.52 130.52,58.87 131.45,58.87 131.65,58.67 133.58,58.67 135.21,60.3 135.21,65.97 136.19,66.95 137.61,66.95 139.83,69.17 139.83,70.1 v2(139.63,70.3) 139.63,72.37 RC69.2 137.64,74.37 RC123.2
  BOTTOM w0.102: v5(127.34,57.99) 127.62,57.71 U1.K45
VSSIO_SENSE_R: length 46.2
  TOP w0.102: RC133.1 115.8,44.76 v5(115.7,44.76)
  TOP w0.254: PR513.2 130.69,11.22 131.15,11.22 131.78,11.85 131.78,15.3 131.48,15.61 131.48,19.16 130.12,20.52 129.47,20.52 126.29,23.7 126.29,25.14 127.01,25.85 127.01,26.78 v4(126.63,27.16) 125.33,28.46 v1(124.29,28.46)
  IN4 w0.127: v1(124.29,28.46) 124.29,28.67 120.76,32.2 120.76,42.78 120.2,43.34 116.85,43.34 116.52,43.68 116.52,43.95 115.71,44.76 v5(115.7,44.76)
  BOTTOM w0.102: U1.AN17 116.07,44.4 v5(115.7,44.76)
VSSIO_SENSE_R_FB: length 1.8
  TOP w0.254: PR514.1 PR513.1 129.13,11.01 129.06,10.94 PR510.1
VSSSENSE: length 49.1
  TOP w0.254: RC68.2 148.54,50.57 RC70.1 148.57,50.58 149.18,51.19 v1(149.18,52.23) 149.76,52.82 149.76,53.87 149.37,54.26 RC75.2
  IN3 w0.254: v1(149.18,52.23) 149.18,53.73 149.84,54.39 149.84,59.18 154.01,63.34 154.01,65.99 155.86,67.84 155.86,75.46 153.52,77.8 153.52,81.29 153.85,81.62 153.85,83.63 152.62,84.86 v1(151.73,84.86)
  BOTTOM w0.102: v2(151.14,85.46) 151.16,85.43
  BOTTOM w0.203: PC741.1 148.37,84.24 PU700.16
  BOTTOM w0.254: v2(151.14,85.46) 149.28,85.46 148.67,84.85 PC741.1 ; 151.16,85.43 v1(151.73,84.86)
VSSSENSE_R: length 27.5
  TOP w0.254: RC68.1 146.7,49.53 v3(147,49.24)
  IN1 w0.102: 133.77,54.5 131.74,54.5 130.05,56.18 129.37,56.18 v1(128.53,57.02)
  IN1 w0.254: v3(147,49.24) 146.8,49.43 146.8,53.45 144.9,55.36 142.94,55.36 142.58,55.72 141.04,55.72 139.44,54.12 134.14,54.12 133.77,54.5
  BOTTOM w0.102: U1.G43 128.92,56.63 v1(128.53,57.02)
+ADDR_XEN: length 4
  TOP w0.127: v1(155.32,105.21) v2(156.08,105.21)
  BOTTOM w0.254: R393.1 155.51,104.58 155.67,104.74 U9.32
  BOTTOM w0.508: v1(155.32,105.21) R393.1
+BL_PWR_SRC: length 49
  TOP w2.032: 141.84,101.34 137.7,101.34 135.15,103.9 126.28,103.9 125.34,102.96 106.9,102.96 103.54,106.32 98.53,106.32 98.13,105.92 95.87,105.92
  vias: v1(95.86,108.18) v1(95.86,107.54) v1(96.49,108.18) v1(96.49,107.54) v1(141.78,103.23) v1(142.41,103.23) v1(143.05,103.23) v1(143.68,103.23) v4(143.71,101.38)
+CAMERA_VDD: length 80.5
  TOP w0.102: v1(150.42,109.37) v2(149.7,109.37)
  IN3 w1.016: 150.72,108.38 149.07,106.73 147.52,106.73 145.04,104.25 141.54,104.25 140.75,103.45 140.75,101.76 138.12,99.13 138.12,98.31 137.33,97.52 133.62,97.52 132.94,98.21 118.26,98.21 112.02,91.97 99.93,91.97 96.74,95.16 93.5,95.16 92.13,96.53 92.13,102.63 93.83,104.33 93.83,106.33
  vias: v1(92.93,108.23) v1(92.93,107.59) v1(151.1,109.36)
+CAP_LDO: length 10.8
  TOP w0.127: v2(256.05,84.27) 256.05,84.13 257.32,82.86 C714.1
  TOP w0.254: U46.B46 262.59,79.43 v1(262.37,79.21)
  TOP w0.508: C714.1 257.49,82.86 v1(258.09,82.26)
  IN1 w0.508: v1(262.37,79.21) 262.37,80.53 259.94,82.97 258.59,82.97 258.09,82.47 v1(258.09,82.26)
+COINCELL: length 7.6
  TOP w0.508: JRTC1.1 317.38,9.26 317.15,9.03 316.62,9.03 316.28,9.37 v2(313.09,9.37) 312.14,9.37 311.62,8.85 PR1.1
+CRT_VCC: length 7.4
  TOP w0.127: v1(9.66,60.35) 9.75,60.44 v4(9.75,61.16)
  TOP w0.457: C1224.2 21.75,78.83 21.57,78.65 U73.5 ; v1(13.63,76.88) 14.1,77.35 U74.5
  TOP w0.508: v1(22.78,78.1) 22.31,78.57 C1224.2 ; R1644.1 9.48,73.33 v1(9.14,73.67)
  BOTTOM w0.508: v1(11.7,78.47) R1646.1 R1647.1 ; R1645.1 v1(10.9,81.07)
  vias: v1(7.21,76.6) v1(7.84,76.6) v1(9,60.33)
+DC1_PWR_SRC: length 62.9
  TOP w0.254: PU100.16 249.27,12.58
  TOP w0.508: v1(249.2,14.75) 248.52,14.75 PC116.1 v4(248.51,13.34) 249.27,12.58
  TOP w2.032: 255.49,18.12 255.49,20.52 254.18,21.83 244.58,21.83 239.22,16.47 239.11,16.47
  IN3 w0.508: v1(239.92,15.02) 241.52,16.62 246.31,16.62 248.18,14.75 v1(249.2,14.75)
  BOTTOM w0.508: PD100.1 248.83,14.38 v1(249.2,14.75)
  BOTTOM w3.048: 220.55,10.58 223.12,13.14 223.12,15.15 226.99,19.02 234.47,19.02 236.23,17.27 238.83,17.27
  vias: v1(239.16,15.03) v1(239.57,14.48) v1(240.3,14.49)
+DC_IN: length 117.3
  TOP w0.127: v4(49.52,14.65) v1(48.77,14.65)
  IN2 w0.508: v1(48.77,14.65) 46.79,14.65 44.95,12.81 40.86,12.81 39.61,14.06 35.21,14.06 33.86,12.71 32.4,12.71 30.34,14.77 24.33,14.77 22.62,13.07 20.17,13.07 20,13.24 19.37,13.24 18.87,12.74 v1(18.87,10.84)
  IN3 w0.508: v1(47.47,50.24) 47.26,50.24 45.41,52.09 38.87,52.09 37.41,53.55 24.92,53.55 23.11,51.75 20.86,51.75 19.12,53.49 19.12,62.61 v1(19.53,63.01)
  BOTTOM w0.508: PR1335.1 v1(18.87,10.84) ; v1(48.77,14.65) 50.01,14.65 51.31,15.95 51.31,19.98 50.38,20.92 50.38,37 46.81,40.57 46.81,49.57 v1(47.47,50.24)
  vias: v1(19.53,65.55) v1(19.53,64.92) v1(19.53,64.28) v1(19.53,63.65) v1(20.22,65.55) v1(20.22,64.92) v1(20.22,64.28) v1(20.22,63.65) v1(20.22,63.01) v4(18,69.81) v4(18.31,63.87)
+DC_IN_SS: length 168.1
  TOP w0.102: v4(27.62,75.89) 28.05,75.46 v1(28.67,75.46)
  TOP w0.254: PU1300.22 32.19,17.13 31.94,16.88 31.35,16.88
  TOP w0.508: v1(27.08,16.53) 27.4,16.22 PC1306.1 29.62,16.22 30.28,16.88 31.35,16.88 ; PR1306.1 29.42,75.46 v1(28.67,75.46)
  IN1 w0.508: v1(15.75,64.65) 16.6,64.65 17.2,65.25 17.2,68.5 19.39,70.69 21.63,70.69 24.72,73.77 24.72,74.48 25.7,75.46 v1(28.67,75.46)
  IN2 w0.508: v1(32.37,64.25) 31.91,64.7 31.91,68.36 28.67,71.6 v1(28.67,75.46) ; v1(27.08,16.53) 28.29,17.74 29.88,17.74 30.32,17.29 38.84,17.29 42,14.13 43.88,14.13 45.67,15.92 v1(47.56,15.92) 51.81,15.92 53.21,14.53 58.02,14.53 58.49,14.06 60.31,14.06 61.05,14.81 65.4,14.81 v1(65.91,15.32)
  IN4 w0.508: v1(45.93,46.24) 47.1,46.24 47.68,46.82 47.68,48.93 46.2,50.42 46.2,59.59 42.75,63.03 35.16,63.03 33.94,64.25 v1(32.37,64.25)
  BOTTOM w0.508: v1(45.93,46.24) 45.93,40.31 49.74,36.49 49.74,20.65 50.68,19.72 50.68,16.22 49.97,15.5 47.98,15.5 v1(47.56,15.92) ; PQ1301.4 PR410.1 72.54,10.38 71.87,11.04 67.2,11.04 65.91,12.33 v1(65.91,15.32)
  vias: v1(15.06,64.65) v1(15.06,64.02) v1(15.06,63.38) v1(15.06,62.75) v1(15.06,62.11) v1(15.75,64.02) v1(15.75,63.38) v1(15.75,62.75) v1(15.75,62.11)
+DCIN_JACK: length 0.9
  TOP w0.102: v1(15.02,72.25) v4(15.02,71.4)
  vias: v1(14.38,73.52) v1(14.38,72.89) v1(14.38,72.25) v1(15.02,73.52) v1(15.02,72.89) v1(15.72,73.52) v1(15.72,72.89) v1(15.72,72.25) v1(24.16,70.56) v1(24.16,69.93) v1(24.16,69.29) v1(24.78,70.77) v1(24.78,70.13) v1(24.78,69.5) v1(25.42,70.56) v1(25.42,69.93) v1(25.42,69.29) v4(23.41,70.05) v4(25.24,71.21)
+DDR_CHG: length 2.7
  BOTTOM w0.102: R927.2 v2(33.18,85.76)
  BOTTOM w0.508: Q72.1 R927.2
+DIMM0_1_CA_CPU: length 46.1
  IN2 w0.508: v1(104.19,37.59) 102.4,37.59 84.49,19.68 v3(80.45,19.68)
  BOTTOM w0.254: U1.BG7 108.79,38.74 107.52,37.47
  BOTTOM w0.508: QD2.3 77.55,14.87 77.68,14.99 RD6.1 v3(80.45,19.68) ; v1(104.19,37.59) 104.74,37.04 RC97.2 107.09,37.04 107.52,37.47
+DIMM0_1_VREF_CPU: length 55.3
  TOP w0.508: RC96.2 110.55,40.9 110.09,40.45 v5(110.09,39.39)
  IN2 w0.508: v3(71.86,14.78) 74.13,14.78 79.66,20.31 84.23,20.31 102.65,38.73 104.29,38.73 v1(105.01,38.01)
  IN3 w0.508: v1(105.01,38.01) 105.01,38.36 105.52,38.87 109.57,38.87 v5(110.09,39.39)
  BOTTOM w0.254: U1.BE7 110.09,38.94 v5(110.09,39.39)
  BOTTOM w0.508: RD5.1 71.02,12.75 71.06,12.79 QD1.3 v3(71.86,14.78)
+DIMM1_VREF_CA: length 55.5
  IN2 w0.508: v3(74.44,61.99) 75.63,60.79 75.63,53.74 73.37,51.48 73.37,24.81 66.57,18.01 v1(66.57,15.31)
  BOTTOM w0.356: JDIMM1.126 74.6,62.15 v3(74.44,61.99)
  BOTTOM w0.508: CD7.1 CD8.1 RD7.2 v1(66.57,15.31)
+DIMM1_VREF_DQ: length 11.7
  BOTTOM w0.254: JDIMM1.1 69.43,22.25 69.78,21.9
  BOTTOM w0.508: 69.78,21.9 70.35,21.33 v2(70.35,16.51) RD1.2 70.03,15.48 69.36,14.82 RD2.2 CD2.1 CD1.1
+DIMM2_VREF_CA: length 53
  IN2 w0.508: v1(65.49,59.83) 65.49,58.85 63.7,57.06 63.7,50.9 62.52,49.72 62.52,18.04 59.25,14.78 v3(59.25,14.75)
  BOTTOM w0.356: JDIMM2.126 65.15,59.15 65.49,59.49 v1(65.49,59.83)
  BOTTOM w0.508: v3(59.25,14.75) 58.59,14.09 RD12.2 CD29.1 CD30.1
+DIMM2_VREF_DQ: length 11.4
  BOTTOM w0.127: RD10.2 v2(54.18,11.36)
  BOTTOM w0.254: JDIMM2.1 54.25,19.25 53.88,18.88
  BOTTOM w0.508: RD10.2 CD24.1 CD23.1 RD11.2 55.8,14.93 53.88,16.85 53.88,18.88
+GFX_PWR_SRC:
  vias: v2(117.84,90.87)
+LCDVDD: length 8.1
  TOP w0.127: v4(136.12,100.02) 136.12,99.21 136.21,99.13 v1(136.21,99.12)
  BOTTOM w0.508: C1330.1 107,88.07 C298.1 107.65,88.97 108.44,89.76 108.44,90.55 107.93,91.06 107.93,93.05 v1(107.21,93.77)
  vias: v1(107.55,108.03) v1(107.55,107.39) v1(108.19,108.03) v1(108.19,107.39) v1(134.31,99.12) v1(134.94,99.12) v1(135.58,99.12)
+OZ_AVDD:
  vias: v2(277.21,10.96)
+OZ_DVDD:
  vias: v2(279.51,9.92)
+PCH_V5REF_RUN: length 5.6
  TOP w0.102: v2(164.43,36.22) 164.43,35.85 v1(164.09,35.5)
  BOTTOM w0.254: UH4.P34 163.74,35.16 v1(164.09,35.5)
  BOTTOM w0.508: v1(181.44,33.59) 182,33.03 RH213.2 182.49,33.16 CH71.1 183.8,34.1 DH3.1
+PCH_V5REF_SUS: length 30.6
  IN2 w0.508: v1(165.44,30.46) 170.44,30.46 170.94,30.96 174.81,30.96 175.69,31.84 182.14,31.84 182.4,32.1 185.93,32.1 v1(186.48,31.55)
  BOTTOM w0.254: v1(165.44,30.46) 165.44,30.63 UH4.M26
  BOTTOM w0.508: DH2.1 183.21,36.54 CH63.1 185.07,36.54 RH208.2 185.1,34.92 v2(186.08,33.94) 186.11,33.91 186.11,31.92 v1(186.48,31.55)
+PE_VDDH:
  vias: v2(276.89,17.23)
+PECI_VREF: length 5.5
  TOP w0.127: v2(280.36,52.5) C737.1
  TOP w0.254: U51.B51 283.22,54.35 282.54,53.67 281.35,53.67 281.3,53.72 C737.1
  TOP w0.508: C737.1 R862.1
+PWR_SRC: length 182.9
  TOP w1.524: 144.98,96.48 146.11,96.48 152.56,90.03 154.45,90.03 155.71,88.77 155.71,83.33 157.92,81.12 157.92,78.79 155.15,76.02 155.15,76.01
  TOP w2.032: 47.66,77.87 47.66,85.81 49.41,87.56 65.91,87.56 67.91,89.57 79.79,89.57 81.45,91.23 81.45,94.6 86.38,99.53 98.52,99.53 99.36,98.69 101.5,98.69 104.58,95.62
  TOP w2.54: 107.85,95.65 111.74,99.54 131.51,99.54 134.19,96.86 139.16,96.86 139.98,96.03
  TOP w3.048: 181.82,4 181.78,3.96 173.42,3.96 172.22,5.17 165.96,5.17
  TOP w4.572: 40.33,49.69 37.71,49.69 32.39,55.01 27.83,55.01
  IN2 w5.08: 46,57.6 47.21,58.81 47.21,70.89
  vias: v1(35.29,71.61) v1(35.29,70.98) v1(35.92,71.61) v1(35.92,70.98) v1(44.71,47.75) v1(44.67,37.42) v1(44.67,36.79) v1(44.77,48.54) v1(44.98,49.22) v1(45.26,48.08) v1(45.27,47.34) v1(45.31,37.42) v1(45.31,36.79) v1(45.31,36.15) v1(45.31,35.52) v1(45.47,48.75) v1(45.94,47.58) v1(45.94,36.15) v1(45.94,35.52) v1(45.95,48.27) v1(47.27,76.41) v1(47.26,75.78) v1(47.27,75.14) v1(47.26,74.51) v1(47.92,76.41) v1(47.91,75.78) v1(47.92,75.14) v1(47.91,74.51) v1(67.59,5.93) v1(67.59,5.29) v1(67.59,4.66) v1(68.23,5.93) v1(68.23,5.29) v1(68.23,4.66) v1(68.86,5.93) v1(68.86,5.29) v1(68.86,4.66) v1(69.5,5.93) v1(69.5,5.29) v1(69.5,4.66) v1(130.12,2.84) v1(130.12,2.2) v1(130.75,2.84) v1(130.75,2.2) v1(131.39,2.2) v1(142.18,96.99) v1(142.82,96.99) v1(143.45,96.99) v1(144.1,96.99) v1(187.17,2.35) v1(187.56,2.92) v1(187.94,2.35) v1(190.82,4.56) v1(191.15,5.1) v1(191.51,5.66) v1(215.6,3.95) v1(215.6,3.31) v1(216.24,3.95) v1(216.24,3.31) v1(216.87,3.95) v1(216.87,3.31) v4(143.16,95.59)
+PWR_SRC_S: length 679.9
  TOP w0.508: RC72.1 105.67,12.61 v1(106.23,13.17) ; v1(197.01,43.34) 196.32,42.66 196.32,28.36 192.88,24.92 v1(192.88,24.86) 192.88,23.21 192.37,22.7 192.37,16.05 191.94,15.61 v1(191.6,15.61) ; v1(243.41,48.31) 243.41,48.97 241.97,50.42 241.97,54.85 v1(242.6,55.48) ; v1(75.72,11.12) 74.82,10.22 73.37,10.22 69.09,14.5 61.16,14.5 59.98,15.68 54.55,15.68 48.71,21.52 48.71,47.73 43.49,52.96 39.48,52.96 39.02,53.42 39.02,56.56 40.07,57.62 41.19,57.62 45.66,62.09 45.66,69.81 44.58,70.89 v1(43.5,70.89) 42.42,70.89 40.85,72.46 PQ4.1 40.85,73.68 PC8.1 ; R722.1 310.79,39.1 307.84,42.05 v1(307.84,43.65) ; v1(134.49,44.4) 135.04,44.96 R930.1 ; v1(132.99,13.15) 132.99,14.92 132.15,15.76 132.15,19.21 130.28,21.08 129.78,21.08 126.87,24 126.87,24.9 127.54,25.58 v1(127.54,27.07)
  IN1 w0.508: v1(180.47,51.52) 181.68,51.52 183.89,49.31 188,49.31 191.23,46.08 194.81,46.08 197.01,43.88 v1(197.01,43.34) 197.86,43.34 198.77,44.26 208.86,44.26 214.41,38.71 217.47,38.71 220.82,42.05 220.82,43.84 227.36,50.38 227.36,51.71 229.93,54.28 v1(231.09,54.28) ; v1(106.23,13.17) 106.23,13.94 106.91,14.63 132.56,14.63 132.99,14.2 v1(132.99,13.15) ; v1(206.14,4.05) 207,4.05 207.61,4.66 207.61,11.57 204.56,14.62 v1(200.87,14.62) 198.33,14.62 197.87,14.16 193.39,14.16 191.93,15.61 v1(191.6,15.61)
  IN2 w0.508: v1(190.58,2.18) 192.23,3.83 192.23,6.18 193.6,7.55 197.24,7.55 200.77,4.02 203.78,4.02 204.41,3.39 205.48,3.39 v1(206.14,4.05) ; v1(180.47,51.52) 179.38,50.43 174.05,50.43 171.2,53.27 171.2,58.55 170,59.75 169.8,59.75 169.27,60.28 169.27,67.41 169.1,67.57 169.1,69.13 167.91,70.31 167.91,76.78 v1(168.95,77.82)
  IN3 w0.508: v1(307.84,43.65) 306.77,44.71 306.77,48.69 305,50.47 305,53.4 304.04,54.35 304.04,56.56 302.48,58.13 v1(302.48,66.25)
  IN4 w0.508: v1(75.72,11.12) 77.55,11.12 80.76,14.34 93.59,14.34 94.66,13.26 99.11,13.26 99.8,13.95 105.83,13.95 106.23,13.56 v1(106.23,13.17) ; v1(302.48,66.25) 298.19,66.25 297.96,66.48 294.26,66.48 292.26,68.49 286.39,68.49 285.03,67.13 284.52,67.13 282.28,64.88 277.28,64.88 275.65,63.24 269.77,63.24 267.52,61 265.49,61 264.75,61.73 258.67,61.73 256.95,60.02 253.23,60.02 252.42,59.2 244.25,59.2 243.32,58.28 243.32,56.21 v1(242.6,55.48) 237.15,55.48 235.95,54.28 v1(231.09,54.28) ; v1(168.95,77.82) 168.64,77.82 168.32,78.14 168.32,80.46 160.62,88.17 159.62,88.17 153.23,94.56 137.93,94.56 137.42,95.07 v1(137.42,95.18) 137.42,96.21 135.57,98.06 133.77,98.06 131.25,100.58 115.89,100.58 114.5,99.19 108.6,99.19 99.99,90.59 91.94,90.59 91.37,90.01 86.47,90.01 86.12,89.67 68.55,89.67 65.08,86.2 64.51,86.2 63.81,85.51 60.28,85.51 59.83,85.96 51.14,85.96 42.79,77.62 42.79,71.6 v1(43.5,70.89)
  BOTTOM w0.508: v1(190.58,2.18) 191.06,2.66 R920.1 ; v1(192.88,24.86) 192.27,25.47 189.82,25.47 189.31,24.97 RH279.1 ; R564.1 v1(307.84,43.65) ; v1(127.54,27.07) v2(128.16,27.7) 130.13,29.66 130.13,30.44 131.73,32.04 131.73,35.33 133.38,36.98 133.38,43.29 v1(134.49,44.4) ; R933.1 190.33,16.34 191.06,15.61 v1(191.6,15.61) ; v1(231.09,54.28) 229.74,54.28 229.33,53.87 R940.1 ; v1(168.95,77.82) 168.33,77.2 R917.1 ; R714.1 242.23,55.11 v1(242.6,55.48) ; R729.1 243.06,46.73 243.4,47.08 243.4,48.3 v1(243.41,48.31) ; v1(137.42,95.18) 137.42,95.63 R412.1 ; R905.1 v1(206.14,4.05)
+RSVD_VCC3P3_1: length 3.6
  TOP w0.203: U31.1 284.71,78.07 284.45,77.82
  TOP w0.508: R553.2 282.57,77.44 v2(282.74,77.61) 282.77,77.65 284.28,77.65 284.45,77.82
+RSVD_VCC3P3_2: length 3
  TOP w0.203: U31.2 285.11,77.42 284.63,76.93
  TOP w0.508: 284.63,76.93 v2(284.42,76.73) 283.51,76.73 R554.2
+RTC_CELL: length 326.7
  TOP w0.457: RH38.1 RH127.2
  TOP w0.508: R1156.1 293.4,49.11 294.75,47.76 296.27,47.76 v1(297.97,49.46) ; v1(291.27,5.52) 291.27,4.35 291.79,3.83 v4(300.51,3.83) 309.62,3.83 311.37,5.59 PD4.1 312.07,7.64 PC3.1 ; v1(180.52,28.8) 180.52,29.95 180.1,30.36 177.98,30.36 176.93,29.31 176.31,29.31 175.99,29.63 174.08,29.63 173.11,28.65 RH38.1 ; R810.1 v1(297.97,49.46) ; v1(297.97,49.46) 296.99,50.44 R813.1 296.72,50.88 296.74,50.91 R815.1 ; v1(172.01,29.27) 171.77,29.51 CH89.1 CH88.1 CH90.1 RH127.2 ; v1(288.73,46.39) R870.2
  IN1 w0.508: v1(297.97,49.46) 294.9,46.39 v1(288.73,46.39) 282.93,46.39 282.77,46.55 280.22,46.55 279.33,45.67 274.74,45.67 269.63,40.55 263.84,40.55 262.08,42.3 260.2,42.3 259.73,41.83 246.37,41.83 245.31,42.9 236.01,42.9 232.23,39.11 225.96,39.11 220.83,33.98 216.92,33.98 214.97,32.03 199.79,32.03 191.66,40.16 v1(190.54,40.16) 189.41,41.28 189.41,41.89 188.01,43.29 184.04,43.29 181.83,45.5 176.48,45.5 v1(175.84,44.85)
  IN3 w0.508: v1(164.03,99.31) 164.64,98.69 164.64,75.07 165.94,73.77 165.94,68.02 166.28,67.69 166.28,66.1 165.99,65.82 165.99,62.57 166.59,61.97 166.59,59.52 166.68,59.44 166.68,55.52 169.4,52.8 169.4,52.16 175.84,45.72 v1(175.84,44.85) 176.49,44.2 177.91,44.2 181.45,40.66 181.45,36.8 182.07,36.18 182.07,33.3 180.52,31.74 v1(180.52,28.8) ; v1(297.97,49.46) 296.7,48.19 296.7,42.55 297.68,41.56 297.68,39.28 297.39,38.98 297.39,33.53 294.75,30.9 294.75,19.88 292.14,17.27 292.14,6.4 v1(291.27,5.52)
  BOTTOM w0.254: U9.16 162.81,101.24 164.04,100.01 C274.1 ; UH4.A22 170.69,28.81 171.55,28.81 v1(172.01,29.27)
  BOTTOM w0.508: v1(190.54,40.16) 190.31,40.38 RH23.1 RH22.1 RH11.1 ; v1(164.03,99.31) 164.19,99.15 164.83,99.15 R390.2 C274.1
+RTC_CELL_VBAT: length 12.5
  TOP w0.127: C723.1 294.3,48.94 294.9,48.35 v2(295.06,48.35)
  TOP w0.279: U51.B64 290.01,54.07 289.98,54.11 v1(289.98,54.46)
  TOP w0.508: R815.2 v1(295.19,51.37) ; v1(294.3,50.06) C723.1
  IN1 w0.508: v1(289.98,54.46) 289.98,53.09 290.27,52.79 293.77,52.79 v1(295.19,51.37) 295.19,50.95 294.3,50.06 v1(294.3,50.06)
+SATA_SIDE_PWR: length 66.4
  TOP w0.127: v1(242.92,95.71) 242.92,94.83 v4(243.1,94.65)
  IN1 w2.032: 259.56,94.41 250.6,94.41 248.81,92.62 245.57,92.62 244.1,94.09 ; 264.98,92.15 274.34,82.79 275.49,82.79
  IN4 w2.032: 259.4,92.14 257.23,94.31 250.25,94.31 248.79,92.85 244.23,92.85 ; 277.27,82.86 274.27,82.86 266.36,90.78 264.24,90.78 263.51,91.51
  vias: v1(242.92,96.38) v1(243.56,96.36) v1(243.57,95.69) v1(244.21,96.36) v1(244.21,95.69) v1(244.85,95.69) v1(244.86,96.36) v1(262.84,93.99) v1(262.87,95.35) v1(262.87,94.68) v1(262.86,93.35) v1(263.52,95.33) v1(263.52,94.66) v1(263.51,93.99) v1(263.52,93.35) v1(303.4,87.77) v1(303.37,87.12) v1(304.03,87.78) v1(304.02,87.13) v1(304.69,87.77) v1(304.68,87.11) v1(305.34,87.77) v1(305.33,87.09) v1(310.7,51.27) v1(310.7,50.63) v1(310.7,49.97) v1(310.69,49.31) v1(311.35,49.32) v1(311.36,51.27) v1(311.36,50.63) v1(311.36,49.97)
+SDC_IN: length 96
  TOP w0.508: PR1308.2 25.8,74.32 v1(26.19,74.71) ; PR1313.2 40.22,16.02 40.24,16.01 40.53,16.01 41.42,15.12 v1(41.97,15.12)
  IN1 w0.508: v1(26.19,74.71) 26.19,74.23 21.91,69.95 19.55,69.95 17.84,68.24 17.84,61.78 18.89,60.73 v1(19.94,60.73)
  IN2 w0.508: v1(41.97,15.12) 41.97,20.55 41.65,20.86 41.65,26.12 39.45,28.32 39.45,32.12 37.75,33.83 37.75,41.14 38.22,41.61 38.22,44.8 32.77,50.25 32.77,61.4 33.75,62.38 33.75,64.7 33.41,65.05 33.41,73.49 30.8,76.1 27.58,76.1 v1(26.19,74.71)
  vias: v4(20.24,59.74)
+SIM_PWR: length 23.6
  TOP w0.508: v1(297.05,41.3) 297.05,40.46 292.23,35.65 292.23,34.77 v4(291,33.54) 289.49,32.03 v1(289.49,29.71) 289.07,29.3 288.5,29.3 287.78,28.58 v1(287.78,27.79)
  BOTTOM w0.508: v1(289.49,29.71) 289.49,29.74 289.97,30.22 U40.5 C616.1 ; JMINI1.8 297,41.35 v1(297.05,41.3) ; JSIM1.1 v1(287.78,27.79)
+SKT_VCC:
  vias: v2(284.76,11.14)
+TRM_CT1: length 3.3
  TOP w0.508: v3(302.67,84.1) 303.2,83.56 C39.1
  BOTTOM w0.508: v3(302.67,84.1) 303.14,83.63 TR1.10
+TRM_CT2: length 4.1
  TOP w0.127: C38.1 303.81,81.42 v2(304.17,81.06)
  TOP w0.508: C38.1 303.15,82.29 v1(302.86,82)
  BOTTOM w0.508: TR1.9 304.35,82.34 303.2,82.34 v1(302.86,82)
+TRM_CT3: length 5.8
  TOP w0.508: v1(302.85,76.03) v2(302.85,76.72) 302.85,76.74 303.09,76.98 303.09,79.33 303.45,79.69 C37.1
  BOTTOM w0.508: TR1.4 302.87,76.01 v1(302.85,76.03)
+TRM_CT4: length 5.8
  TOP w0.508: v1(302.87,74.74) 303.23,74.74 v2(303.81,75.32) C36.1
  BOTTOM w0.508: TR1.3 v1(302.87,74.74)
+V_DDR_REF: length 77.8
  IN2 w0.508: v1(56.71,17.14) 55.61,16.04 53.19,16.04 52.09,17.14 45.78,17.14 44.67,18.25 44.67,26.06 43.03,27.7 43.03,46.8 37.95,51.88 37.95,58.81 39.17,60.03 v1(39.17,61.83)
  BOTTOM w0.508: RD2.1 RD7.1 67.49,15.49 v2(66.82,16.15) 64.1,16.15 63.72,15.77 57.94,15.77 57.64,15.47 RD12.1 RD11.1 v1(56.71,17.14)
+V_DDR_REFA_M3: length 7
  BOTTOM w0.102: v2(69.83,11.59) 69.83,13.14 RD5.2
  BOTTOM w0.508: QD1.1 72.83,15.52 72.51,15.83 71.85,15.83 70.59,14.57 RD1.1 RD5.2
+V_DDR_REFB_M3: length 27.2
  IN2 w0.508: v3(74.75,11.19) 73.45,9.89 61.37,9.89 60.84,10.42 v1(56.71,10.42)
  BOTTOM w0.508: RD6.2 79.58,14.08 79.4,13.9 QD2.1 78.25,12.93 77.17,11.85 75.41,11.85 v3(74.75,11.19) ; RD10.1 v1(56.71,10.42)
+V_DDR_SMREF: length 4.8
  TOP w0.102: RC81.1 102.83,74.06 v2(102.65,73.87)
  TOP w0.508: QC5.1 102.77,77.43 102.83,77.37 RC134.1 RC80.2 RC81.1
+V_SM_VREF_CNT: length 27.5
  TOP w0.508: RC134.2 101.61,77.11 v1(101.61,78.28) 101.61,79.49 101.81,79.69 QC5.3 ; v1(102.86,58.25) 102.28,57.67 RC84.2 100.86,57.67 RC78.1
  BOTTOM w0.254: U1.AY43 112.58,56.57 112.88,56.87 v5(112.88,57.02)
  BOTTOM w0.508: v1(102.86,58.25) v4(102.86,76.35) 102.86,77.02 v1(101.61,78.28)
+VCHGR: length 42.7
  TOP w0.127: v4(62.49,6.56) 62.43,6.5 v1(61.54,6.5)
  TOP w0.508: v1(31.94,23.48) 31.94,24.48 31.49,24.93 PR1328.2
  BOTTOM w0.254: v1(31.94,23.48) 32.79,22.63 34.75,22.63 36.78,20.6 37.66,20.6 38.93,19.33 43.46,19.33 44.42,18.37 44.42,11.58 43.05,10.21 27.93,10.21 27.32,10.82 v1(27.32,11.1)
  vias: v1(26.05,11.06) v1(26.05,11.72) v1(26.69,11.73) v1(26.69,11.1) v1(27.11,12.48) v1(27.32,11.73) v1(27.74,12.48) v1(27.96,11.71) v1(27.96,11.07) v1(61.52,5.78) v1(61.54,5.1) v1(62.29,5.21) v1(62.92,5.21) v1(63.71,5.22) v1(63.9,6.49) v1(64.23,5.84) v1(64.55,5.19) v1(64.56,6.5)
+VCHGR_B: length 12.9
  TOP w0.127: 21.75,18.5 21.74,18.49 21.74,17.85 v2(21.54,17.66)
  IN4 w1.016: 21.9,17.6 21.9,16.3 23.6,14.6 31.21,14.6 31.7,14.11
  vias: v1(20.82,21.5) v1(20.82,20.8) v1(20.82,20.16) v1(20.86,19.23) v1(20.86,18.55) v1(21.53,18.54) v1(21.57,21.51) v1(21.57,20.81) v1(21.57,20.14) v1(32.73,13.61) v1(33.37,13.61)
+VCHGR_L:
  vias: v2(28.53,17.76)
+VDISPLAY_VCC: length 0.9
  TOP w0.127: v2(80.51,100.02) 80.87,100.38 v1(80.87,100.82)
  vias: v1(81.55,100.84)
+VR_CAP: length 2.1
  TOP w0.127: C740.1 299.08,62.47 v2(299.08,63.47)
  vias: v1(291.28,59.84) v1(291.91,59.84) v1(297.54,62.13) v1(297.53,61.49)
+VREFOUT: length 4.9
  TOP w0.102: C1180.1 v2(26.15,43.51)
  TOP w0.254: 28.64,41.92 29.14,41.43 U72.23
  TOP w0.508: 28.64,41.92 28.12,41.92 R1143.1 27.45,42.59 C1180.1
+XCLK_RCOMP: length 2.8
  TOP w0.102: v1(161.7,41.21) 161.85,41.36 v4(161.85,42.2)
  TOP w0.508: RH100.1 161.25,41.21 v1(161.7,41.21)
  BOTTOM w0.254: UH4.Y47 161.52,41.39 v1(161.7,41.21)
-DCIN_JACK:
  vias: v1(18.53,74.65) v1(18.52,73.97) v1(18.52,73.33) v1(18.51,72.62) v1(18.5,71.9) v1(19.14,74.28) v1(19.13,73.62) v1(19.11,72.9) v1(19.12,72.17) v4(17.52,71.82)
A_ENABLE: length 6.2
  BOTTOM w0.102: R1617.1 v2(164.13,78.08)
  BOTTOM w0.254: Q58.3 167.09,78.46 167.16,78.38 R917.2 167.13,78.08 C770.1 R1617.1 165.38,78.42 165.55,78.58 165.55,79.03 165.32,79.26 Q57.3
A_ON_3.3V#: length 6
  BOTTOM w0.102: v2(161.58,81.93) Q60.2 162.35,83 163.09,82.27 R918.2 163.17,81.54 Q57.6 162.86,80.56 162.73,80.43 162.73,80.05 162.87,79.91 Q57.5
AC_PRESENT: length 139.2
  TOP w0.102: R835.1 286.12,51.37 v1(286.15,51.4) 286.48,51.4 v2(286.76,51.68) U51.A54
  IN2 w0.102: 169.39,27.9 167.1,27.9 v1(166.69,27.49)
  IN2 w0.122: 169.39,27.9 169.47,27.99 175.8,27.99 177.68,29.87 183.08,29.87 183.28,29.67 186.87,29.67 187.48,30.28 192.98,30.28 194.33,28.94 228.66,28.94 238.03,38.31 245.77,38.31 247.21,39.76 253.66,39.76 254.63,38.78 270.22,38.78 271.96,40.52 276.55,40.52 279.16,43.14 281.08,43.14 283,45.06 v1(283,45.46)
  IN3 w0.122: v1(286.15,51.4) 286.15,50.69 285.39,49.93 285.39,45.99 v1(285.92,45.47)
  BOTTOM w0.102: v1(285.92,45.47) 283,45.47 v1(283,45.46) ; UH4.H20 166.69,27.63 v1(166.69,27.49)
ACAV_IN: length 445.7
  TOP w0.102: U51.B1 292.92,54.35 293.42,53.85 v1(293.84,53.85) ; v1(33.91,29.56) 33.91,27.89 34.35,27.45 PQ1306.2 ; v1(153.19,92.44) 153.19,93.23 151.64,94.78 v2(151.64,95.82) v1(151.64,97.47)
  TOP w0.254: v1(31.18,73.94) PQ1311.5
  IN1 w0.084: v1(31.91,82.15) 31.18,81.43 v1(31.18,73.94) ; v1(33.91,29.56) 33.91,29.03 37.96,24.98 37.96,24.12 39.21,22.87 41,22.87 42.61,21.26 42.61,12.14 35.43,4.96 35.43,3.12 35.12,2.82 30.09,2.82 v1(29.49,3.41)
  IN2 w0.122: v1(31.91,82.15) 33.03,83.27 44.56,83.27 46.95,85.66 66.82,85.66 67.06,85.42 69.28,85.42 69.78,84.92 76.69,84.92 84.36,92.59 87.5,92.59 88.89,93.98 97.62,93.98 99.95,96.31 99.95,100.17 100.46,100.67 101.55,100.67 102.1,100.12 135.64,100.12 135.9,99.85 136.76,99.85 137.47,99.15 149.96,99.15 v1(151.64,97.47)
  IN2 w0.254: v1(33.91,29.56) 33.91,31.79 35.13,33 35.13,39.51 37.71,42.09 37.71,44.38 31.98,50.11 31.98,61.33 33.24,62.59 33.24,64.49 32.72,65.01 32.72,72.4 v1(31.18,73.94)
  IN4 w0.084: v1(293.84,53.85) 293.22,53.23 290.08,53.23 289.06,52.21 289.06,50.59 288.66,50.19 279.9,50.19 278.36,48.65 274.43,48.65 273.87,48.1 270.82,48.1 268.51,45.78 259.55,45.78 258.48,44.71 254.63,44.71 253.15,43.23 236.28,43.23 230.09,37.04 219.5,37.04 217.51,35.06 198.19,35.06 193.95,39.3 192.57,39.3 189.01,42.85 187.54,42.85 183.03,47.37 183.03,48.11 181.59,49.55 173.06,49.55 171.5,51.11 170.73,51.11 166.98,54.86 166.98,57.3 167.93,58.25 167.93,70.07 167.05,70.95 167.05,79.93 160.12,86.86 159.14,86.86 153.56,92.44 v1(153.19,92.44)
  BOTTOM w0.102: v1(151.64,97.47) 151.71,97.47 152.75,96.43 157.93,96.43 158.32,96.82 158.32,98.66 159.19,99.53 U9.21
  BOTTOM w0.254: PR1320.1 PR1316.1 27.53,4.35 PR1310.2 PR1311.2 v1(29.49,3.41)
ACAV_IN_NB: length 439.1
  TOP w0.102: v2(45.18,77.81) 45.29,77.81 v1(45.85,78.37) ; U51.A15 293.77,61.6 294.26,62.08 294.38,62.08 v1(294.86,62.56)
  IN1 w0.084: v1(45.85,78.37) 46.09,78.13 46.09,72.79 47.06,71.83 47.06,53.85 43.76,50.55 43.76,31.46 41.86,29.56 41.86,23.33 43.08,22.11 43.08,10.9 35.88,3.69 35.88,2.96 35.3,2.38 28.35,2.38 24.94,5.79 24.94,10.6 23.32,12.23 20.5,12.23 19.73,11.45 18.83,11.45 18.43,11.06 18.43,8.96 16.33,6.86 11.75,6.86 11.14,6.24 v1(11.14,5.25)
  IN4 w0.084: v1(294.86,62.56) 294.35,62.04 294.25,62.04 293.52,61.31 293.52,54.5 292.49,53.48 289.97,53.48 288.81,52.31 288.81,50.69 288.56,50.44 276.74,50.44 275.4,49.09 274.49,49.09 273.74,48.34 270.72,48.34 269.68,47.3 267.62,47.3 266.34,46.03 259.44,46.03 258.38,44.96 254.53,44.96 253.05,43.48 236.18,43.48 229.95,37.25 219.41,37.25 217.43,35.27 198.27,35.27 194.03,39.51 192.71,39.51 189.15,43.06 187.63,43.06 183.24,47.45 183.24,48.19 181.67,49.76 173.15,49.76 171.59,51.32 170.81,51.32 167.19,54.95 167.19,57.21 168.14,58.17 168.14,70.19 167.26,71.06 167.26,80.02 160.21,87.07 159.22,87.07 152.79,93.51 139.78,93.51 139.56,93.29 137.26,93.29 135.76,94.78 135.76,96.33 135.09,97.01 133.33,97.01 130.85,99.49 116.3,99.49 113.95,97.14 108.79,97.14 101.16,89.51 92.43,89.51 91.74,88.82 87.13,88.82 86.88,88.57 69,88.57 65.58,85.15 64.95,85.15 62.17,82.36 54.19,82.36 53.39,81.56 49.05,81.56 v1(45.85,78.37)
  BOTTOM w0.254: v1(11.14,5.25) PR1342.2
ALERT#: length 4
  TOP w0.102: v1(144.57,87.92) 145.27,87.23 v2(145.27,86.76)
  TOP w0.254: PR735.1 144.57,88.51 v1(144.57,87.92)
  BOTTOM w0.203: PU700.6 144.57,86.95 v1(144.57,87.92)
  BOTTOM w0.254: v1(144.57,87.92) 144.57,88.51 PR735.1
ALW_ENABLE: length 10.8
  BOTTOM w0.102: v2(209.67,6.8) 207.27,6.8 C762.1 206.46,4.51 207.2,3.76 Q51.3 206.84,2.51 206.76,2.44 R905.2 R1619.1 204.96,2.73 Q49.3
ALW_ON_3.3V#: length 38.3
  TOP w0.102: v1(209.09,4.77) 209.07,4.79 203.36,4.79 202.52,5.62 202.52,8.62 203.37,9.47 203.37,12.06 203.01,12.42 Q66.2 v2(196.31,14.11) 196.3,14.12 v1(196.3,16.41)
  BOTTOM w0.102: QH8.2 189.06,20.84 190.54,19.35 194.32,19.35 196.3,17.37 v1(196.3,16.41) ; 208.26,4.91 208.03,4.91 207.85,4.73 Q51.5 ; 208.26,4.91 208.31,4.96 R907.2 208.45,5.41 v1(209.09,4.77) ; 208.26,4.91 208.35,4.91 208.5,4.76 Q51.6
ALW_PWRGD_3V_5V: length 124.7
  TOP w0.102: v1(244.96,6.11) v2(244.34,5.48) ; v1(291.29,61.35) 291.5,61.14 292.14,61.14 292.34,61.35 U51.B15
  TOP w0.254: v1(244.96,6.11) 244.95,6.12 PR112.1 244.98,6.89 245.95,6.89 246.32,7.26 246.32,7.91 247.08,8.67 PU100.23
  IN1 w0.084: v1(244.96,6.11) 244.96,4.65 247.46,2.16 287.7,2.16 290.39,4.85 v1(292.18,4.85)
  IN3 w0.122: v1(291.29,61.35) 291.29,61.53 291.78,62.02 295.16,62.02 297.12,60.06 298.03,60.06 298.44,59.65 298.44,49.3 297.48,48.34 297.48,43.34 298.87,41.95 298.87,39.84 297.83,38.8 297.83,33.35 295.2,30.72 295.2,19.61 292.65,17.07 292.65,6.27 292.18,5.8 v1(292.18,4.85)
ALWON: length 93.4
  TOP w0.102: v1(290,51.7) 290,51.98 289.76,52.22 U51.A60 ; v1(243.57,15.94) v2(243.57,16.51) 244.29,17.23 246.69,17.23 246.86,17.4 PR115.1
  IN1 w0.084: v1(243.57,15.94) 244.48,16.85 246.84,16.85 247.92,17.93 260.33,17.93 260.65,18.25 290.65,18.25 v1(291.14,18.74)
  IN3 w0.122: v1(290,51.7) 291.63,51.7 294.17,49.16 294.17,46.33 289.76,41.92 289.76,35.76 288.94,34.94 288.94,29.18 290.18,27.93 290.18,22.16 290.72,21.63 290.72,19.16 v1(291.14,18.74)
AUD_HP_NB_SENSE: length 377
  TOP w0.102: U46.A41 263.84,81.38 v1(263.68,81.54)
  TOP w0.254: v1(40.54,45.54) 40.47,45.61 v2(39.5,45.61) R1087.2 C967.1 ; v1(21.39,40.57) 21.01,40.57 20.42,39.98 Q107.5
  IN1 w0.084: v1(41.48,84.03) 41.48,80.15 42.84,78.79 42.84,70 43.54,69.31 43.54,69.13 44.1,68.57 44.1,63.9 43.33,63.13 43.33,62.52 43.92,61.92 43.92,54.49 40.54,51.11 v1(40.54,45.54)
  IN2 w0.122: v1(263.68,81.54) 263.16,82.06 263.16,82.21 262.23,83.14 257.41,83.14 256.22,81.94 253.55,81.94 241.79,70.18 241.79,69.15 236.97,64.33 236.97,62.43 228.34,53.81 228.34,52.89 220.96,45.51 214.82,45.51 213.27,43.96 195.14,43.96 194.09,45.01 187.03,45.01 182.06,49.98 182.06,53.39 177.52,57.93 173.33,57.93 170.89,60.36 170.89,61 170.24,61.66 170.24,63.41 170.89,64.06 170.89,67.58 170.27,68.2 170.27,72.66 169.46,73.46 169.46,76.06 170.42,77.02 170.42,78.76 168.76,80.42 168.76,81.74 167.59,82.9 167.59,86.52 168.46,87.38 168.46,95 164.91,98.55 162.41,98.55 160.98,99.98 159.17,99.98 156.14,103.01 147.33,103.01 146.95,102.64 138.55,102.64 138.1,103.09 137.25,103.09 135.73,104.61 114.6,104.61 113.91,105.31 105.48,105.31 104.28,106.5 98.12,106.5 93.09,101.47 93.09,97.05 92.32,96.28 72.15,96.28 70.6,94.73 69.19,94.73 62.7,88.24 43.35,88.24 40.85,85.73 40.85,84.67 v1(41.48,84.03)
  BOTTOM w0.254: v1(40.54,45.54) 39.07,47.01 27.83,47.01 v1(21.39,40.57) 21.16,40.35 R1652.2
AUD_HP_OUT_L: length 12.5
  TOP w0.254: v1(21.59,31.34) 21.46,31.47 v2(21.46,32.33) 21.46,36.22 22.4,37.16 U72.31
  BOTTOM w0.254: R1650.2 21.46,31.47 v1(21.59,31.34)
AUD_HP_OUT_L1: length 1.1
  BOTTOM w0.254: R1650.1 21.45,32.9 L105.2
AUD_HP_OUT_L2: length 11.6
  BOTTOM w0.254: JHP1.1 14.28,28.15 v4(16.5,30.38) 17.35,31.23 D81.3 18.56,32.37 18.75,32.18 C1213.1 19.81,31.6 L105.1
AUD_HP_OUT_R: length 8.4
  TOP w0.254: v1(22.36,34.4) v2(22.36,35.43) 22.36,36.14 22.83,36.61 25.95,36.61 26,36.66 U72.32
  BOTTOM w0.254: v1(22.36,34.4) R1651.2
AUD_HP_OUT_R1: length 1.1
  BOTTOM w0.254: R1651.1 21.45,35.32 L106.2
AUD_HP_OUT_R2: length 14.5
  BOTTOM w0.254: JHP1.2 12.06,39.95 12.6,40.5 13.59,40.5 14.5,39.6 14.5,38.2 14.15,37.86 14.15,35.77 v4(14.35,35.58) 15.63,34.3 D81.2 18.41,34.3 18.69,34.02 C1212.1 20.37,34.02 L106.1
AUD_NB_MUTE#: length 389.7
  TOP w0.102: v2(42.58,34.64) 42.25,34.64 v1(41.81,35.07) R1099.2 ; v1(35.64,32.34) 35.26,32.73 34.28,32.73 33.64,33.37 U72.47 ; v1(264.59,81.52) 264.84,81.27 U46.A39
  IN1 w0.084: v1(35.64,32.34) 35.64,33.74 38.39,36.49 38.39,40.43 40.97,43.01 40.97,51.24 44.15,54.42 44.15,61.99 43.54,62.6 43.54,63.04 44.32,63.82 44.32,68.67 43.8,69.2 43.8,69.38 43.05,70.12 43.05,78.94 41.94,80.05 41.94,84.26 v1(41.51,84.69)
  IN2 w0.122: v1(264.59,81.52) 264.16,81.09 261.87,81.09 260.07,82.89 257.59,82.89 255.51,80.82 255.51,74.84 254.91,74.23 252.94,74.23 252.44,73.73 252.44,67.38 251.62,66.56 251.62,63.94 250.14,62.46 242.55,62.46 236.33,56.25 234,56.25 233,55.24 231.04,55.24 221.06,45.26 214.92,45.26 211.64,41.98 208.55,41.98 204.38,37.81 199.65,37.81 193.45,44.01 187.48,44.01 181.81,49.67 181.81,51.49 181.09,52.21 179.93,52.21 178.84,51.12 174.33,51.12 171.89,53.56 171.89,58.96 170.65,60.21 170.65,60.83 169.96,61.51 169.96,63.49 170.64,64.16 170.64,67.35 170.02,67.97 170.02,70.28 169.16,71.14 169.16,76.11 170.18,77.13 170.18,78.66 168.51,80.32 168.51,81.64 167.34,82.8 167.34,86.62 168.09,87.37 168.09,95.02 164.8,98.3 162.31,98.3 160.88,99.73 159.07,99.73 156.04,102.76 147.43,102.76 147.05,102.39 138.45,102.39 138,102.84 137.15,102.84 135.63,104.37 114.5,104.37 113.81,105.06 105.35,105.06 104.15,106.25 98.26,106.25 93.34,101.33 93.34,96.94 92.43,96.03 80.1,96.03 78.59,94.51 78.59,93.59 74.43,89.42 66.12,89.42 64.59,87.89 43.39,87.89 41.1,85.61 41.1,85.1 v1(41.51,84.69)
  IN3 w0.122: v1(35.64,32.34) 36.71,32.34 39.44,35.07 v1(41.81,35.07)
AUD_PC_BEEP: length 5.7
  TOP w0.102: C1105.2 v2(37.98,43.76)
  TOP w0.254: U72.12 35.29,40.16 37.04,41.91 C1106.2 C1105.2
AUD_SENSE_A: length 26.2
  TOP w0.254: U72.13 34.92,40.91 34.93,40.9 35.34,40.9 36.62,42.19 C980.1 36.62,43.76 33.6,46.78 26.69,46.78 22.97,43.06 v2(22.97,42.53) R1083.2 R1086.1
AUD_SENSE_B: length 5.3
  TOP w0.102: v2(34.45,45.07) 33.46,44.08 C979.1 34.35,42.9 R1078.2 34.37,42.17 33.64,41.44 U72.14
AUX_EN_WOWL: length 42.5
  TOP w0.102: v1(260.34,71.81) U46.B67
  IN1 w0.084: v1(239.34,61.97) 239.35,61.98 239.35,66.55 237.82,68.08 237.82,70.26 238.56,71 241.36,71 241.58,71.22 252.88,71.22 253.12,70.97 254.41,70.97 255.07,70.31 257.28,70.31 258.78,71.81 v1(260.34,71.81)
  BOTTOM w0.102: Q39.2 234.75,56.64 234.7,56.69 R716.1 234.7,59.04 235.11,59.45 v2(235.84,59.45) 238.36,61.97 v1(239.34,61.97)
B: length 6.1
  BOTTOM w0.102: JCRT1.3 6.31,75.4 7.08,74.64 8.37,74.64 9.52,75.78 C1207.1 L101.2
BAT1_LED#: length 139.1
  TOP w0.102: v1(170.2,60.65) 169.68,60.13 v1(169.68,59.13) ; U46.B64 260.19,73.31 v1(260.85,73.96)
  IN1 w0.084: v1(170.2,60.65) 170.2,60.3 171.62,58.88 171.62,51.84 173.48,49.98 181.7,49.98 183.41,48.26 187.52,48.26 190.75,45.03 194.37,45.03 195.86,43.53 195.86,42.53 196.49,41.91 196.49,40.14 199.37,37.26 217.52,37.26 233.52,53.25 233.52,55.47 236.9,58.86 236.9,70.84 237.1,71.04 237.1,71.8 237.93,72.64 240.59,72.64 240.71,72.76 241.75,72.76 242.44,72.06 251.56,72.06 252.44,72.95 255.19,72.95 255.68,73.44 260.33,73.44 v1(260.85,73.96)
  BOTTOM w0.102: Q83.1 165.93,59.22 166.06,59.34 R959.1 166.96,59.9 v2(167.63,59.9) 168.9,59.9 v1(169.68,59.13)
BAT1_LED#_Q: length 1.5
  BOTTOM w0.102: R951.1 163.18,60.17 163.18,59.31 163.26,59.22 Q83.6
BAT2_LED#: length 140.6
  TOP w0.102: U46.A9 264.34,69.28 v1(264.5,69.12)
  IN1 w0.084: v1(264.5,69.12) 264.5,69.78 263.52,70.76 258.33,70.76 257.46,69.89 254.9,69.89 254.28,70.51 252.91,70.51 252.66,70.76 241.79,70.76 241.31,70.28 240.09,70.28 239.65,69.85 239.65,68.3 240.15,67.81 240.15,60.01 239.33,59.19 239.33,57.57 217.96,36.2 198.93,36.2 195.42,39.72 195.42,41.48 192.75,44.15 190.43,44.15 187.37,47.22 186.69,47.22 186.23,46.75 183.72,46.75 181.33,49.13 173.13,49.13 170.58,51.69 170.58,57.9 v1(170.56,57.92)
  BOTTOM w0.102: v1(170.56,57.92) 170.09,57.44 167.56,57.44 v2(167.31,57.19) 166.97,56.86 R958.1 164.32,57.41 163.81,57.92 Q83.4
BAT2_LED#_Q: length 4.6
  TOP w0.102: v1(164.66,59.02) 164.66,59.02 164.66,57.97 v1(164.65,57.96) 164.65,57.96 164.65,57.74 163.95,57.04 v2(163.95,56.99)
  BOTTOM w0.102: v1(164.65,57.96) 164.69,57.92 Q83.3 ; v1(164.66,59.02) 164.36,59.33 R949.1
BATT_WHITE: length 4.8
  TOP w0.127: v2(164.62,60.2) 164.25,60.57 JLED1.4
  TOP w0.254: JLED1.4 164.25,62.55 v1(164.54,62.83)
  BOTTOM w0.254: R949.2 164.04,61.63 164.04,62.34 v1(164.54,62.83)
BATT_WHITE_LED: length 94.9
  IN2 w0.122: v1(159.85,70.03) 159.05,70.83 159.05,81.17 159.59,81.71 159.59,84.95 153.57,90.97 150.43,90.97 147.04,94.37 141.93,94.37 139.4,96.9 134.49,96.9 132.76,98.63 114.55,98.63 v1(113.71,97.79)
  BOTTOM w0.102: v1(113.71,97.79) 113.43,98.07 113.43,105.24 111.38,107.29 111.38,108.24 111.1,108.52 JLVDS1.1 ; v1(159.85,70.03) 161.26,68.62 161.26,58.67 162.27,57.66 v2(162.27,57.34) 162.76,56.86 R958.2
BATT_YELLOW: length 5.3
  TOP w0.127: 162.88,60.36 162.88,60.13 163.3,59.71 v2(163.3,58.95)
  TOP w0.254: JLED1.5 163.75,61.01 163.1,60.36 v1(162.74,60.36)
  BOTTOM w0.254: R951.2 163.07,61.31 162.74,60.98 v1(162.74,60.36)
BATT_YELLOW_LED: length 106.7
  IN2 w0.122: v1(169.94,58.54) 169.55,58.54 168.83,59.26 168.83,67.22 168.66,67.39 168.66,68.92 167.47,70.11 167.47,77.81 168,78.34 168,81.44 166.68,82.76 166.68,95.09 164.75,97.02 159.71,97.02 158.49,98.23 158.49,99.6 155.83,102.27 147.63,102.27 147.26,101.89 138.25,101.89 137.79,102.34 136.94,102.34 135.42,103.87 113.44,103.87 v1(112.94,104.37)
  BOTTOM w0.102: JLVDS1.2 110.6,108.54 111.07,108.08 111.07,107.21 112.94,105.33 v1(112.94,104.37) ; R959.2 166.42,58.44 v2(169.11,58.44) 169.85,58.44 v1(169.94,58.54)
BAY_SMBCLK: length 6
  TOP w0.102: v3(297.85,57.53) 298.06,57.32 298.29,57.32 R856.2 ; v1(295.19,57.1) 294.88,57.1 294.38,57.6 U51.A7
  IN1 w0.084: v1(295.19,57.1) 295.41,56.88 296.21,56.88 296.68,57.34 297.67,57.34 v3(297.85,57.53)
BAY_SMBDAT: length 9.9
  TOP w0.102: v1(297.85,56.89) 298.06,57.09 298.29,57.09 R854.2 ; v3(291.28,57.84) 291.68,57.44 292.23,57.44 292.32,57.35 U51.B7
  IN1 w0.084: v1(297.85,56.89) 297.61,57.13 296.77,57.13 296.3,56.66 293.82,56.66 293,57.49 291.64,57.49 v3(291.28,57.84)
BBS_BIT0_R: length 3.5
  BOTTOM w0.102: UH4.P1 164,18.49 164,17.82 163.24,17.05 v2(163.24,16.72) 162.62,16.1 RH52.1
BBS_BIT1: length 9.1
  BOTTOM w0.102: UH4.D47 169.57,41.39 170.84,42.65 170.84,44.74 171.2,45.11 171.2,46.89 171.47,47.15 171.47,47.82 RH342.1 171.93,48.28 v2(172.71,48.28)
BC_CLK_ECE1117: length 108.8
  TOP w0.102: v1(221.15,33.35) 221.75,33.94 226.12,33.94 227.27,32.79 227.27,30.27 v2(226.84,29.84) 226.84,28.67 225.82,27.65 221.01,27.65 219.55,26.18 JTP1.7 ; v1(290.26,64.54) U51.A20
  IN2 w0.122: v1(221.15,33.35) 221.66,32.84 226.97,32.84 241.68,47.55 241.68,48.03 243.06,49.42 253.15,49.42 255.31,51.59 257.51,51.59 258.41,50.69 263.26,50.69 264.21,51.64 270.85,51.64 272.51,53.3 276.31,53.3 277.46,54.45 280.79,54.45 281.6,55.25 282.24,55.25 282.57,55.59 282.57,58.16 282.89,58.48 286.17,58.48 288.27,60.58 288.79,60.58 289.22,61.01 289.87,61.01 290.2,61.34 290.2,62.41 290.66,62.86 290.66,64.15 v1(290.26,64.54)
BC_CLK_ECE5048: length 35.1
  TOP w0.102: U51.A43 281.83,57.1 v1(281.81,57.12) ; v1(270.31,78.06) U46.A30
  BOTTOM w0.102: v1(281.81,57.12) 283.01,58.33 283.01,61.83 283.29,62.11 283.29,63.22 281.22,65.29 281.22,66.5 278.08,69.64 278.08,71.85 276.24,73.69 276.1,73.69 275.53,73.12 275.39,73.12 275.24,73.26 275.24,73.4 275.81,73.98 275.81,74.12 275.67,74.26 275.53,74.26 274.95,73.69 274.81,73.69 274.67,73.84 274.67,73.98 275.24,74.55 275.24,74.69 275.09,74.84 274.95,74.84 274.38,74.27 274.24,74.27 274.09,74.41 274.09,74.55 274.66,75.13 274.66,75.27 272.41,77.52 272.09,77.52 v2(271.8,77.8) 271.14,78.47 270.73,78.47 v1(270.31,78.06)
BC_CLK_EMC4021: length 221.3
  TOP w0.102: v1(163.85,94.83) 163.85,94.83 163.72,94.95 163.72,95.25 163.85,95.38 164.33,95.38 164.45,95.5 164.45,95.66 164.33,95.78 163.79,95.78 163.67,95.9 163.67,96.07 163.79,96.19 164.28,96.19 164.39,96.29 164.39,96.49 164.28,96.6 163.8,96.6 163.68,96.71 163.68,96.88 163.8,97 164.52,97 164.64,97.12 164.64,97.29 164.52,97.41 164.06,97.41 163.93,97.53 163.93,97.71 164.06,97.84 164.55,97.84 164.72,98.02 164.72,103.98 163.86,104.85 v2(163.05,104.85) v1(162.35,105.55) ; U51.A12 294.43,60.1 294.91,60.58 v1(294.91,60.77)
  IN2 w0.122: v1(294.91,60.77) 295.55,61.41 295.55,62.85 293.02,65.38 293.02,68.2 291.98,69.24 277.82,69.24 275.96,67.38 275.96,66.76 272.87,63.66 269.17,63.66 267,61.5 265.52,61.5 264.73,62.29 255.16,62.29 251.95,59.08 243.67,59.08 241.37,56.78 240.38,56.78 236.56,52.95 235.09,52.95 233.07,50.93 231.61,50.93 222.51,41.83 222.51,41.23 218.28,36.99 213.6,36.99 211.92,35.32 198.04,35.32 194.04,39.32 192.91,39.32 191.54,40.69 187.28,40.69 181.65,46.31 177.72,46.31 176.86,47.17 176.47,47.17 175.4,48.24 173.14,48.24 172.36,49.02 172.36,49.02 166.84,54.54 166.84,62.92 165.67,64.09 165.67,65.42 164.69,66.4 164.69,68.96 165.48,69.75 165.48,78.28 165.29,78.47 165.29,81.34 164.69,81.94 164.69,93.99 v1(163.85,94.83)
  BOTTOM w0.102: U9.8 161.19,106 161.27,106.08 161.82,106.08 v1(162.35,105.55)
