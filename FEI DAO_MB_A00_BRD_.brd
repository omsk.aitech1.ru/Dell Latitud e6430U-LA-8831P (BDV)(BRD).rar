# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D62: length 66.7
  IN4 w0.084: v3(118.65,63.09) 119.05,63.49 119.05,64.96 118.03,65.98 118.03,69.91 115.2,72.74 111.17,72.74 110.27,71.84 106.51,71.84 94.73,83.62 88.56,83.62 88.48,83.54 88.48,83.13 88.4,83.05 88.23,83.05 88.15,83.13 88.15,83.54 88.06,83.62 87.89,83.62 87.81,83.54 87.81,83.13 87.73,83.05 87.56,83.05 87.48,83.13 87.48,83.54 87.39,83.62 87.22,83.62 87.14,83.54 87.14,83.13 87.06,83.05 86.89,83.05 86.8,83.13 86.8,83.54 86.72,83.62 86.55,83.62 86.47,83.54 86.47,83.13 86.39,83.05 86.22,83.05 86.13,83.13 86.13,83.54 86.05,83.62 85.88,83.62 85.8,83.54 85.8,83.13 85.72,83.05 85.55,83.05 85.46,83.13 85.46,83.59 85.39,83.67 85.2,83.67 85.13,83.59 85.13,83.13 85.04,83.05 84.88,83.05 84.79,83.13 84.79,83.54 84.71,83.62 84.54,83.62 84.46,83.54 84.46,83.13 84.37,83.05 84.21,83.05 84.12,83.13 84.12,83.59 84.05,83.67 83.86,83.67 83.79,83.59 83.79,83.13 83.7,83.05 83.54,83.05 83.45,83.13 83.45,83.59 83.38,83.67 83.19,83.67 83.12,83.59 83.12,83.13 83.03,83.05 82.87,83.05 82.78,83.13 82.78,83.56 82.68,83.67 82.52,83.67 82.42,83.56 82.42,83.13 82.34,83.05 82.14,83.05 82.06,83.13 82.06,83.52 81.96,83.62 79.74,83.62 79.64,83.52 v1(79.64,83.19)
  BOTTOM w0.102: v1(79.64,83.19) 79.02,82.57 78.03,82.57 77.41,81.95 JDIMM1.192 ; U1.AG55 118.97,62.77 v3(118.65,63.09)
DDR_A_D63: length 67.7
  IN4 w0.084: v1(78.11,83.19) 78.53,82.76 89.02,82.76 89.11,82.85 89.11,83.25 89.19,83.33 89.36,83.33 89.44,83.25 89.44,82.85 89.52,82.76 89.69,82.76 89.78,82.85 89.78,83.25 89.86,83.33 90.03,83.33 90.11,83.25 90.11,82.85 90.19,82.76 90.36,82.76 90.45,82.85 90.45,83.25 90.53,83.33 90.7,83.33 90.78,83.25 90.78,82.85 90.87,82.76 91.03,82.76 91.12,82.85 91.12,83.25 91.2,83.33 91.37,83.33 91.45,83.25 91.45,82.85 91.54,82.76 91.7,82.76 91.79,82.85 91.79,83.25 91.87,83.33 92.04,83.33 92.12,83.25 92.12,82.85 92.21,82.76 92.37,82.76 92.46,82.85 92.46,83.25 92.54,83.33 92.71,83.33 92.79,83.25 92.79,82.29 92.89,82.19 93.03,82.19 93.13,82.29 93.13,83.25 93.21,83.33 93.38,83.33 93.46,83.25 93.46,82.1 93.56,82 93.7,82 93.8,82.1 93.8,83.25 93.88,83.33 94.05,83.33 94.13,83.25 94.13,82.1 94.24,82 94.38,82 94.48,82.1 94.48,83.1 94.58,83.2 94.75,83.2 94.85,83.1 94.85,82.1 94.95,82 95.94,82 106.39,71.55 110.39,71.55 111.29,72.45 115.08,72.45 117.65,69.88 117.65,65.95 118.12,65.47 118.12,64.27 v1(118.65,63.74)
  BOTTOM w0.102: v1(118.65,63.74) 118.41,63.51 U1.AK56 ; v1(78.11,83.19) 77.98,83.19 77.34,82.55 JDIMM1.194
DDR_A_DQS0: length 62.8
  IN4 w0.084: 116.74,34.19 116.74,35.95 117.49,36.71 117.49,40.22 v3(117.92,40.64)
  IN4 w0.091: v1(80.09,23.41) 79.88,23.63 79.88,23.78 79.99,23.89 83.64,23.89 83.91,24.16 83.91,25.73 84.98,26.8 87.21,26.8 88.63,28.21 99.81,28.21 100.02,28.42 100.02,29.32 100.15,29.45 100.48,29.45 100.61,29.32 100.61,28.44 100.83,28.21 101.23,28.21 101.46,28.44 101.46,29.35 101.55,29.45 101.83,29.45 101.92,29.35 101.92,28.44 102.15,28.21 102.49,28.21 102.72,28.44 102.72,29.35 102.81,29.45 103.09,29.45 103.18,29.35 103.18,28.5 103.41,28.27 103.75,28.27 103.98,28.5 103.98,29.35 104.07,29.45 104.46,29.45 105.75,30.73 114.85,30.73 115.14,31.02 115.14,31.75 115.55,32.15 115.55,32.29 116.05,32.79 116.22,32.79 116.74,33.31 116.74,34.19
  BOTTOM w0.102: v1(80.09,23.41) 79.9,23.61 79.9,24.21 79.34,24.76 78.03,24.76 77.63,25.16 77.63,25.33 77.41,25.55 JDIMM1.12 ; v3(117.92,40.64) 118.23,40.96 U1.AJ11
DDR_A_DQS1: length 53.6
  IN4 w0.084: 111.63,36.83 112.85,36.83 113.95,37.92 113.95,39.34 114.55,39.94 v3(114.55,40)
  IN4 w0.091: 111.63,36.83 111.32,36.83 110.79,36.29 109.96,36.29 109.42,35.75 105.67,35.75 102.93,33.01 92.5,33.01 91.25,31.76 84.92,31.76 82.18,29.02 77.89,29.02 77.64,29.28 71.38,29.28 71.28,29.39 71.28,29.51 v1(71.51,29.75)
  BOTTOM w0.102: U1.AR10 114.88,40.33 v3(114.55,40) ; JDIMM1.29 69.2,30.65 69.38,30.47 70.97,30.47 71.23,30.22 71.23,30.04 v1(71.51,29.75)
DDR_A_DQS2: length 50.2
  IN4 w0.091: v3(112.9,40.21) 112.98,40.13 112.98,39.91 112.88,39.81 110.6,39.81 110.46,39.95 109.86,39.95 108.71,38.8 102.96,38.8 101.7,37.54 99.14,37.54 97.98,36.38 82.87,36.38 80.71,34.22 73.35,34.22 72.81,34.76 71.4,34.76 71.25,34.91 71.25,35.31 71.35,35.41 v1(71.6,35.41)
  BOTTOM w0.102: JDIMM1.47 69.21,36.05 69.4,35.86 69.59,35.86 69.84,36.11 71.05,36.11 71.26,35.9 71.26,35.62 71.47,35.41 v1(71.6,35.41) ; U1.AY11 112.74,40.37 v3(112.9,40.21)
DDR_A_DQS3: length 48.6
  IN4 w0.091: v3(79.85,39.68) 79.85,39.68 79.6,39.44 79.6,39.34 79.69,39.25 80.87,39.25 81.84,40.21 83.81,40.21 83.89,40.29 83.89,40.52 84.07,40.7 84.52,40.7 84.73,40.49 84.73,39.98 84.89,39.83 85.18,39.83 85.26,39.9 85.26,40.68 85.49,40.91 85.95,40.91 86.18,40.68 86.18,40.32 86.31,40.19 86.61,40.19 86.73,40.32 86.73,40.69 86.96,40.92 87.35,40.92 87.58,40.69 87.58,40.25 87.65,40.18 88,40.18 88.1,40.28 88.1,40.7 88.32,40.92 88.62,40.92 88.84,40.7 88.84,39.94 88.97,39.82 89.26,39.82 89.33,39.89 89.33,40.72 89.52,40.92 100.14,40.92 102,42.78 108.95,42.78 109.16,42.99 109.58,42.99 109.79,42.78 111.3,42.78 112.87,44.34 114,44.34 114.07,44.27 114.15,44.27 114.37,44.49 v1(114.37,44.78)
  BOTTOM w0.102: JDIMM1.64 77.35,41.15 77.74,40.77 79.26,40.77 79.65,40.38 79.65,39.88 79.85,39.68 v3(79.85,39.68) ; v1(114.37,44.78) 114.04,44.45 U1.AU17
DDR_A_DQS4: length 53.3
  IN4 w0.091: v1(112.81,58.01) 112.97,58.01 113.06,58.1 113.06,58.33 112.95,58.44 112.64,58.44 112.54,58.34 112.46,58.34 112.22,58.1 110.73,58.1 110.53,58.29 109.73,58.29 109,59.03 107.16,59.03 106.63,59.56 106.63,59.99 106.17,60.46 105.97,60.65 103.31,60.65 102.31,61.65 96.57,61.65 92.35,65.87 85.6,65.87 85.12,66.35 81.08,66.35 80.78,66.05 73.16,66.05 73.06,65.95 73.06,65.11 72.85,64.91 72.51,64.91 72.31,65.11 72.31,65.22 72.24,65.29 72.02,65.29 71.95,65.22 71.95,65.13 71.74,64.93 71.36,64.93 71.16,65.13 71.16,65.59 v3(70.87,65.88)
  BOTTOM w0.102: v3(70.87,65.88) 70.89,65.88 71.21,65.55 71.21,65.25 71.14,65.17 69.48,65.17 69.2,65.45 JDIMM1.137 ; v1(112.81,58.01) 112.81,57.89 U1.AW45
DDR_A_DQS5: length 51.7
  IN4 w0.091: v1(113.69,61.52) 113.43,61.78 112.74,61.78 112.44,61.48 110.66,61.48 110.37,61.78 109.98,61.78 108.17,63.59 106.33,63.59 106.1,63.81 106.1,64.39 105.29,65.2 98.69,65.2 93.61,70.27 89.46,70.27 89.37,70.36 89.37,71.2 89.16,71.4 88.77,71.4 88.56,71.2 88.56,70.36 88.47,70.27 88.2,70.27 88.11,70.36 88.11,71.45 87.91,71.64 87.5,71.64 87.3,71.45 87.3,70.36 87.21,70.27 86.94,70.27 86.85,70.36 86.85,71.45 86.65,71.64 86.24,71.64 86.04,71.45 86.04,70.36 85.95,70.27 85.68,70.27 85.59,70.36 85.59,71.45 85.39,71.64 79.52,71.64 79.28,71.41 79.28,71.17 79.09,70.98 v3(79.09,70.98)
  BOTTOM w0.102: v3(79.09,70.98) 79.31,70.98 79.43,70.86 79.43,70.52 79.35,70.43 77.71,70.43 77.59,70.55 JDIMM1.154 ; U1.AV51 113.69,61.25 v1(113.69,61.52)
DDR_A_DQS6: length 53.8
  IN4 w0.091: v1(114.27,63.74) 114.07,63.54 113.94,63.54 113.84,63.64 113.84,64.1 113.52,64.42 112.07,64.42 111.39,65.1 111.01,65.1 108.48,67.63 103.57,67.63 94.59,76.61 77.3,76.61 77.01,76.32 71.66,76.32 70.89,75.55 v3(70.83,75.55)
  BOTTOM w0.102: JDIMM1.171 69.1,75.65 69.29,75.46 69.44,75.46 69.78,75.11 71.02,75.11 71.09,75.18 71.09,75.29 v3(70.83,75.55) ; v1(114.27,63.74) 114.27,63.74 114.59,63.42 U1.AT56
DDR_A_DQS7: length 66.9
  IN4 w0.091: v1(79.25,82.02) 79.47,82.02 79.61,81.89 79.61,81.66 79.93,81.34 81.59,81.34 81.79,81.53 81.79,82 81.89,82.1 82.14,82.1 82.24,82 82.24,81.53 82.44,81.34 82.85,81.34 83.05,81.53 83.05,82 83.15,82.1 83.4,82.1 83.5,82 83.5,81.53 83.7,81.34 84.11,81.34 84.31,81.53 84.31,82 84.41,82.1 84.66,82.1 84.76,82 84.76,81.53 84.96,81.34 85.37,81.34 85.57,81.53 85.57,82 85.67,82.1 85.92,82.1 86.02,82 86.02,81.53 86.21,81.34 86.63,81.34 86.83,81.53 86.83,82 86.93,82.1 87.18,82.1 87.28,82 87.28,81.53 87.47,81.34 87.89,81.34 88.08,81.53 88.08,82 88.19,82.1 88.44,82.1 88.54,82 88.54,81.53 88.73,81.34 89.15,81.34 89.34,81.53 89.34,82 89.45,82.1 89.7,82.1 89.8,82 89.8,81.53 89.99,81.34 90.41,81.34 90.6,81.53 90.6,81.82 90.71,81.92 90.96,81.92 91.06,81.82 91.06,81.53 91.25,81.34 91.67,81.34 91.86,81.53 91.86,81.82 91.97,81.92 92.22,81.92 92.32,81.82 92.32,81.53 92.51,81.34 95.67,81.34 106.12,70.89 110.67,70.89 111.56,71.78 114.07,71.78 116.11,69.74 116.11,67.96 116.51,67.57 116.51,65.65 117.43,64.73 117.43,62.48 117.9,62.01 118.42,62.01 v1(118.62,61.81)
  BOTTOM w0.102: v1(79.25,82.02) 79.46,82.02 79.6,81.88 79.6,81.58 79.28,81.26 77.96,81.26 77.45,80.75 JDIMM1.188 ; v1(118.62,61.81) 118.22,62.21 U1.AK54
DDR_A_DQS#0: length 62.6
  IN4 w0.084: 116.57,34.19 116.57,34.21 116.57,34.21 116.57,34.26 116.57,34.26 116.57,36.02 117.33,36.77 117.33,40.43 117.17,40.59 v1(116.93,40.59)
  IN4 w0.091: v3(79.33,23.41) 79.53,23.41 79.71,23.59 79.71,23.86 79.91,24.06 83.57,24.06 83.74,24.23 83.74,25.8 84.91,26.97 87.14,26.97 88.56,28.39 99.74,28.39 99.85,28.49 99.85,29.39 100.08,29.62 100.55,29.62 100.78,29.39 100.78,28.51 100.91,28.39 101.16,28.39 101.29,28.51 101.29,29.43 101.48,29.62 101.9,29.62 102.09,29.43 102.09,28.51 102.22,28.39 102.42,28.39 102.55,28.51 102.55,29.43 102.74,29.62 103.16,29.62 103.35,29.43 103.35,28.57 103.48,28.44 103.68,28.44 103.81,28.57 103.81,29.43 104,29.62 104.39,29.62 105.68,30.9 114.78,30.9 114.97,31.09 114.97,31.82 115.38,32.23 115.38,32.36 115.98,32.96 116.15,32.96 116.57,33.38 116.57,34.19
  BOTTOM w0.102: v3(79.33,23.41) 79.56,23.41 79.68,23.53 79.68,24.12 79.25,24.54 77.94,24.54 77.53,24.95 JDIMM1.10 ; v1(116.93,40.59) 116.93,40.65 117.18,40.91 U1.AL11
DDR_A_DQS#1: length 53.6
  IN4 w0.084: 114.32,39.46 114.31,39.46 114.11,39.27 114.11,37.85 112.92,36.66 111.7,36.66 111.7,36.66 111.65,36.66 111.64,36.65 111.63,36.65
  IN4 w0.091: v3(70.75,29.75) 71.05,29.45 71.05,29.29 71.23,29.11 77.57,29.11 77.82,28.85 82.25,28.85 84.99,31.59 91.32,31.59 92.57,32.84 103,32.84 105.74,35.57 109.49,35.57 110.03,36.12 110.86,36.12 111.39,36.65 111.63,36.65 ; 114.32,39.46 114.41,39.46 v1(114.54,39.33)
  BOTTOM w0.102: U1.AR8 114.88,39.68 v1(114.54,39.33) ; v3(70.75,29.75) 70.88,29.75 71.01,29.87 71.01,30.13 70.88,30.26 69.41,30.26 69.2,30.05 JDIMM1.27
DDR_A_DQS#2: length 50.2
  IN4 w0.091: v1(113.52,40.21) 113.16,39.84 113.16,39.84 112.95,39.64 110.53,39.64 110.38,39.78 109.93,39.78 108.77,38.62 103.02,38.62 101.77,37.37 99.21,37.37 98.05,36.21 82.94,36.21 80.78,34.05 73.27,34.05 72.74,34.58 71.33,34.58 71.08,34.83 71.08,35.17 v3(70.83,35.41)
  BOTTOM w0.102: JDIMM1.45 69.22,35.45 69.41,35.64 69.68,35.64 69.93,35.9 70.96,35.9 71.05,35.81 71.05,35.63 v3(70.83,35.41) ; U1.AV11 113.39,40.33 v1(113.52,40.21)
DDR_A_DQS#3: length 48.5
  IN4 w0.091: v1(114.38,43.84) 114.38,44.01 114.29,44.1 114,44.1 113.93,44.17 112.94,44.17 111.37,42.6 109.72,42.6 109.51,42.81 109.23,42.81 109.02,42.6 102.07,42.6 100.21,40.74 89.6,40.74 89.5,40.65 89.5,39.82 89.33,39.64 88.9,39.64 88.67,39.87 88.67,40.63 88.55,40.75 88.39,40.75 88.27,40.63 88.27,40.21 88.08,40.01 87.58,40.01 87.41,40.18 87.41,40.62 87.28,40.75 87.03,40.75 86.91,40.62 86.91,40.25 86.68,40.02 86.24,40.02 86.01,40.25 86.01,40.61 85.88,40.74 85.56,40.74 85.43,40.61 85.43,39.83 85.26,39.65 84.82,39.65 84.56,39.91 84.56,40.42 84.45,40.53 84.14,40.53 84.06,40.45 84.06,40.22 83.89,40.04 81.91,40.04 80.94,39.08 79.62,39.08 79.43,39.26 79.43,39.59 79.34,39.68 v3(79.09,39.68)
  BOTTOM w0.102: v1(114.38,43.84) 114.54,43.84 114.69,43.99 U1.AT17 ; JDIMM1.62 79.17,40.55 79.43,40.29 79.43,39.8 79.31,39.68 v3(79.09,39.68)
DDR_A_DQS#4: length 53.4
  IN4 w0.091: v1(71.63,65.88) 71.33,65.58 71.33,65.2 71.43,65.1 71.67,65.1 71.77,65.2 71.77,65.29 71.94,65.46 72.31,65.46 72.48,65.29 72.48,65.18 72.58,65.08 72.78,65.08 72.88,65.18 72.88,66.02 73.09,66.22 80.71,66.22 81.01,66.53 85.19,66.53 85.67,66.05 92.42,66.05 96.64,61.82 102.38,61.82 103.38,60.82 106.04,60.82 106.24,60.63 106.8,60.06 106.8,59.63 107.23,59.2 109.07,59.2 109.81,58.46 110.61,58.46 110.8,58.27 112.15,58.27 112.39,58.51 112.47,58.51 112.57,58.61 113.02,58.61 113.23,58.41 113.23,58.24 v3(113.46,58.01)
  BOTTOM w0.102: v1(71.63,65.88) 71.43,65.68 71.43,65.16 71.23,64.96 69.3,64.96 69.2,64.85 JDIMM1.135 ; v3(113.46,58.01) 113.46,57.89 U1.AV45
DDR_A_DQS#5: length 51.6
  IN4 w0.091: v1(79.85,70.98) 79.61,70.98 79.51,71.08 79.51,71.31 79.67,71.47 85.32,71.47 85.41,71.38 85.41,70.29 85.61,70.1 86.02,70.1 86.22,70.29 86.22,71.38 86.31,71.47 86.58,71.47 86.67,71.38 86.67,70.29 86.87,70.1 87.28,70.1 87.48,70.29 87.48,71.38 87.57,71.47 87.84,71.47 87.93,71.38 87.93,70.29 88.13,70.1 88.54,70.1 88.74,70.29 88.74,71.13 88.84,71.23 89.09,71.23 89.19,71.13 89.19,70.29 89.39,70.1 93.54,70.1 98.61,65.02 105.22,65.02 105.93,64.32 105.93,63.74 106.26,63.41 108.1,63.41 109.91,61.61 110.29,61.61 110.59,61.31 112.53,61.31 112.58,61.26 112.58,60.9 112.66,60.82 112.78,60.82 113.06,61.1 v3(113.06,61.35)
  BOTTOM w0.102: U1.AY51 112.74,61.17 112.93,61.35 v3(113.06,61.35) ; v1(79.85,70.98) 79.65,70.78 79.65,70.43 79.44,70.22 77.69,70.22 77.42,69.95 JDIMM1.152
DDR_A_DQS#6: length 53.7
  IN4 w0.091: v1(71.6,75.55) 71.45,75.69 71.45,75.87 71.73,76.15 77.08,76.15 77.37,76.43 94.52,76.43 103.49,67.46 108.41,67.46 110.94,64.93 111.32,64.93 112.02,64.23 113.45,64.23 113.67,64 113.67,63.57 113.87,63.37 113.99,63.37 v3(114.26,63.09)
  BOTTOM w0.102: v3(114.26,63.09) 114.59,62.77 U1.AT55 ; JDIMM1.169 69.04,75.05 69.23,75.24 69.35,75.24 69.69,74.9 71.11,74.9 71.3,75.09 71.3,75.25 v1(71.6,75.55)
DDR_A_DQS#7: length 67
  IN4 w0.091: v3(80.02,82.02) 79.83,81.84 79.83,81.68 80,81.51 81.52,81.51 81.61,81.6 81.61,82.07 81.82,82.27 82.21,82.27 82.42,82.07 82.42,81.6 82.51,81.51 82.78,81.51 82.87,81.6 82.87,82.07 83.08,82.27 83.47,82.27 83.68,82.07 83.68,81.6 83.77,81.51 84.04,81.51 84.13,81.6 84.13,82.07 84.34,82.27 84.73,82.27 84.94,82.07 84.94,81.6 85.03,81.51 85.3,81.51 85.39,81.6 85.39,82.07 85.6,82.27 85.99,82.27 86.2,82.07 86.2,81.6 86.29,81.51 86.56,81.51 86.65,81.6 86.65,82.07 86.86,82.27 87.25,82.27 87.45,82.07 87.45,81.6 87.55,81.51 87.82,81.51 87.91,81.6 87.91,82.07 88.11,82.27 88.51,82.27 88.71,82.07 88.71,81.6 88.81,81.51 89.08,81.51 89.17,81.6 89.17,82.07 89.37,82.27 89.77,82.27 89.97,82.07 89.97,81.6 90.07,81.51 90.34,81.51 90.43,81.6 90.43,81.89 90.63,82.1 91.03,82.1 91.23,81.89 91.23,81.6 91.33,81.51 91.6,81.51 91.69,81.6 91.69,81.89 91.89,82.1 92.29,82.1 92.49,81.89 92.49,81.6 92.59,81.51 95.74,81.51 106.19,71.06 110.59,71.06 111.49,71.96 114.14,71.96 116.29,69.81 116.29,68.03 116.68,67.64 116.68,65.72 117.6,64.8 117.6,62.55 117.97,62.18 118.38,62.18 v1(118.64,62.44)
  BOTTOM w0.102: U1.AK55 118.22,62.86 v1(118.64,62.44) ; JDIMM1.186 77.42,80.15 77.54,80.26 77.54,80.53 78.05,81.05 79.37,81.05 79.81,81.49 79.81,81.81 v3(80.02,82.02)
DDR_A_MA0: length 52.5
  IN4 w0.132: v3(80.23,52.93) 80.01,52.93 79.91,53.04 79.91,53.31 80.01,53.41 80.92,53.41 80.99,53.48 80.99,53.56 81.09,53.67 81.34,53.67 81.44,53.56 81.44,52.81 81.57,52.68 81.84,52.68 81.97,52.81 81.97,53.4 82.07,53.5 82.4,53.5 82.5,53.4 82.5,52.81 82.63,52.68 82.89,52.68 83.03,52.81 83.03,53.4 83.13,53.5 83.45,53.5 83.55,53.4 83.55,52.81 83.69,52.68 83.95,52.68 84.08,52.81 84.08,53.4 84.18,53.5 84.51,53.5 84.61,53.4 84.61,52.81 84.74,52.68 85.01,52.68 85.14,52.81 85.14,53.4 85.24,53.5 85.57,53.5 85.67,53.4 85.67,52.81 85.8,52.68 86.06,52.68 86.2,52.81 86.2,53.4 86.3,53.5 86.62,53.5 86.72,53.4 86.72,52.81 86.86,52.68 87.12,52.68 87.25,52.81 87.25,53.4 87.35,53.5 87.68,53.5 87.78,53.4 87.78,52.81 87.91,52.68 88.18,52.68 88.31,52.81 88.31,53.4 88.41,53.5 88.73,53.5 88.84,53.4 88.84,52.77 88.94,52.67 89.24,52.67 89.34,52.77 89.34,53.4 89.45,53.5 89.74,53.5 89.84,53.4 89.84,53.04 89.99,52.88 102.62,52.88 102.93,52.57 107.41,52.57 107.51,52.47 107.51,52.24 107.41,52.14 106.09,52.14 105.99,52.04 v1(105.99,51.7)
  BOTTOM w0.102: U1.BG35 105.58,52.58 105.38,52.38 105.38,52.24 105.48,52.14 105.86,52.14 105.99,52.01 v1(105.99,51.7)
  BOTTOM w0.165: v3(80.23,52.93) 80.34,53.05 80.34,53.81 80.22,53.94 77.64,53.94 77.45,53.75
  BOTTOM w0.17: JDIMM1.98 77.45,53.75
DDR_A_MA1: length 53
  IN4 w0.084: 101.87,51.69 102.63,51.69 103.2,51.11 108.58,51.11 109.84,52.37 110.39,52.37 110.61,52.59 v1(111.14,52.59)
  IN4 w0.132: 101.87,51.69 90.04,51.69 89.82,51.47 76.99,51.47 76.74,51.23 71.19,51.23 71.1,51.32 71.1,52.33 71.01,52.42 68.87,52.42 68.78,52.51 68.78,53.97 68.87,54.06 71.08,54.06 71.18,53.97 71.18,53.58 71.08,53.49 70.54,53.49 70.45,53.4 v3(70.45,52.98)
  BOTTOM w0.102: v1(111.14,52.59) 111.46,52.26 U1.BB34
  BOTTOM w0.17: v3(70.45,52.98) 69.98,53.45 JDIMM1.97
DDR_A_MA2: length 53.2
  IN4 w0.132: v3(78.71,52.93) 78.66,52.93 78.55,53.04 78.55,53.31 78.66,53.41 79.04,53.41 79.14,53.51 79.14,53.82 79.04,53.92 78.25,53.92 78.15,53.82 78.15,53.48 78.05,53.38 77.73,53.38 77.63,53.48 77.63,53.88 77.53,53.98 75.08,53.98 74.98,53.88 74.98,52.18 75.08,52.08 75.4,52.08 75.51,52.18 75.51,53.35 75.61,53.45 75.93,53.45 76.03,53.35 76.03,52.18 76.13,52.08 76.47,52.08 76.57,52.18 76.57,53.37 76.67,53.48 76.95,53.48 77.06,53.37 77.06,52.37 77.16,52.27 89.49,52.27 89.71,52.49 102.58,52.49 102.81,52.26 104.17,52.26 104.27,52.15 104.27,51.8 104.17,51.7 v1(104.03,51.7)
  BOTTOM w0.102: v1(104.03,51.7) 105.23,52.9 109.29,52.9 109.62,52.58 U1.BE35
  BOTTOM w0.152: v3(78.71,52.93) 78.87,52.93 79,53.06 79,53.28 78.87,53.41 77.61,53.41 77.35,53.15
  BOTTOM w0.17: JDIMM1.96 77.35,53.15
DDR_A_MA3: length 53.5
  IN4 w0.084: v1(106.64,51.7) 106.64,51.41 106.53,51.3 103.45,51.3 102.66,52.09 101.87,52.09
  IN4 w0.132: v3(71.98,52.98) 72.16,52.98 72.26,53.07 72.26,53.57 72.35,53.67 73.94,53.67 74.03,53.57 74.03,53.31 73.94,53.22 73.34,53.22 73.25,53.13 73.25,52.82 73.34,52.73 73.94,52.73 74.03,52.63 74.03,52.33 73.94,52.24 71.67,52.24 71.58,52.15 71.58,51.77 71.67,51.68 76.64,51.68 76.83,51.87 89.66,51.87 89.87,52.09 101.87,52.09
  BOTTOM w0.102: v1(106.64,51.7) 107.31,52.37 108.78,52.37 108.88,52.27 110.33,52.27 U1.BD35
  BOTTOM w0.152: v3(71.98,52.98) 72.17,52.98 72.3,52.85 72.3,52.52 72.17,52.39 69.59,52.39 69.13,52.85
  BOTTOM w0.17: JDIMM1.95 69.13,52.85
DDR_A_MA4: length 56.7
  IN4 w0.084: 101.87,50.89 102.62,50.89 102.78,50.73 108.77,50.73 110.04,52 114.14,52 114.23,52.09 115.05,52.09 115.16,52.19 115.16,52.4 115.05,52.5 114.94,52.5 114.84,52.6 114.84,52.75 114.94,52.85 115.04,52.85 115.14,52.95 115.14,53.11 115.04,53.22 114.14,53.22 114.04,53.11 114.04,52.94 114.14,52.84 114.3,52.84 114.4,52.74 v1(114.4,52.59)
  IN4 w0.132: v3(80.23,50.57) 80.01,50.57 79.91,50.47 79.91,50.16 80.01,50.06 81.32,50.06 81.45,50.19 81.45,50.57 81.55,50.67 81.88,50.67 81.98,50.57 81.98,50.16 82.08,50.06 82.41,50.06 82.51,50.16 82.51,50.57 82.61,50.67 82.94,50.67 83.04,50.57 83.04,50.16 83.14,50.06 83.46,50.06 83.57,50.16 83.57,50.57 83.67,50.67 83.99,50.67 84.09,50.57 84.09,50.16 84.2,50.06 84.52,50.06 84.62,50.16 84.62,50.57 84.72,50.67 85.05,50.67 85.15,50.57 85.15,50.16 85.25,50.06 85.58,50.06 85.68,50.16 85.68,50.57 85.78,50.67 86.11,50.67 86.21,50.57 86.21,50.16 86.31,50.06 86.63,50.06 86.74,50.16 86.74,50.57 86.84,50.67 87.16,50.67 87.26,50.57 87.26,50.16 87.37,50.06 87.69,50.06 87.79,50.16 87.79,50.57 87.89,50.67 88.22,50.67 88.32,50.57 88.32,50.16 88.42,50.06 88.75,50.06 88.85,50.16 88.85,50.57 88.95,50.67 89.28,50.67 89.38,50.57 89.38,50.16 89.48,50.06 89.8,50.06 89.91,50.16 89.91,50.57 90.01,50.67 90.33,50.67 90.43,50.57 90.43,50.16 90.53,50.06 90.86,50.06 90.96,50.16 90.96,50.79 91.06,50.89 91.39,50.89 91.49,50.79 91.49,50.16 91.59,50.06 91.92,50.06 92.02,50.16 92.02,50.79 92.12,50.89 101.87,50.89
  BOTTOM w0.102: v1(114.4,52.59) 114.36,52.55 114.36,52.31 114.49,52.19 U1.AT34
  BOTTOM w0.165: v3(80.23,50.57) 80.23,51.54 80.02,51.75
  BOTTOM w0.17: 80.02,51.75 79.83,51.95 JDIMM1.92
DDR_A_MA5: length 53.7
  IN4 w0.084: v1(113.75,52.59) 113.85,52.49 113.85,52.32 113.71,52.18 109.92,52.18 108.66,50.93 103.08,50.93 102.72,51.29 101.87,51.29
  IN4 w0.132: v3(71.98,50.54) 71.98,50.35 72.3,50.03 73.09,50.03 73.2,50.13 73.2,50.73 73.3,50.83 74.03,50.83 74.13,50.73 74.13,50.14 74.24,50.03 74.98,50.03 75.08,50.14 75.08,50.73 75.18,50.83 75.43,50.83 75.53,50.73 75.53,49.7 75.63,49.6 75.91,49.6 76.01,49.7 76.01,50.73 76.12,50.83 76.91,50.83 77.16,51.07 90,51.07 90.21,51.29 101.87,51.29
  BOTTOM w0.102: U1.AU34 114.06,52.13 113.96,52.03 113.82,52.03 113.72,52.13 113.72,52.56 v1(113.75,52.59)
  BOTTOM w0.17: v3(71.98,50.54) 72.15,50.72 72.15,51.55 72.05,51.65 71.02,51.65 JDIMM1.91
DDR_A_MA6: length 54.5
  IN4 w0.084: 101.87,50.49 102.43,50.49 102.48,50.55 108.88,50.55 109.93,51.59 v1(111.18,51.59)
  IN4 w0.132: v3(78.71,50.57) 78.48,50.57 78.38,50.47 78.38,50.23 78.28,50.12 77.02,50.12 76.92,50.23 76.92,50.33 76.81,50.43 76.51,50.43 76.41,50.33 76.41,49.7 76.51,49.6 78.76,49.6 78.86,49.7 78.86,50.05 78.96,50.15 79.33,50.15 79.43,50.05 79.43,49.7 79.53,49.6 92.32,49.6 92.42,49.7 92.42,50.39 92.52,50.49 92.82,50.49 92.92,50.39 92.92,49.7 93.02,49.6 93.4,49.6 93.47,49.67 93.47,50.39 93.58,50.49 93.89,50.49 93.99,50.39 93.99,49.7 94.09,49.6 94.42,49.6 94.52,49.7 94.52,50.36 94.62,50.47 94.94,50.47 95.05,50.36 95.05,49.7 95.15,49.6 95.47,49.6 95.57,49.7 95.57,50.36 95.68,50.47 96,50.47 96.1,50.36 96.1,49.7 96.2,49.6 96.53,49.6 96.63,49.7 96.63,50.36 96.73,50.47 97.06,50.47 97.16,50.36 97.16,49.7 97.26,49.6 97.59,49.6 97.69,49.7 97.69,50.39 97.79,50.49 98.07,50.49 98.18,50.39 98.18,49.93 98.28,49.83 98.54,49.83 98.65,49.93 98.65,50.39 98.75,50.49 101.87,50.49
  BOTTOM w0.102: U1.BB32 111.19,51.2 111.09,51.3 111.09,51.5 v1(111.18,51.59)
  BOTTOM w0.165: JDIMM1.90 77.7,51.35 78.17,51.35 78.34,51.52 79.34,51.52 79.46,51.41 79.46,51.18 79.32,51.04 78.81,51.04 78.71,50.94 v3(78.71,50.57)
DDR_A_MA7: length 57.2
  IN4 w0.084: v1(114.51,51.66) 113.63,50.78 110.76,50.78 109.03,49.05 108.23,49.05 107.98,49.3 107.76,49.3
  IN4 w0.132: 107.76,49.3 99.7,49.3 98.23,47.82 98.02,47.82 97.89,47.96 97.89,48.24 97.79,48.34 97.46,48.34 97.36,48.24 97.36,47.87 97.26,47.77 96.93,47.77 96.83,47.87 96.83,48.24 96.73,48.34 96.41,48.34 96.3,48.24 96.3,47.87 96.2,47.77 95.88,47.77 95.78,47.87 95.78,48.24 95.67,48.34 95.35,48.34 95.25,48.24 95.25,47.87 95.15,47.77 94.82,47.77 94.72,47.87 94.72,48.24 94.62,48.34 94.29,48.34 94.19,48.24 94.19,47.87 94.09,47.77 93.76,47.77 93.66,47.87 93.66,48.24 93.56,48.34 93.24,48.34 93.13,48.24 93.13,47.87 93.03,47.77 92.71,47.77 92.61,47.87 92.61,48.24 92.5,48.34 92.18,48.34 92.08,48.24 92.08,47.87 91.98,47.77 91.65,47.77 91.55,47.87 91.55,48.24 91.45,48.34 91.12,48.34 91.02,48.24 91.02,47.87 90.92,47.77 90.59,47.77 90.49,47.87 90.49,48.24 90.39,48.34 90.07,48.34 89.96,48.24 89.96,47.87 89.86,47.77 89.54,47.77 89.44,47.87 89.44,48.24 89.33,48.34 89.01,48.34 88.91,48.24 88.91,47.87 88.81,47.77 88.48,47.77 88.38,47.87 88.38,48.24 88.28,48.34 87.95,48.34 87.85,48.24 87.85,47.87 87.75,47.77 87.42,47.77 87.32,47.87 87.32,48.24 87.22,48.34 86.9,48.34 86.79,48.24 86.79,47.87 86.69,47.77 86.37,47.77 86.27,47.87 86.27,48.24 86.16,48.34 85.84,48.34 85.74,48.24 85.74,47.87 85.64,47.77 85.31,47.77 85.21,47.87 85.21,48.24 85.11,48.34 84.78,48.34 84.68,48.24 84.68,47.87 84.58,47.77 84.25,47.77 84.15,47.87 84.15,48.24 84.05,48.34 83.73,48.34 83.62,48.24 83.62,47.87 83.52,47.77 83.2,47.77 83.1,47.87 83.1,48.24 83,48.34 82.67,48.34 82.57,48.24 82.57,47.87 82.47,47.77 82.14,47.77 82.04,47.87 82.04,48.24 81.94,48.34 81.61,48.34 81.51,48.24 81.51,47.87 81.41,47.77 80.01,47.77 79.91,47.87 79.91,48.16 80.04,48.28 v3(80.23,48.28)
  BOTTOM w0.102: U1.AT32 114.76,51.41 v1(114.51,51.66)
  BOTTOM w0.165: v3(80.23,48.28) 80.23,48.95 79.19,49.99
  BOTTOM w0.17: JDIMM1.86 77.4,50.15 77.57,49.99 79.19,49.99
DDR_A_MA8: length 52.1
  IN4 w0.084: 101.87,50.09 104.1,50.09 104.37,50.36 109.82,50.36 110.61,51.16 112.05,51.16 v1(112.49,51.59)
  IN4 w0.132: v3(70.45,50.54) 70.45,51.92 70.36,52.01 69.29,52.01 69.19,51.92 69.19,50.27 69.39,50.08 71.66,50.08 72.11,49.63 74.86,49.63 75.29,49.2 98.48,49.2 99.37,50.09 101.87,50.09
  BOTTOM w0.102: v1(112.49,51.59) 112.81,51.27 U1.AY32
  BOTTOM w0.165: 69.95,51.05 v3(70.45,50.54)
  BOTTOM w0.17: JDIMM1.89 69.95,51.05
DDR_A_MA9: length 54
  IN4 w0.084: v1(113.14,51.59) 112.51,50.96 110.68,50.96 109.89,50.17 104.51,50.17 104.03,49.69 101.87,49.69
  IN4 w0.132: 101.87,49.69 99.54,49.69 98.59,48.74 75.18,48.74 74.73,49.2 71.96,49.2 71.54,49.62 69.17,49.62 69.07,49.52 69.07,49.17 69.17,49.07 71.42,49.07 71.88,48.61 v3(71.98,48.61)
  BOTTOM w0.102: U1.AV32 113.46,51.27 v1(113.14,51.59)
  BOTTOM w0.17: v3(71.98,48.61) 70.73,49.85 JDIMM1.85
DDR_A_MA10: length 49.8
  IN4 w0.084: 101.87,55.96 102.08,55.96 102.1,55.93 103.62,55.93 104.31,55.24 106.44,55.24 v1(107.89,53.79)
  IN4 w0.132: 101.87,55.96 93.75,55.96 91.37,58.34 76.67,58.34 76.31,58.7 73.33,58.7 73.2,58.57 73.2,57.86 73.08,57.73 72.8,57.73 72.67,57.86 72.67,58.57 72.55,58.7 72.29,58.7 72.17,58.57 72.17,58.28 72.04,58.15 71.77,58.15 71.65,58.28 71.65,58.57 71.52,58.7 71.25,58.7 71.13,58.57 71.13,57.84 71.25,57.71 71.85,57.71 71.98,57.58 v3(71.98,57.26)
  BOTTOM w0.102: v1(107.89,53.79) 108.29,53.38 109.32,53.38 109.63,53.69 U1.BE37
  BOTTOM w0.17: v3(71.98,57.26) 71.07,56.35 69.2,56.35 69.1,56.45 JDIMM1.107
DDR_A_MA11: length 53.2
  IN4 w0.084: v1(112.17,50.21) 111.78,50.59 110.84,50.59 109.07,48.83 108.19,48.83 108.12,48.9 107.88,48.9
  IN4 w0.132: v3(78.71,48.28) 78.71,47.94 78.61,47.84 76.87,47.84 76.76,47.94 76.76,48.24 76.66,48.34 76.32,48.34 76.21,48.24 76.21,47.42 76.11,47.32 75.79,47.32 75.69,47.42 75.69,48.21 75.55,48.34 75.21,48.34 75.11,48.24 75.11,46.86 75.21,46.76 76.65,46.76 76.75,46.86 76.75,47.28 76.85,47.38 77.18,47.38 77.28,47.28 77.28,46.8 77.38,46.69 77.71,46.69 77.81,46.8 77.81,47.27 77.91,47.37 78.23,47.37 78.34,47.27 78.34,47.05 78.44,46.95 78.76,46.95 78.86,47.05 78.86,47.24 79,47.37 98.34,47.37 99.87,48.9 107.88,48.9
  BOTTOM w0.102: U1.BA30 112.17,50.3 v1(112.17,50.21)
  BOTTOM w0.165: v3(78.71,48.28) 78.71,48.38 78.84,48.51 78.99,48.51 79.11,48.63 79.11,49.38 78.95,49.55 77.55,49.55
  BOTTOM w0.17: JDIMM1.84 77.55,49.55
DDR_A_MA12: length 54.2
  IN4 w0.084: 108.16,48.5 109,48.5 110.69,50.18 v1(111.48,50.18)
  IN4 w0.132: v3(70.45,48.61) 70.45,48.26 70.56,48.16 70.94,48.16 71.07,48.03 71.07,47.45 71.17,47.35 71.5,47.35 71.6,47.45 71.6,48.06 71.7,48.16 72.03,48.16 72.13,48.06 72.13,47.41 72.23,47.31 72.56,47.31 72.66,47.41 72.66,48.06 72.76,48.16 73.09,48.16 73.2,48.06 73.2,47.53 73.3,47.43 73.6,47.43 73.7,47.53 73.7,48.62 73.8,48.72 74.2,48.72 74.3,48.62 74.3,47.77 74.4,47.67 74.61,47.67 74.71,47.57 74.71,47.29 74.62,47.19 74.08,47.19 73.98,47.09 73.98,46.4 74.08,46.3 78.68,46.3 79.29,46.91 98.45,46.91 100.03,48.5 108.16,48.5
  BOTTOM w0.102: U1.BC30 111.18,50.47 v1(111.48,50.18)
  BOTTOM w0.165: 69.81,49.25 v3(70.45,48.61)
  BOTTOM w0.17: JDIMM1.83 69.81,49.25
DDR_A_MA13: length 53.7
  IN4 w0.084: v1(113.55,56.03) 113.55,55.91 113.03,55.39 110.61,55.39 110.02,55.97 109.57,55.97 108.86,56.68 106.1,56.68 105.91,56.87 102.86,56.87 102.35,57.38 102.35,57.85 101.97,58.23 101.87,58.23
  IN4 w0.132: 101.87,58.23 94.85,58.23 91.58,61.5 73.5,61.5 73.4,61.4 73.4,60.62 73.3,60.52 72.97,60.52 72.86,60.62 72.86,61.16 72.76,61.26 72.45,61.26 72.34,61.16 72.34,60.62 72.24,60.52 71.93,60.52 71.82,60.62 71.82,61.53 71.98,61.68 v3(71.98,62.03)
  BOTTOM w0.102: U1.AW41 113.14,55.61 113.31,55.78 v1(113.55,56.03)
  BOTTOM w0.165: v3(71.98,62.03) 70.14,60.2 69.29,60.2 69.14,60.05
  BOTTOM w0.17: JDIMM1.119 69.14,60.05
DDR_A_MA14: length 52.6
  IN4 w0.084: 108.16,48.1 108.24,48.1 108.45,48.3 109.23,48.3 110.71,49.78 113.02,49.78 113.13,49.67 v1(113.13,49.19)
  IN4 w0.132: v3(80.23,46.45) 80.03,46.45 79.91,46.33 79.91,46.04 80.01,45.94 81.3,45.94 81.44,46.07 81.44,46.38 81.56,46.51 81.83,46.51 81.96,46.38 81.96,46.06 82.09,45.94 82.36,45.94 82.49,46.06 82.49,46.41 82.59,46.51 82.92,46.51 83.02,46.41 83.02,46.06 83.14,45.94 86.58,45.94 86.72,46.07 86.72,46.38 86.84,46.51 87.12,46.51 87.24,46.38 87.24,46.06 87.37,45.94 87.66,45.94 87.79,46.06 87.79,46.41 87.89,46.51 88.21,46.51 88.32,46.41 88.32,46.04 88.42,45.94 88.74,45.94 88.84,46.04 88.84,46.41 88.95,46.51 89.27,46.51 89.37,46.41 89.37,46.04 89.47,45.94 89.8,45.94 89.9,46.04 89.9,46.41 90,46.51 90.33,46.51 90.43,46.41 90.43,46.04 90.53,45.94 90.86,45.94 90.96,46.04 90.96,46.41 91.06,46.51 91.38,46.51 91.49,46.41 91.49,46.04 91.59,45.94 91.91,45.94 92.01,46.04 92.01,46.41 92.12,46.51 92.44,46.51 92.54,46.41 92.54,46.04 92.64,45.94 92.97,45.94 93.07,46.04 93.07,46.41 93.17,46.51 93.5,46.51 93.6,46.41 93.6,46.04 93.7,45.94 94.03,45.94 94.13,46.04 94.13,46.41 94.23,46.51 98.61,46.51 100.2,48.1 100.62,48.1 100.75,47.97 100.75,47.88 100.83,47.8 101.2,47.8 101.28,47.88 101.28,48.02 101.36,48.1 101.73,48.1 101.81,48.02 101.81,47.86 101.89,47.78 102.26,47.78 102.34,47.86 102.34,48 102.41,48.07 102.79,48.07 102.87,48 102.87,47.88 102.94,47.81 103.32,47.81 103.39,47.88 103.39,48 103.47,48.07 103.85,48.07 103.92,48 103.92,47.87 104,47.79 104.37,47.79 104.45,47.87 104.45,48.01 104.53,48.08 104.9,48.08 104.98,48.01 104.98,47.88 105.06,47.81 105.43,47.81 105.51,47.88 105.51,48 105.58,48.07 105.96,48.07 106.04,48 106.04,47.87 106.11,47.79 106.49,47.79 106.56,47.87 106.56,48 106.64,48.07 107.02,48.07 107.09,48 107.09,47.85 107.17,47.77 107.54,47.77 107.62,47.85 107.62,47.97 107.75,48.1 108.16,48.1
  BOTTOM w0.102: U1.AY28 112.79,49.53 v1(113.13,49.19)
  BOTTOM w0.152: 77.31,48.35 77.49,48.18 77.49,48.09 77.76,47.82 78.26,47.82 78.27,47.82 79.41,47.82 80.23,47 v3(80.23,46.45)
  BOTTOM w0.17: JDIMM1.80 77.31,48.35
DDR_A_MA15: length 53
  IN4 w0.084: v3(113.68,48.2) 113.24,48.64 110.45,48.64 109.06,47.25 108.35,47.25 108.1,47
  IN4 w0.132: v1(79.45,44.47) 79.44,44.48 79.44,44.98 79.54,45.08 80.64,45.08 80.78,44.95 80.78,44.57 80.88,44.47 81.2,44.47 81.31,44.57 81.31,45.04 81.41,45.14 81.73,45.14 81.83,45.04 81.83,44.57 81.94,44.47 82.26,44.47 82.36,44.57 82.36,45.04 82.46,45.14 82.79,45.14 82.89,45.04 82.89,44.57 82.99,44.47 83.32,44.47 83.42,44.57 83.42,45.04 83.52,45.14 83.85,45.14 83.95,45.04 83.95,44.57 84.05,44.47 84.37,44.47 84.48,44.57 84.48,45.04 84.58,45.14 84.9,45.14 85,45.04 85,44.57 85.1,44.47 85.43,44.47 85.53,44.57 85.53,45.04 85.63,45.14 85.96,45.14 86.06,45.04 86.06,44.57 86.16,44.47 86.49,44.47 86.59,44.57 86.59,45.04 86.69,45.14 87.02,45.14 87.12,45.04 87.12,44.57 87.22,44.47 87.54,44.47 87.64,44.57 87.64,45.04 87.75,45.14 88.07,45.14 88.17,45.04 88.17,44.57 88.27,44.47 88.6,44.47 88.7,44.57 88.7,45.04 88.8,45.14 89.13,45.14 89.24,45.04 89.24,44.57 89.34,44.47 89.67,44.47 89.77,44.57 89.77,45.04 89.87,45.14 90.2,45.14 90.3,45.04 90.3,44.57 90.4,44.47 90.73,44.47 90.84,44.57 90.84,45.04 90.94,45.14 94.36,45.14 94.93,45.71 98.94,45.71 100.23,47 108.1,47
  BOTTOM w0.102: U1.AU26 113.99,48.52 v3(113.68,48.2)
  BOTTOM w0.165: 77.18,47.75 77.61,47.31 77.61,47.31 78.26,46.67 78.26,45.9 79.45,44.72 v1(79.45,44.47)
  BOTTOM w0.17: JDIMM1.78 77.18,47.75
DDR_A_RAS#: length 53.6
  IN4 w0.084: 101.87,55.16 103.39,55.16 103.94,54.61 104.8,54.61 v1(105.31,54.1)
  IN4 w0.132: 101.87,55.16 93.42,55.16 91.88,56.7 79.64,56.7 79.54,56.6 79.54,56.18 79.44,56.07 79.14,56.07 79.04,56.18 79.04,56.57 78.94,56.68 78.68,56.68 78.58,56.57 78.58,56.18 78.48,56.07 78.15,56.07 78.05,56.18 78.05,56.53 77.94,56.63 76.32,56.63 76.22,56.73 76.22,57.04 76.12,57.14 75.38,57.14 75.27,57.24 75.27,57.63 75.12,57.78 74.51,57.78 74.38,57.65 74.38,57.27 74.25,57.14 73.73,57.14 73.6,57.27 73.6,58.17 73.73,58.3 75.41,58.3 75.98,57.73 76.89,57.73 76.99,57.63 76.99,57.17 77.09,57.07 77.4,57.07 77.5,57.17 77.5,57.63 77.6,57.73 78.9,57.73 79.03,57.6 79.03,57.39 78.9,57.26 v3(78.71,57.26)
  BOTTOM w0.102: v1(105.31,54.1) 105.82,54.61 107.14,54.61 107.35,54.4 108.87,54.4 109.05,54.22 110.31,54.22 U1.BD39
  BOTTOM w0.165: v3(78.71,57.26) 78.9,57.26 79.02,57.39 79.02,57.62 78.9,57.75 77.67,57.75 77.36,57.44
  BOTTOM w0.17: JDIMM1.110 77.27,57.35 77.36,57.44
DDR_A_WE#: length 51.2
  IN4 w0.084: 101.87,57.83 101.93,57.83 102.16,57.6 102.16,57.31 102.79,56.68 105.84,56.68 106.02,56.5 108.78,56.5 109.49,55.79 109.94,55.79 110.53,55.2 113.1,55.2 113.39,55.49 114.26,55.49 v1(114.77,55.99)
  IN4 w0.132: 101.87,57.83 94.68,57.83 91.41,61.1 74.45,61.1 73.44,60.09 72.65,60.09 72.11,59.54 v3(71.98,59.54)
  BOTTOM w0.102: U1.AT41 114.44,55.67 v1(114.77,55.99)
  BOTTOM w0.165: 70.82,58.39 v3(71.98,59.54)
  BOTTOM w0.17: 70.82,58.39 70.68,58.25 JDIMM1.113
DDR_B_BS0: length 72.6
  IN1 w0.084: 101.87,55.73 v1(105.39,55.73)
  IN1 w0.132: v3(52.98,53.73) 52.98,54.22 52.86,54.35 51.33,54.35 51.2,54.47 51.2,54.83 51.33,54.96 54.12,54.96 54.27,54.8 54.27,54.04 54.4,53.91 54.76,53.91 54.88,54.04 54.88,54.8 55.04,54.96 55.34,54.96 55.49,54.8 55.49,54.08 55.62,53.95 55.98,53.95 56.1,54.08 56.1,54.8 56.25,54.96 57.38,54.96 58.41,55.98 63.75,55.98 64.41,56.65 67.12,56.65 68.03,55.73 76.72,55.73 76.85,55.6 76.85,54.64 76.98,54.5 77.25,54.5 77.38,54.64 77.38,55.6 77.51,55.73 77.78,55.73 77.91,55.6 77.91,54.64 78.04,54.5 78.3,54.5 78.44,54.64 78.44,55.6 78.57,55.73 101.87,55.73
  BOTTOM w0.102: v1(105.39,55.73) 106.09,55.02 107.13,55.02 107.55,54.61 109.11,54.61 U1.BG39
  BOTTOM w0.17: v3(52.98,53.73) 53.59,54.34 53.93,54.34 54.22,54.05 JDIMM2.109
DDR_B_BS1: length 73
  IN1 w0.084: v1(104.7,54.09) 103.9,54.89 101.87,54.89
  IN1 w0.132: 101.87,54.89 91.18,54.89 91.05,54.76 91.05,54.09 90.92,53.96 90.64,53.96 90.52,54.09 90.52,54.76 90.39,54.89 90.12,54.89 89.99,54.76 89.99,53.03 89.86,52.91 89.59,52.91 89.46,53.03 89.46,54.76 89.33,54.89 89.06,54.89 88.93,54.76 88.93,53.02 88.8,52.89 88.54,52.89 88.4,53.02 88.4,54.76 88.27,54.89 88.01,54.89 87.88,54.76 87.88,53.02 87.74,52.89 87.41,52.89 87.28,53.02 87.28,53.85 87.14,53.98 86.88,53.98 86.75,53.85 86.75,53.02 86.62,52.89 81.82,52.89 81.13,53.59 71.39,53.59 70.48,54.5 67.86,54.5 67.04,55.32 65.66,55.32 64.99,54.65 59.36,54.65 v3(58.91,55.1)
  BOTTOM w0.102: U1.BD42 110.32,55.98 108.97,55.98 108.81,56.14 105.22,56.14 104.7,55.62 v1(104.7,54.09)
  BOTTOM w0.17: v3(58.91,55.1) 59.48,54.53 60.38,54.53 60.75,54.17 61.9,54.17 62.32,53.75 JDIMM2.108
DDR_B_BS2: length 77.1
  IN1 w0.084: v1(114.74,47.26) 114.22,46.74 109.04,46.74 108.71,46.41 103.16,46.41 101.87,45.11
  IN1 w0.132: 101.87,45.11 101.19,44.43 99.62,44.43 96.93,41.75 83.66,41.75 83.53,41.61 83.53,40.96 83.4,40.83 83.13,40.83 83,40.96 83,41.61 82.87,41.75 82.6,41.75 82.47,41.61 82.47,40.96 82.34,40.83 82.07,40.83 81.94,40.96 81.94,41.61 81.81,41.75 81.55,41.75 81.41,41.61 81.41,40.96 81.28,40.83 81.02,40.83 80.89,40.96 80.89,41.61 80.75,41.75 77.78,41.75 76.85,40.81 62.96,40.81 62.46,41.32 56.41,41.32 53.78,43.95 52.06,43.95 v3(51.46,43.34)
  BOTTOM w0.102: v1(114.74,47.26) 114.38,46.9 U1.AT22
  BOTTOM w0.17: v3(51.46,43.34) 52.2,44.08 53.32,44.08 54.29,45.05 JDIMM2.79
DDR_B_CAS#: length 75.8
  IN1 w0.084: 101.87,57.2 102.05,57.2 102.62,56.64 108.3,56.64 109.17,57.51 113.71,57.51 v1(114.23,56.99)
  IN1 w0.132: v3(52.98,55.76) 52.98,56.57 53.11,56.69 53.65,56.69 53.78,56.57 53.78,56.31 53.9,56.18 54.2,56.18 54.32,56.31 54.32,56.57 54.45,56.69 54.95,56.69 55.08,56.57 55.08,55.48 55.2,55.35 55.56,55.35 55.69,55.48 55.69,56.49 55.83,56.64 56.85,56.64 57.58,55.91 57.76,55.91 58.02,56.16 58.02,56.34 57.15,57.21 57.15,57.38 58.04,58.27 58.22,58.27 58.41,58.08 58.41,57.65 58.54,57.51 58.81,57.51 58.94,57.65 58.94,58.08 59.07,58.21 59.33,58.21 59.47,58.08 59.47,57.65 59.6,57.51 59.86,57.51 59.99,57.65 59.99,58.08 60.13,58.21 61.91,58.21 62.58,58.89 66.01,58.89 66.36,59.24 68.05,59.24 68.97,58.33 93.47,58.33 94.59,57.2 101.87,57.2
  BOTTOM w0.102: U1.AV43 113.87,56.64 v1(114.23,56.99)
  BOTTOM w0.17: JDIMM2.115 54.35,55.85 53.93,56.26 53.49,56.26 v3(52.98,55.76)
DDR_B_D0: length 85
  IN1 w0.084: v1(118.09,32.89) 118.51,32.47 118.51,32.08 118.11,31.67 118.11,29.3 110.13,21.33 98.6,21.33 97.36,20.09 90.2,20.09 88.65,18.54 83.71,18.54 82.1,16.92 67.49,16.92 65.99,18.43 59.95,18.43 59.66,18.71 56.35,18.71 54.62,20.44 53.03,20.44 v3(52.22,21.24)
  BOTTOM w0.102: v3(52.22,21.24) 53.02,20.45 JDIMM2.5 ; v1(118.09,32.89) 117.67,33.31 117.67,34.34 117.44,34.57 117.44,35.87 117.56,35.98 117.56,37.23 U1.AL4
DDR_B_D1: length 84.9
  IN1 w0.084: v1(118.09,32.26) 117.82,31.99 117.82,29.42 110.01,21.61 98.48,21.61 97.28,20.41 90.01,20.41 88.45,18.84 83.38,18.84 81.75,17.21 67.61,17.21 66.11,18.71 60.07,18.71 59.78,19 57.43,19 57.33,19.1 57.33,21.12 57.23,21.22 57.09,21.22 56.99,21.12 56.99,19.1 56.89,19 56.75,19 56.66,19.1 56.66,21.14 56.55,21.24 v3(53.75,21.24)
  BOTTOM w0.102: v3(53.75,21.24) 53.94,21.05 JDIMM2.7 ; v1(118.09,32.26) 117.37,32.98 117.37,34.32 117.23,34.47 U1.AL1
DDR_B_D2: length 84.3
  IN1 w0.084: v3(53.75,22.9) 53.75,22.2 53.85,22.1 54.26,22.1 54.35,22.18 54.35,23.25 54.45,23.35 54.58,23.35 54.68,23.25 54.68,22.18 54.77,22.1 54.93,22.1 55.02,22.18 55.02,22.8 55.1,22.89 55.27,22.89 55.35,22.8 55.35,22.18 55.44,22.1 55.6,22.1 55.69,22.18 55.69,22.8 55.77,22.89 55.94,22.89 56.02,22.8 56.02,22.18 56.11,22.1 57.05,22.1 57.14,22.18 57.14,22.8 57.22,22.89 57.39,22.89 57.47,22.8 57.47,22.18 57.56,22.1 57.72,22.1 57.81,22.18 57.81,22.8 57.89,22.89 58.06,22.89 58.14,22.8 58.14,22.18 58.23,22.1 60.66,22.1 61.31,21.45 69.74,21.45 71.95,19.23 78.64,19.23 82.13,22.72 96.54,22.72 103.79,29.97 114.19,29.97 115.13,30.9 115.13,31.54 115.23,31.64 115.23,33.31 v1(116.11,34.2)
  BOTTOM w0.102: v1(116.11,34.2) 116.54,34.62 116.54,35.72 116.44,35.82 116.44,36.22 116.11,36.54 U1.AN3 ; JDIMM2.15 54.3,23.45 v3(53.75,22.9)
DDR_B_D3: length 83.9
  IN1 w0.084: v3(52.22,22.9) 52.22,21.9 52.32,21.8 52.54,21.8 52.62,21.88 52.62,22.35 52.7,22.44 52.87,22.44 52.95,22.35 52.95,21.88 53.04,21.8 57.53,21.8 57.63,21.69 57.63,20.92 57.73,20.82 57.93,20.82 58.03,20.93 58.03,21.69 58.13,21.8 60.56,21.8 61.19,21.16 69.62,21.16 71.83,18.94 78.8,18.94 82.19,22.34 96.56,22.34 103.9,29.68 114.3,29.68 115.41,30.78 115.41,31.42 115.52,31.53 115.52,32.95 v1(116.11,33.54)
  BOTTOM w0.102: v3(52.22,22.9) 53.38,24.05 JDIMM2.17 ; U1.AR4 115.6,37.21 115.6,35.95 115.51,35.86 115.51,35.16 115.71,34.97 115.71,33.95 v1(116.11,33.54)
DDR_B_D4: length 85.3
  IN1 w0.084: v1(118.09,34.2) 117.3,33.41 117.3,32.43 117.53,32.2 117.53,29.54 109.89,21.9 98.36,21.9 97.19,20.72 89.57,20.72 88.04,19.2 83.1,19.2 81.4,17.5 69.27,17.5 69.17,17.6 69.17,18.9 69.07,19 68.94,19 68.84,18.9 68.84,17.6 68.74,17.5 68.61,17.5 68.5,17.6 68.5,18.9 68.4,19 68.27,19 68.17,18.9 68.17,17.6 68.07,17.5 67.93,17.5 67.83,17.6 67.83,18.9 67.73,19 67.6,19 67.5,18.9 67.5,18.06 67.4,17.97 67.26,17.97 67.16,18.06 67.16,18.9 67.06,19 60.19,19 59.76,19.42 v3(59.6,19.42)
  BOTTOM w0.102: v1(118.09,34.2) 118.09,34.27 117.66,34.7 117.66,35.76 117.77,35.87 117.77,37.25 U1.AK4 ; JDIMM2.4 62.27,20.15 61.68,19.57 61.68,19.19 61.31,18.81 60.21,18.81 v3(59.6,19.42)
DDR_B_D5: length 84.8
  IN1 w0.084: v1(118.09,34.85) 117.33,34.85 116.87,34.39 116.87,32.41 117.25,32.03 117.25,29.66 109.77,22.19 98.24,22.19 97.1,21.04 89.21,21.04 88.58,20.41 83.75,20.41 81.13,17.78 70.21,17.78 70.13,17.87 70.13,18.66 70.03,18.75 69.89,18.75 69.79,18.66 69.79,17.9 69.69,17.8 69.55,17.8 69.46,17.9 69.46,19.19 69.35,19.29 68.83,19.29 68.72,19.39 68.72,19.7 68.62,19.8 68.46,19.8 68.38,19.72 68.38,19.41 68.28,19.31 68.14,19.31 68.04,19.41 68.04,19.72 67.96,19.8 67.79,19.8 67.71,19.72 67.71,19.37 67.62,19.29 67.41,19.29 67.33,19.37 67.33,19.72 67.25,19.8 67.08,19.8 66.99,19.72 66.99,19.37 66.91,19.29 66.74,19.29 66.66,19.37 66.66,19.72 66.57,19.8 66.41,19.8 66.32,19.72 66.32,19.37 66.24,19.29 66.07,19.29 65.99,19.37 65.99,19.72 65.9,19.8 65.74,19.8 65.65,19.72 65.65,19.37 65.57,19.29 65.4,19.29 65.32,19.37 65.32,19.72 65.23,19.8 65.07,19.8 64.98,19.72 64.98,19.37 64.9,19.29 64.73,19.29 64.65,19.37 64.65,19.72 64.56,19.8 64.4,19.8 64.31,19.72 64.31,19.37 64.23,19.29 64.06,19.29 63.98,19.37 63.98,19.72 63.89,19.8 63.73,19.8 63.64,19.72 63.64,19.37 63.56,19.29 63.39,19.29 63.31,19.37 63.31,19.72 63.22,19.8 63.05,19.8 62.97,19.72 62.97,19.37 62.89,19.29 62.72,19.29 62.64,19.37 62.64,19.72 62.55,19.8 62.38,19.8 62.3,19.72 62.3,19.37 62.22,19.29 62.05,19.29 61.96,19.37 61.96,19.72 61.88,19.8 61.71,19.8 61.63,19.72 61.63,19.37 61.55,19.29 61.26,19.29 v3(61.12,19.42)
  BOTTOM w0.102: v3(61.12,19.42) 61.12,19.6 62.27,20.75 JDIMM2.6 ; U1.AK3 118.09,36.54 118.5,36.13 118.5,35.26 v1(118.09,34.85)
DDR_B_D6: length 84
  IN1 w0.084: v3(61.12,22.54) 61.47,22.54 61.57,22.44 61.57,21.89 61.68,21.78 61.89,21.78 61.97,21.87 61.97,22.26 62.05,22.34 62.22,22.34 62.31,22.26 62.31,21.87 62.39,21.78 62.56,21.78 62.64,21.87 62.64,22.26 62.73,22.34 62.89,22.34 62.98,22.26 62.98,21.87 63.06,21.78 63.23,21.78 63.31,21.87 63.31,22.26 63.4,22.34 63.56,22.34 63.65,22.26 63.65,21.87 63.73,21.78 63.9,21.78 63.98,21.87 63.98,22.26 64.07,22.34 64.23,22.34 64.32,22.26 64.32,21.87 64.4,21.78 64.57,21.78 64.65,21.87 64.65,22.26 64.74,22.34 64.9,22.34 64.99,22.26 64.99,21.87 65.07,21.78 65.24,21.78 65.32,21.87 65.32,22.26 65.41,22.34 65.58,22.34 65.66,22.26 65.66,21.87 65.74,21.78 65.91,21.78 65.99,21.87 65.99,22.26 66.08,22.34 66.29,22.34 66.37,22.26 66.37,21.82 66.46,21.73 66.62,21.73 66.71,21.82 66.71,22.26 66.79,22.34 66.96,22.34 67.04,22.26 67.04,21.82 67.13,21.73 67.29,21.73 67.38,21.82 67.38,22.26 67.46,22.34 67.63,22.34 67.71,22.26 67.71,21.82 67.8,21.73 67.97,21.73 68.05,21.82 68.05,22.26 68.13,22.34 68.3,22.34 68.38,22.26 68.38,21.82 68.47,21.73 68.64,21.73 68.72,21.82 68.72,22.26 68.8,22.34 68.97,22.34 69.05,22.26 69.05,21.82 69.14,21.73 69.31,21.73 69.39,21.82 69.39,22.26 69.47,22.34 69.66,22.34 69.77,22.24 69.77,21.89 69.87,21.78 70.08,21.78 70.16,21.87 70.16,22.26 70.25,22.34 70.41,22.34 70.5,22.26 70.5,21.87 70.58,21.78 70.75,21.78 70.83,21.87 70.83,22.26 70.92,22.34 71.08,22.34 71.17,22.26 71.17,21.87 71.25,21.78 71.42,21.78 71.5,21.87 71.5,22.26 71.59,22.34 71.75,22.34 71.84,22.26 71.84,21.87 71.92,21.78 72.09,21.78 72.17,21.87 72.17,22.26 72.26,22.34 72.43,22.34 72.51,22.26 72.51,21.87 72.59,21.78 75.05,21.78 75.91,22.64 81.36,22.64 81.74,23.02 96.22,23.02 103.45,30.25 114.06,30.25 114.84,31.04 114.84,31.66 114.94,31.76 114.94,33.68 v1(116.11,34.85)
  BOTTOM w0.102: v1(116.11,34.85) 115.72,35.24 115.72,35.77 115.8,35.86 115.8,37.25 U1.AN4 ; JDIMM2.16 62.14,23.75 61.97,23.58 61.21,23.58 61.12,23.49 v3(61.12,22.54)
DDR_B_D7: length 83.8
  IN1 w0.084: v3(59.6,22.54) 59.6,23.07 59.5,23.17 55.75,23.17 55.64,23.27 55.64,23.68 55.75,23.78 61.7,23.78 61.8,23.68 61.8,22.73 61.9,22.63 62.12,22.63 62.2,22.71 62.2,23.34 62.28,23.43 62.45,23.43 62.53,23.34 62.53,22.71 62.62,22.63 62.79,22.63 62.87,22.71 62.87,23.34 62.95,23.43 63.12,23.43 63.21,23.34 63.21,22.71 63.29,22.63 63.5,22.63 63.58,22.71 63.58,23.35 63.67,23.44 63.84,23.44 63.92,23.35 63.92,22.71 64,22.63 64.17,22.63 64.25,22.71 64.25,23.35 64.34,23.44 64.51,23.44 64.59,23.35 64.59,22.71 64.67,22.63 74.53,22.63 74.83,22.93 81.23,22.93 81.66,23.35 96.15,23.35 103.33,30.54 113.11,30.54 113.91,31.34 v1(114.39,31.34)
  BOTTOM w0.102: v3(59.6,22.54) 61.02,23.96 61.92,23.96 62.31,24.35 JDIMM2.18 ; U1.AR1 115.25,34.9 115.37,34.78 115.37,32.33 v1(114.39,31.34)
DDR_B_D8: length 74.8
  IN1 w0.084: v3(53.75,25.44) 53.81,25.5 62.57,25.5 63.28,24.79 86.35,24.79 86.43,24.87 86.43,25.61 86.51,25.7 86.68,25.7 86.77,25.61 86.77,24.87 86.85,24.79 87.02,24.79 87.1,24.87 87.1,25.61 87.19,25.7 87.35,25.7 87.44,25.61 87.44,24.87 87.52,24.79 87.69,24.79 87.77,24.87 87.77,25.61 87.86,25.7 88.11,25.7 88.19,25.61 88.19,25.23 88.28,25.14 88.44,25.14 88.53,25.23 88.53,25.61 88.61,25.7 96.58,25.7 102.77,31.89 112.55,31.89 113.38,32.72 113.38,34.09 v1(114.14,34.85)
  BOTTOM w0.102: v3(53.75,25.44) 53.93,25.25 JDIMM2.21 ; U1.AU4 113.83,37.25 113.83,35.92 113.66,35.75 113.66,35.33 v1(114.14,34.85)
DDR_B_D9: length 74.8
  IN1 w0.084: v1(114.39,32.6) 114.39,32.51 112.91,31.03 103.13,31.03 96.03,23.93 75.08,23.93 74.27,23.12 68.65,23.12 67.84,23.93 62.92,23.93 62.56,24.29 53.37,24.29 v3(52.22,25.44)
  BOTTOM w0.102: U1.AT2 114.69,35.8 114.75,35.75 114.75,34.52 114.55,34.32 114.55,33.85 114.4,33.7 114.21,33.7 113.93,33.42 113.93,33.05 114.38,32.6 v1(114.39,32.6) ; JDIMM2.23 54.1,25.85 54.08,25.87 52.65,25.87 v3(52.22,25.44)
DDR_B_D10: length 72.9
  IN1 w0.084: v3(53.75,28.48) 53.89,28.34 55.03,28.34 55.11,28.42 55.11,29.17 55.21,29.27 55.35,29.27 55.45,29.17 55.45,28.42 55.53,28.34 55.7,28.34 55.79,28.42 55.79,29.17 55.88,29.27 56.02,29.27 56.12,29.17 56.12,28.42 56.2,28.34 62.61,28.34 63.16,27.79 75,27.79 75.57,28.36 96.27,28.36 103.49,35.59 107.72,35.59 108.33,36.2 112.11,36.2 112.88,35.43 v1(112.88,34.23)
  BOTTOM w0.102: v3(53.75,28.48) 54.11,28.85 JDIMM2.33 ; U1.AV4 112.92,37.01 112.92,36.72 113.04,36.6 113.04,36.31 112.96,36.23 112.96,34.31 v1(112.88,34.23)
DDR_B_D11: length 73
  IN1 w0.084: v3(52.22,28.48) 52.67,28.03 56.57,28.03 56.65,27.95 56.65,27.41 56.75,27.31 56.89,27.31 56.99,27.41 56.99,27.95 57.07,28.03 57.24,28.03 57.32,27.95 57.32,27.4 57.42,27.3 57.56,27.3 57.66,27.4 57.66,27.95 57.74,28.03 57.91,28.03 58,27.95 58,27.39 58.09,27.29 58.23,27.29 58.33,27.39 58.33,27.95 58.41,28.03 62.38,28.03 62.98,27.43 95.74,27.43 103.72,35.41 111.32,35.41 v1(111.68,35.05)
  BOTTOM w0.102: v3(52.22,28.48) 53.19,29.45 JDIMM2.35 ; U1.BA4 111.86,37.4 111.86,36.05 111.63,35.83 111.63,35.1 v1(111.68,35.05)
DDR_B_D12: length 74
  IN1 w0.084: v1(114.14,34.2) 113.67,33.72 113.67,32.6 112.67,31.6 102.89,31.6 96.7,25.41 93.12,25.41 93.03,25.33 93.03,24.96 92.95,24.87 92.78,24.87 92.7,24.96 92.7,25.33 92.61,25.41 92.4,25.41 92.32,25.33 92.32,24.58 92.24,24.5 92.07,24.5 91.98,24.58 91.98,25.33 91.9,25.41 91.69,25.41 91.59,25.31 91.59,24.6 91.49,24.5 91.35,24.5 91.25,24.6 91.25,25.31 91.15,25.41 91.02,25.41 90.92,25.31 90.92,24.6 90.82,24.5 90.68,24.5 90.58,24.6 90.58,25.31 90.48,25.41 90.31,25.41 90.21,25.31 90.21,24.58 90.13,24.5 89.96,24.5 89.88,24.58 89.88,25.31 89.78,25.41 89.64,25.41 89.54,25.31 89.54,24.58 89.46,24.5 89.29,24.5 89.21,24.58 89.21,25.31 89.11,25.41 88.97,25.41 88.87,25.31 88.87,24.58 88.79,24.5 88.62,24.5 88.54,24.58 88.54,24.77 88.45,24.85 88.29,24.85 88.2,24.77 88.2,24.58 88.12,24.5 74.84,24.5 74.03,23.69 69.03,23.69 68.22,24.5 63.16,24.5 62.58,25.08 v3(61.12,25.08)
  BOTTOM w0.102: JDIMM2.22 61.39,25.55 61.12,25.29 v3(61.12,25.08) ; v1(114.14,34.2) 114.14,34.27 114.54,34.68 114.54,35.66 114.44,35.76 114.44,36.22 114.14,36.52 U1.AU3
DDR_B_D13: length 74.4
  IN1 w0.084: v3(59.6,25.08) 59.53,25.08 59.4,24.95 59.4,24.72 59.53,24.59 62.67,24.59 63.04,24.21 68.1,24.21 68.91,23.41 74.15,23.41 74.96,24.21 92.61,24.21 92.7,24.3 92.7,24.5 92.78,24.59 92.95,24.59 93.03,24.5 93.03,24.3 93.12,24.21 93.29,24.21 93.37,24.3 93.37,25.03 93.47,25.12 93.61,25.12 93.7,25.03 93.7,24.3 93.79,24.21 93.96,24.21 94.04,24.3 94.04,25.03 94.14,25.12 94.28,25.12 94.37,25.03 94.37,24.3 94.46,24.21 94.63,24.21 94.71,24.3 94.71,25.03 94.81,25.12 95.02,25.12 95.1,25.04 95.1,24.31 95.2,24.21 95.34,24.21 95.44,24.31 95.44,25.04 95.52,25.12 96.82,25.12 103.01,31.32 112.79,31.32 113.95,32.48 113.95,32.82 v1(114.39,33.25)
  BOTTOM w0.102: U1.AR3 115.25,36.58 114.93,36.26 114.93,35.91 115.05,35.79 115.05,34.53 114.85,34.34 114.85,33.72 114.38,33.25 v1(114.39,33.25) ; JDIMM2.24 62.16,26.15 62.02,26.01 60.53,26.01 v3(59.6,25.08)
DDR_B_D14: length 72.5
  IN1 w0.084: v1(111.75,33.58) 111.75,33.35 111.65,33.25 111.41,33.25 111.31,33.35 111.31,33.85 111.21,33.96 111.05,33.96 110.95,33.85 110.95,33.16 110.85,33.06 110.67,33.06 110.59,33.14 110.59,33.86 110.49,33.96 110.35,33.96 110.25,33.86 110.25,33.14 110.17,33.06 109.96,33.06 109.87,33.14 109.87,33.9 109.79,33.98 109.62,33.98 109.54,33.9 109.54,33.14 109.45,33.06 109.29,33.06 109.2,33.14 109.2,33.9 109.12,33.98 108.95,33.98 108.87,33.9 108.87,33.14 108.78,33.06 108.62,33.06 108.53,33.14 108.53,33.9 108.45,33.98 108.28,33.98 108.2,33.9 108.2,33.14 108.11,33.06 107.95,33.06 107.86,33.14 107.86,33.9 107.78,33.98 107.61,33.98 107.53,33.9 107.53,33.14 107.44,33.06 102.18,33.06 95.98,26.86 74.84,26.86 74.67,26.69 64.76,26.69 64.68,26.6 64.68,26.24 64.6,26.16 64.43,26.16 64.34,26.24 64.34,26.6 64.26,26.69 64.09,26.69 64.01,26.6 64.01,26.24 63.93,26.16 63.76,26.16 63.67,26.24 63.67,26.6 63.59,26.69 61.21,26.69 61.12,26.78 v3(61.12,27.11)
  BOTTOM w0.102: v3(61.12,27.11) 61.12,28.39 61.88,29.15 JDIMM2.34 ; v1(111.75,33.58) 112.01,33.58 112.14,33.71 112.14,34.47 112.72,35.05 U1.AY2
DDR_B_D15: length 73.9
  IN1 w0.084: v3(59.6,27.11) 60.14,27.65 62.22,27.65 62.72,27.15 95.86,27.15 102.06,33.34 102.91,33.34 102.99,33.43 102.99,34.16 103.09,34.26 103.23,34.26 103.33,34.16 103.33,33.43 103.41,33.34 103.62,33.34 103.71,33.43 103.71,34.2 103.79,34.28 103.96,34.28 104.04,34.2 104.04,33.43 104.13,33.34 104.29,33.34 104.38,33.43 104.38,34.2 104.46,34.28 104.68,34.28 104.77,34.2 104.77,33.43 104.85,33.34 105.02,33.34 105.1,33.43 105.1,34.2 105.18,34.28 105.35,34.28 105.44,34.2 105.44,33.43 105.52,33.34 105.69,33.34 105.77,33.43 105.77,34.2 105.85,34.28 106.02,34.28 106.11,34.2 106.11,33.43 106.19,33.34 106.36,33.34 106.44,33.43 106.44,34.2 106.53,34.28 106.74,34.28 106.82,34.2 106.82,33.43 106.9,33.34 107.07,33.34 107.16,33.43 107.16,34.2 107.24,34.28 111.53,34.28 v1(111.68,34.42)
  BOTTOM w0.102: U1.BA3 112.16,36.54 112.47,36.24 112.47,35.22 v1(111.68,34.42) ; v3(59.6,27.11) 59.6,27.3 62.05,29.75 JDIMM2.36
DDR_B_D16: length 68.9
  IN1 w0.084: v1(105.98,38.02) 105.98,37.64 104.5,36.16 102.97,36.16 97.88,31.08 88.07,31.08 87.94,30.95 87.94,29.7 87.84,29.6 87.69,29.6 87.58,29.7 87.58,30.98 87.48,31.08 87.34,31.08 87.25,30.98 87.25,29.64 87.16,29.56 86.99,29.56 86.91,29.64 86.91,30.38 86.81,30.48 86.67,30.48 86.58,30.38 86.58,29.64 86.49,29.56 73.1,29.56 72.34,30.32 68.43,30.32 67.33,29.22 57.85,29.22 56.18,30.9 53.87,30.9 v3(53.75,31.02)
  BOTTOM w0.102: v3(53.75,31.02) 53.75,30.9 53.99,30.65 JDIMM2.39 ; v1(105.98,38.02) 106.37,38.41 107.73,38.41 108.62,39.3 109.06,39.3 109.62,39.86 U1.BE9
DDR_B_D17: length 68.8
  IN1 w0.084: v3(52.22,31.02) 52.79,30.45 56.21,30.45 57.75,28.91 62.79,28.91 63.42,28.28 67.88,28.28 68.87,29.27 88.05,29.27 88.18,29.4 88.18,29.55 88.29,29.65 88.43,29.65 88.54,29.55 88.54,29.36 88.63,29.27 96.48,29.27 103.19,35.98 105.22,35.98 107.91,38.66 v1(107.91,39.69)
  BOTTOM w0.102: U1.BD9 110.33,40.16 108.38,40.16 v1(107.91,39.69) ; JDIMM2.41 54.15,31.25 53.95,31.46 52.65,31.46 v3(52.22,31.02)
DDR_B_D18: length 68.1
  IN1 w0.084: v1(104.02,39.69) 104.02,39.45 103.11,38.53 101.66,38.53 96.79,33.67 74.54,33.67 73.66,32.79 66.36,32.79 65.2,31.63 57.89,31.63 57.76,31.76 57.76,33.1 57.6,33.26 57.14,33.26 57.04,33.36 57.04,33.5 57.14,33.6 57.64,33.6 57.74,33.7 57.74,33.84 57.64,33.93 57.25,33.93 57.17,34.02 57.17,34.19 57.25,34.27 57.58,34.27 57.71,34.4 57.71,34.58 57.58,34.71 v3(53.75,34.71)
  BOTTOM w0.102: v3(53.75,34.71) 54.2,34.25 JDIMM2.51 ; U1.BD13 110.13,41.53 109.75,41.53 109.7,41.58 109.37,41.58 109.22,41.43 108.87,41.43 108.63,41.19 105.55,41.19 105.16,40.81 104.7,40.81 104.02,40.14 v1(104.02,39.69)
