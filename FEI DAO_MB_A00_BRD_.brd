# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.05VTTP: length 24.5
  TOP w0.127: v4(113.49,6.78) v1(113.49,8.44)
  TOP w0.254: v1(113.44,13.99) 113.44,15.77 114.71,17.04 126.59,17.04 127.48,16.15 130.05,16.15 130.47,15.73 PC510.1
  vias: v1(112.85,8.46) v1(113,10.25) v1(113.31,10.88) v1(113.63,10.25) v1(113.95,10.88) v1(114.13,8.44) v1(114.27,10.25) v1(114.76,8.44) v1(115.4,8.44)
+1.8V_RUN: length 5.4
  BOTTOM w0.254: v1(157.04,26.36) 157.35,26.04 UH4.AG16 ; v1(157.04,26.36) 157.44,26.76 UH4.AG17 157.06,27.19 v1(157.04,27.19) 156.66,26.81 UH4.AJ17 156.63,26.76 v1(157.04,26.36) ; v1(157.04,26.36) 156.72,26.04 UH4.AJ16
  BOTTOM w0.508: LH8.1 141.22,34.17 CH52.1 141.19,34.41 v1(140.79,34.82)
  vias: v1(103.49,19.21) v1(104.2,19.19) v1(104.88,19.19) v1(107.6,34.68) v1(108.23,34.68) v1(108.87,34.68) v1(150.11,16.87) v1(150.74,16.89) v4(103.04,20.33)
+1.8V_RUN_LVDS: length 2.5
  BOTTOM w0.254: UH4.AP37 154.67,36.59 v1(154.74,36.59) 155.01,36.86 UH4.AM38 ; UH4.AM37 155,35.94 v1(154.74,35.94) 154.3,35.49 UH4.AP36
  vias: v1(144.89,36.38) v2(149.89,36.56)
+1.8V_RUNP: length 22.7
  TOP w0.102: v4(105.36,14.01) v1(105.36,13.27)
  IN1 w0.254: v1(96.25,3.28) 97.48,2.04 104.43,2.04 104.87,2.49 104.87,8.02 105.36,8.52 v1(105.36,13.27)
  BOTTOM w0.254: PC301.1 PR302.1 96.24,3.27 v1(96.25,3.28)
+3.3V_ALW: length 493.4
  TOP w0.254: C709.1 262.95,82.57 262.95,81.32 262.84,81.21 U46.A43 ; v1(291.29,56.04) 291.29,55.98 291.73,55.54 292.1,55.54 292.3,55.35 U51.B3 ; U46.A54 258.29,76.56 258.09,76.36 257.08,76.36 256.98,76.26 256.48,76.26 C710.1 ; U46.A17 270,71.56 270.29,71.27 ; C756.1 221.63,25.56 221.55,25.47 JTP1.11 ; v1(262.08,71.4) 262.09,71.39 U46.B5 ; C726.1 287,65.85 287,65.65 287.26,65.4 U51.A26
  TOP w0.279: 289.04,50.44 289.04,51.78 288.76,52.06 U51.A58 ; v1(281.09,57.79) 281.4,58.1 U51.A41 ; U51.A52 285.76,52.49 285.54,52.27 285.54,50.8 285.53,50.78 285.53,50.53 C731.1 ; U51.A11 294.58,59.6 v1(295.14,60.16) ; C725.1 289.16,66.01 289.16,64.46 289.26,64.36 U51.A22
  TOP w0.305: v1(282.75,62.72) 283.13,62.35 U51.B35
  TOP w0.318: U46.B30 268.41,77.31 268.15,77.56 v1(268.01,77.56)
  TOP w0.381: R820.1 287.77,46.53 288.92,45.38 v1(289.59,45.38)
  TOP w0.406: C778.1 258.11,85.63 258.68,86.2 U58.5 ; PU1302.5 41.07,26.56 40.75,26.88 PC1342.2
  TOP w0.508: v1(42.84,68.82) PR204.1 ; C777.1 272.01,58.46 v1(272.09,58.53) ; v1(261.52,86.09) 263.84,86.09 264.39,85.53 264.39,84.52 264.28,84.4 R769.1 R755.2 ; v1(253.88,80.2) 254.5,80.2 254.57,80.26 R761.1 255.14,80.18 R785.2 ; R768.1 269.54,84.02 v1(269.63,83.93) ; C728.1 295.67,59.62 v1(295.14,60.16) ; R823.2 284.52,67.7 284.32,67.9 v1(284.32,68.08) ; R1125.1 291.93,67.41 v1(291.93,67.76) 292.11,67.76 292.96,68.62 R817.2 ; 260.13,62.9 260.13,64.25 260.52,64.64 260.52,66.86 R763.1 260.47,66.91 C708.1 ; v1(253.84,81.47) 254.54,82.16 R805.1 ; v1(184.77,28.45) 183.49,28.45 v4(182.77,29.17) 182.09,29.85 182.09,31.85 182.99,32.75 182.99,37.04 181.23,38.8 v1(181.23,41.88) ; v1(31.83,11.58) 31.5,11.91 JLID1.4 ; C727.1 295.53,55.18 v1(295.12,54.76) ; R1162.1 215.68,18.25 217.42,19.99 v1(217.42,21.33) ; R418.1 v1(300.17,54.99) ; v1(164,75.54) 165.25,75.54 v4(166.36,76.65) 168.2,78.49 v1(168.95,78.49) ; C732.1 280.36,64.71 C730.1 280.6,65.34 v1(279.98,65.96) ; v1(167.2,47.38) 165.87,46.05 C784.1 ; v1(259.07,84.68) 258.63,84.24 R778.1 R796.1 ; C731.1 284.98,50.49 v1(284.98,50.9) ; C756.1 221.46,26.63 221.11,26.29 v1(221.11,25.84) ; C1249.1 271.32,61.86 270.92,62.25 v1(270.44,62.25) ; R822.1 284.09,49.26 R824.1 v1(283.13,47.95) ; R1729.1 268.41,64.83 268.1,65.14 268.1,65.95 v1(268.03,66.02) R764.2 ; R420.1 R854.1 v1(300.17,56.76) ; C710.1 256.51,76.51 v1(256.9,76.91) 256.9,77.11 256.61,77.4 R774.1 ; C782.1 252.06,18.72 v1(251.03,19.75) ; R760.1 v1(273.41,80.11) R798.1 ; C778.1 258.76,85.24 v1(259.07,85.56) ; PR1351.1 40.26,28.41 v1(40.26,28.4) 40.26,28.38 40.75,27.9 PC1342.2 ; v1(283.14,48.62) R829.1 R828.1 R827.1 ; R814.1 273.02,56.27 v1(275.77,56.27) ; C779.1 v1(286.15,44.16) ; v1(266.98,59.92) 266.98,60.46 R848.1 ; v1(271.2,77.07) 271.52,77.39 C706.1 ; v1(262.44,82.22) 262.31,82.35 262.31,83 C709.1 ; v1(286.01,65.4) 286.14,65.4 286.63,65.9 C726.1 ; v1(262.18,84.67) 262.95,84.67 263.33,84.29 R773.2 ; v1(300.17,58.61) R871.2 R856.1 ; PR112.2 v1(244.04,6.12) ; C780.1 283.79,19.14 v1(284.14,19.49) ; C725.1 289.61,66.21 v1(290.01,66.61) 290.53,67.13 R759.1 ; v1(254.01,74.74) R800.1 ; R875.1 v1(297.54,60.57) R821.2 ; R820.1 R818.1 ; PR6.1 v1(52.69,3.51) ; R1171.1 v1(278.52,62.86) ; R766.1 v1(267.07,66.06) ; v1(290,51.06) 289.67,51.06 289.04,50.44 C729.1 ; v1(41.48,79.09) PR12.2 ; C785.2 v1(229.44,16.99) ; R776.1 v1(259.09,65.69) R1728.1 ; v1(269.73,66.15) 270.39,66.15 C705.1 C707.1 270.78,68.93 270.29,69.43 270.29,71.27 ; v1(281.09,57.79) 280.97,57.79 280.57,57.4 C739.1 ; R872.2 v1(297.38,53.27) ; R849.1 269.23,60.12 v1(270.17,60.12)
  TOP w2.032: 205.2,7.43 205.2,15.54
  IN1 w0.508: v1(43.61,14.77) 44.21,14.17 44.21,10.28 50.98,3.51 v1(52.69,3.51) ; v1(41.48,79.09) 40.72,78.33 40.72,73.24 41.99,71.97 41.99,69.68 42.84,68.83 v1(42.84,68.82)
  IN1 w2.032: 154.31,7.43 155.96,5.77 169.22,5.77 172.2,8.76 ; 178.45,12.37 179.27,12.37 180.65,13.75 191.48,13.75 194.91,10.32
  IN2 w0.508: v1(140.68,23.47) 140.68,20.8 143.35,18.14 144.17,18.14 145.51,16.8 146.14,16.8 149.73,13.22 149.73,12.88 v1(151.51,11.1) ; v1(42.84,68.82) 42.22,68.2 42.22,64.06 41.56,63.4 38.82,63.4 37.01,61.59 37.01,48.38 39.65,45.74 39.65,42.15 38.38,40.88 38.38,34.09 40.16,32.31 40.16,28.5 v1(40.26,28.4) 42.29,26.38 42.29,21.18 42.6,20.86 42.6,15.78 v1(43.61,14.77)
  IN4 w0.508: v1(156.57,70.13) 161.98,75.54 v1(164,75.54) ; v1(92.61,4.7) 91.93,4.02 77.15,4.02 73.96,7.21 60.14,7.21 56.44,3.51 v1(52.69,3.51) ; v1(244.04,6.12) 244.68,6.77 245.66,6.77 247.34,5.09 256.69,5.09 257.88,6.28 260.86,6.28 v1(266.29,11.71)
  IN4 w1.27: 104.34,8.05 104.36,8.02 104.36,4.04 105.82,2.58 110.39,2.58 111.82,4 111.82,8.05 110.61,9.26
  IN4 w2.032: 110.47,11.36 111.51,12.41 114.24,12.41 116.35,14.51 117.76,14.51 ; 150.14,9.23 150.14,7.27 147.21,4.34 141.96,4.34 141.33,4.96 129.67,4.96
  BOTTOM w0.381: U7.5 185.03,28.01 184.77,28.28 v1(184.77,28.45)
  BOTTOM w0.406: C720.1 139.45,24.09 139.1,24.44 138.64,24.44 138.41,24.21 U50.5
  BOTTOM w0.508: RH202.1 172.73,14.61 172.73,11.8 v1(172.29,11.36) ; PR400.1 155.95,69.07 155.95,69.73 156.34,70.13 v1(156.57,70.13) ; v1(140.68,23.47) 140.23,23.92 C720.1 ; v1(131.9,108.7) 131.56,109.03 C783.1 ; R937.1 164.02,73.32 164.02,75.52 v1(164,75.54) ; C288.1 185.35,29.03 v1(184.77,28.45) ; Q58.2 168.04,78.86 168.41,78.49 v1(168.95,78.49) 168.99,78.53 Q58.1 ; Q58.6 168.99,82.6 v1(168.56,83.03) 168.04,82.51 Q58.5 ; v1(31.83,11.58) 33.1,12.85 C1308.1 33.93,11.99 34.51,11.4 41.66,11.4 43.61,13.35 v1(43.61,14.77) ; v1(221.11,25.84) 220.19,24.91 218.22,24.91 215.75,27.38 215.75,32.06 v1(214.93,32.89) ; 236.19,53.11 R713.1 ; v1(169.75,71.26) 169.75,68.64 R932.1
  vias: v1(91.92,5.17) v1(92.61,5.97) v1(92.61,5.33) v1(132.39,102.14) v1(133.04,102.14) v1(133.34,101.58) v1(133.67,102.14) v1(152.15,11.1) v1(152.78,11.1) v1(153.42,11.1) v1(203.38,17.17) v1(203.46,5.7) v1(204.02,17.17) v1(204.2,5.71) v1(204.65,17.17) v1(204.89,5.7) v1(205.29,17.17) v1(205.56,5.7) v1(232.23,48.12) v1(232.21,47.47) v1(232.21,46.82) v1(232.85,47.47) v1(232.85,46.82) v1(232.86,48.12) v1(234.35,46.67) v1(235.54,48.12) v1(235.53,47.47) v1(235.53,46.82) v1(235.64,52.18) v1(236.17,48.12) v1(236.16,47.47) v1(236.16,46.82) v1(236.28,52.18) v1(236.62,48.6) v1(262.42,62.85) v1(263.05,62.85) v1(263.69,62.85) v1(264.32,62.85) v1(266.27,13.62) v1(266.27,12.99) v1(266.29,12.34) v1(266.91,13.62) v1(266.91,12.99) v1(266.92,12.34) v1(266.92,11.71) v1(267.54,13.62) v1(267.54,12.99) v1(267.56,12.34) v1(267.56,11.71) v1(268.18,13.62) v1(268.18,12.99) v1(268.19,12.34) v1(268.19,11.71) v1(268.83,12.34) v1(268.83,11.71) v1(276.33,47.91) v1(276.33,47.25) v1(312.21,42.28) v1(312.21,41.6) v1(312.19,33.31) v1(312.18,32.66) v1(312.82,32.64) v1(312.92,42.29) v1(312.91,41.6) v1(312.87,33.29) v4(203.6,15.25)
+3.3V_ALW2: length 520.3
  TOP w0.254: v1(252.61,7.81) 252.61,8.02 251.96,8.67 PU100.8
  TOP w0.508: v1(175.11,6.61) 175.11,6.89 v1(178.9,10.68) ; PR1341.1 36.86,4.53 41.19,8.86 41.19,12.72 v1(41.97,13.5) v4(55.35,13.5) 67.73,13.5 75.11,6.12 82.23,6.12 83.69,4.66 89.73,4.66 94.93,9.85 94.93,15.67 95.51,16.25 98.33,16.25 98.72,15.86 98.72,10.75 RC74.1
  IN2 w0.508: v1(252.61,7.81) 254.09,9.29 254.09,15.34 251.57,17.87 246.87,17.87 245.7,16.7 242.73,16.7 241.71,15.68 234.02,15.68 233.2,14.87 224.68,14.87 217.33,7.52 211.66,7.52 209.67,5.52 v1(209.09,5.52) 208.53,5.52 207.69,4.68 201.39,4.68 197.68,8.39 193.31,8.39 190.86,5.94 178.86,5.94 178.08,6.72 175.21,6.72 v1(175.11,6.61) 174.06,5.56 173.27,5.56 169.37,9.46 162.82,9.46 162.43,9.07 155.21,9.07 154.04,10.23 150.92,10.23 148.25,12.9 143.13,12.9 142.72,13.32 142.72,13.81 142.15,14.37 137.86,14.37 137.13,15.11 132.72,15.11 130.13,17.7 96.41,17.7 93.49,14.79 85.37,14.79 83.64,13.05 53.78,13.05 51.55,15.29 45.93,15.29 44.14,13.5 v1(41.97,13.5)
  IN3 w0.122: 175.63,48.5 175,48.5 170.77,52.73 170.77,53.37 169.01,55.12 169.01,57.42 168.24,58.19 168.24,62.42 168.13,62.53 168.13,68.88 167.65,69.36 167.65,74.61 166.68,75.57 166.68,79.7 v1(166.01,80.38)
  IN3 w0.508: v1(303.36,44.92) 304.19,44.09 304.19,36.65 300.16,32.63 300.16,5.69 298.34,3.87 271.8,3.87 270.81,2.88 255.99,2.88 252.61,6.26 v1(252.61,7.81) ; v1(178.9,10.68) 178.92,10.68 182.63,14.39 182.63,15.48 181.89,16.22 181.89,17.49 182.75,18.34 182.75,20.72 183.69,21.65 183.69,24.36 183.51,24.53 183.51,29.02 185.06,30.57 185.06,31.72 184.02,32.76 184.02,36.81 183.3,37.53 183.3,42.58 179.2,46.69 179.2,48.1 178.8,48.5 175.63,48.5
  BOTTOM w0.406: v1(178.9,10.68) 178.97,10.75 178.97,11.11 178.83,11.25 UH5.5
  BOTTOM w0.508: v1(166.01,80.38) 166.01,81.11 165.5,81.62 R918.1 ; v1(303.36,44.92) 303.62,45.18 R565.1 ; PC107.1 251.94,6.87 252.15,7.08 PR100.2 252.66,7.76 v1(252.61,7.81) ; R909.1 175.67,4.79 175.11,5.34 v1(175.11,6.61) ; v1(209.09,5.52) 209.09,5.92 208.68,6.32 R907.1
+3.3V_ALW_PCH: length 516.1
  TOP w0.305: CH1.1 122.38,21.48 121.42,20.52 JXDP2.16
  TOP w0.508: RH299.2 RH298.2 171.8,25.9 v1(172.38,25.32) ; 180.59,32.42 RH66.1 180.57,33.46 179.72,33.46 v1(179.63,33.37) ; 180.59,32.42 180.59,31.24 181.32,30.5 181.32,27.75 180.99,27.43 v1(180.53,27.43) ; 180.59,32.42 181.65,32.42 182.31,33.08 182.31,36.64 180,38.95 v1(180,39.49) v4(180,41.09) ; v1(109.44,20.9) 109.81,20.53 RH41.1 ; v1(286.01,48.62) 286.12,48.74 R835.2 ; CC156.1 109.76,80.86 v1(109.76,81.62) ; v1(93.78,85.38) 93.55,85.38 93.14,85.8 RC124.1 ; v1(176.76,25.28) 176.76,24.85 176.34,24.43 RH345.2 ; RH347.2 176.65,23.48 v1(176.73,23.4) ; CH91.1 154.97,30.06 v1(155.39,29.64) ; RH177.2 176.58,22.47 v1(176.75,22.3) 176.76,22.29 RH288.1 ; R928.1 R908.1 200.39,9.29 C760.1 200.37,6.19 202.25,4.32 v1(202.25,2.22) ; v1(122.38,22.44) CH1.1 ; v1(172.12,22.12) 172.12,21.93 171.84,21.65 170.9,21.65 RH53.2 ; RH357.2 163.44,31.8 164.1,31.14 164.1,30 CH70.1 ; v1(176.75,19.63) 176.03,20.35 RH170.2 ; R712.1 260.7,24.5 260.24,24.95 240.43,24.95 v1(239.73,24.25)
  IN1 w0.102: 155.78,28.29 155.78,27.77 155.96,27.59 156.38,27.59 156.39,27.58 156.86,27.58 156.87,27.59 157.2,27.59 157.22,27.58 157.26,27.58 ; 160.67,28.29 160.67,27.67 ; 158.97,30.01 159.02,30.06 159.75,30.06 159.78,30.02 ; 159.07,28.41 159.07,28.7 159.07,28.71 159.07,29.04 159.07,29.05 159.07,29.14 ; 158.25,24.13 158.25,24.75 ; 157.45,29.17 157.44,29.16 157.44,27.65 157.45,27.65 ; 158.25,29.08 158.25,29.01 158.26,29.01 158.26,28.67 158.25,28.66 158.25,28.47 ; 163,27.62 162.43,27.62 ; 160.82,27.59 161.44,27.59
  IN1 w1.016: 199.09,8.04 188.19,8.04 186.6,9.63 183.64,9.63 182.24,11.03 181.21,11.03 179.96,9.79 176.36,9.79
  IN2 w0.508: v1(139.12,20.84) 139.12,21.14 139.9,21.92 139.9,22.59 139.4,23.09 139.4,26.51 140.35,27.45 144.34,27.45 145.18,28.29 ; 109.76,81.33 109.76,81.32 109.35,80.91 108.02,80.91 102.7,86.23 v1(100.5,86.23) 94.63,86.23 v1(93.78,85.38) ; 109.76,81.33 v1(109.76,81.62) ; 109.76,81.33 113.43,77.66 113.43,74.06 108.02,68.65 96.09,68.65 92.96,65.52 92.96,29.94 83.97,20.95 79.39,20.95 73.86,15.42 71.6,15.42 71.23,15.04 71.23,14.52 72.06,13.69 82.42,13.69 84.82,16.09 93,16.09 97.81,20.9 v1(109.44,20.9) ; v1(184.33,23.82) 184.56,23.82 186.05,25.31 188.09,25.31 v1(189.37,26.59)
  IN3 w0.508: v1(239.73,24.25) 239.95,24.47 239.95,37.59 240.96,38.6 v1(240.96,41.27) 240.96,47.57 243.59,50.2 243.59,56.86 v1(244.06,57.33) ; v1(179.63,33.37) 179.05,33.96 177.02,33.96 176.66,34.31 v1(176.66,34.6) ; v1(139.12,20.84) 138.54,20.25 129.84,20.25 128.26,21.83 122.99,21.83 v1(122.38,22.44) 122.38,22.32 121.89,21.83 110.37,21.83 v1(109.44,20.9)
  IN4 w0.508: v1(240.96,41.27) 241.52,40.72 252.8,40.72 256.11,44.02 258.77,44.02 259.81,45.07 268.75,45.07 270.98,47.3 274.79,47.3 275.51,46.58 278.65,46.58 279.2,47.13 279.2,48.27 280.32,49.39 285.25,49.39 v1(286.01,48.62) ; v1(172.12,22.12) 172.12,23.11 172.46,23.45 173.65,23.45 173.71,23.4 v1(176.73,23.4) ; v1(184.33,23.82) 184.33,23.45 183.71,22.83 181.08,22.83 180.79,23.11 v1(180.79,23.45)
  BOTTOM w0.254: v1(164.15,33.45) 163.74,33.86 UH4.P32 ; v1(155.39,29.64) 155,30.02 UH4.AN24
  BOTTOM w0.381: UC2.5 105.72,82.27 105.29,82.69
  BOTTOM w0.508: v1(163.43,13.87) 163.43,14.77 RH201.1 ; v1(180.79,23.45) 180.73,23.39 RH303.1 ; RH300.1 176.63,22.42 v1(176.75,22.3) ; v1(184.33,23.82) 183.99,23.48 RH302.1 ; v1(180,39.49) 180.36,39.13 DH2.2 ; RH341.2 176.85,25.19 v1(176.76,25.28) 176.12,25.28 RH343.2 ; RH94.2 176.76,19.62 v1(176.75,19.63) 176.74,19.62 RH139.1 ; RH94.2 RH152.2 RH170.2 ; RH94.2 RH304.1 ; v1(100.5,86.23) 104.92,86.23 RC18.1 104.67,85.42 104.67,83.32 105.29,82.69 ; RH354.1 171.54,12.64 v1(171.39,12.48) ; RH139.1 RH80.1 RH97.2 RH101.1 RH103.1 176.28,15.68 v1(176.73,15.68) 176.98,15.93 RH98.1 ; RH139.1 RH170.2 ; RH170.2 RH140.1 ; v1(176.66,34.6) 176.66,35.34 176.44,35.56 RH287.1 ; v1(240.96,41.27) 240.96,41.83 240.14,42.66 234.93,42.66 229.86,37.59 216.78,37.59 211.21,32.01 200.16,32.01 194.29,26.15 189.82,26.15 v1(189.37,26.59) R1622.2 ; RH349.2 180.53,25.79 v1(180.53,27.43) ; RH81.2 176.81,10.46 v1(176.6,10.68) ; v1(180.29,20.74) 180.29,21.29 RH144.1 ; v1(244.06,57.33) 243.55,56.82 R692.2 ; 176.06,23.4 RH350.2 RH348.2 RH346.2 RH301.1 176.77,23.36 v1(176.73,23.4) 176.06,23.4
  vias: v1(161.9,29.6) v1(162.68,29.6) v1(162.72,28.93) v1(162.68,11.36) v1(163.43,11.37) v1(175.96,10.68) v1(202.88,2.22) v5(164.06,28.56)
+3.3V_ALW_PCH_JTAG: length 8.5
  TOP w0.102: v2(177.36,15.05) 175.95,15.05 v1(175.8,15.2)
  TOP w0.508: v1(176.66,17.86) 177.73,18.93 RH288.2
  BOTTOM w0.508: RH45.2 175.95,15.05 v1(175.8,15.2) ; RH43.2 169.74,14.79 v1(169.74,13.89) ; v1(176.66,17.86) 176.81,17.71 RH44.2
+3.3V_ALWP: length 78
  TOP w0.254: v1(252.79,3.73) v4(252.79,5.78) 252.1,6.47 252.1,7.93 251.85,8.17 PU100.7
  IN1 w0.254: v1(252.79,3.73) 252.76,3.73 253.59,2.91 270.99,2.91 271.99,3.9 271.99,7.8 269.24,10.55 265.31,10.55 264.33,11.53 263.1,11.53 v1(262.92,11.35) ; v1(252.08,3.72) 253.27,2.52 271.15,2.52 272.37,3.74 272.37,7.96 269.4,10.93 265.47,10.93 264.49,11.91 263.06,11.91 v1(262.92,12.05)
  BOTTOM w0.254: PR101.1 PC120.2 v1(252.08,3.72)
+3.3V_LAN: length 38.7
  TOP w0.102: v1(286.86,74.43) v4(286.86,73.77)
  TOP w0.203: U31.5 286.31,77.89 286.44,77.76 286.44,76.91 R549.1
  TOP w0.406: U15.5 295.1,88.21 C478.1
  TOP w0.508: v1(283.86,88.24) R546.1 ; RH305.1 v1(296.11,67.76) ; v1(286.26,76.03) R549.1 ; RH306.1 v1(294.96,67.76) ; C478.1 v1(295.88,88.21) ; v1(281.67,75.97) 281.83,75.8 R553.1 R554.1 ; R545.1 v1(285.25,88.25)
  IN2 w0.508: 313.89,90.35 313.02,90.35 311.31,88.63 298.96,88.63 298.39,88.06 ; JLOM1.9 316.11,87.4 314.41,89.1 ; 313.54,64.4 316.68,67.54 316.68,68.67 317.61,69.59 JLOM1.12
  vias: v1(279.13,80.17) v1(279.76,80.2) v1(286.87,75.1) v1(287.5,75.12) v1(287.5,74.44) v1(311.71,64.02) v1(312.35,64.02) v1(314.57,91.3) v1(315.24,42.57) v1(315.26,43.21) v1(315.89,43.21) v1(315.89,42.57)
+3.3V_LAN_OUT: length 8.7
  TOP w0.203: U31.15 290.66,80.13 291.38,79.41 v1(291.38,78.97) ; U31.19 v2(291.28,81.73) 291.56,81.73 291.8,81.49 292.89,81.49 C464.1 ; U31.4 v1(285.91,77.57) ; v1(287.51,85.65) U31.29
  TOP w0.508: C464.1 293.02,82.6 v1(292.97,82.65)
+3.3V_M: length 378.9
  IN2 w1.016: 160.32,17.03 160.32,13.75 161.81,12.26 165.93,12.26 167.16,11.02 169.91,11.02 172.65,8.28 177.78,8.28 179.23,6.83 190.42,6.83 193.66,10.08 198.87,10.08 199.48,9.47 v1(206.7,9.47) 207.63,8.53 217.07,8.53 224.3,15.76 232.67,15.76 233.48,16.57 241.34,16.57 242.36,17.59 245.33,17.59 246.56,18.82 271.89,18.82 273.54,17.17 291.78,17.17 v1(293.69,15.25) ; 304.87,45.53 315.7,45.53
  IN3 w0.508: 170.55,54.38 169.74,55.19 169.74,57.81 168.95,58.6 168.95,60.28 169.19,60.52 169.29,60.52 169.25,60.47 169.42,60.47 171.28,58.62 171.28,54.75
  IN3 w1.016: 300.44,67.19 300.44,64.74 301.12,64.06 301.12,57.19 302.43,55.88 302.43,52.8 301.5,51.88 301.5,46.96 301.52,46.95 ; 171.49,52.99 174.12,50.37 179.34,50.37 180.21,49.5 180.21,49.06 ; 166.58,87.83 166.58,82.09 167.79,80.88 167.79,76.17 168.55,75.41 168.55,70.7 169.02,70.23 169.02,62.96 169.25,62.74 169.25,60.52 ; 198.7,25.71 198.7,26.06 199.76,27.12 199.76,36.41 194.21,41.96 ; 198.98,23.45 207.92,23.45 208.21,23.75 ; 208.21,23.75 v1(208.21,17.19) 208.21,14.6 206.02,12.42 206.02,10.23 ; 208.21,23.75 208.21,35.85 207.02,37.04 207.02,40.65 207.73,41.37 209.17,41.37 210.17,40.37 ; 301.81,44.38 303,43.19 303,36.82 296.04,29.86 296.04,15.83 295.46,15.25 v1(293.69,15.25)
  IN4 w1.016: 299.57,69.63 297.59,71.61 281.39,71.61
  BOTTOM w0.254: 161,17.74 161.06,17.74 v1(161.61,18.29) 161.97,18.65 UH4.V1
  BOTTOM w0.508: v1(208.21,17.19) 208,16.98 U53.8 208,14.22 C745.1 ; CH54.1 160.56,17.29 161,17.74 ; v1(166.54,106.29) R385.1 R426.1 ; v1(170.22,97.67) 169.77,97.22 R395.1 ; v1(167.54,87.94) 167.47,87.87 R919.1 167.16,84.68 C768.1 R916.1 166.15,83.44 167.09,82.49 Q58.4 ; R890.1 208.31,26.27 207.73,26.86 200.92,26.86 199.19,25.13 ; R388.1 v1(155.38,108.2) ; R389.1 v1(166.45,102.68)
  vias: v1(167.53,88.61) v1(179.89,47.77) v1(180.52,47.77) v1(192.39,42.02) v1(192.88,41.54) v1(198.04,24.53) v1(198.72,24.53) v1(211.36,40.18) v1(211.8,39.71) v1(281.26,69.78) v1(300.49,69) v1(300.49,68.36) v1(301.55,46.05) v1(301.55,45.4) v1(318.5,46.37) v1(318.5,45.73) v4(189.53,43.89)
+3.3V_M_CHG: length 2.9
  BOTTOM w0.127: R916.2 v4(164.75,85.37)
  BOTTOM w0.508: Q60.1 164.56,83.65 R916.2
+3.3V_PCIE_FLASH: length 9.6
  IN3 w2.032: 243.38,30.34 241.76,31.95 241.76,36.6 242.8,37.64 242.8,38.82
  vias: v1(235.87,44.92) v1(236.57,44.92) v1(242.58,42.1) v1(242.58,41.41) v1(243.22,42.11) v1(243.22,41.41) v1(243.35,28.84) v1(244,28.85) v1(244.65,28.86) v1(245.29,28.88) v1(258.03,29.21) v1(258.67,29.21) v1(258.79,43.1) v1(258.78,42.47) v1(266.25,22.77) v1(266.88,22.77) v4(248.94,43.22)
+3.3V_PCIE_WWAN: length 37.7
  TOP w0.508: C610.1 v1(300.13,42.36) ; v1(287.43,44.15) 287.43,43.34 C611.1 ; R1159.1 R1160.1 284.22,44.04 v1(284.35,44.17) ; v1(276.22,44.35) C612.1 ; v1(252.56,53.35) 254.35,51.56 257.26,51.56 257.93,50.89 266.79,50.89 271.06,46.62 272.27,46.62 274.54,44.35
  IN1 w0.508: v1(256.06,56.22) 256.06,56.04 253.37,53.35 v1(252.56,53.35)
  BOTTOM w0.508: v1(252.56,53.35) 253.42,53.35 253.86,52.91 Q77.2 ; v1(256.06,56.22) 256.24,56.04 R719.2
  vias: v1(275.52,44.35) v1(275.52,43.71) v1(278.54,32.73) v1(279.18,32.73) v1(279.81,32.73) v1(280.45,32.73) v1(287.43,44.79) v1(288.08,44.82) v1(288.07,44.15) v1(300.11,43.02) v1(300.14,41.55) v1(300.69,43.32) v1(300.7,42.66) v1(300.71,41.98) v1(306.91,37.55) v1(306.91,36.92) v1(307.57,37.55) v1(307.57,36.92) v1(308.22,37.55) v1(308.22,36.9) v4(278.71,38.03)
+3.3V_RTC_LDO: length 63.6
  TOP w0.102: v1(308.74,6.17) v4(307.47,6.17)
  TOP w0.508: v1(308.74,6.17) 308.86,6.29 PD4.3
  IN3 w0.508: v1(308.74,6.17) 305.8,3.24 272.06,3.24 271.07,2.25 255.44,2.25 v1(251.72,5.97)
  BOTTOM w0.508: PR100.1 251.92,6.17 v1(251.72,5.97)
+3.3V_RUN: length 569.1
  TOP w0.254: C662.1 237.28,80.27 236.77,79.77 236.77,78.32 237.01,78.08 U44.16 ; CH76.1 161.8,36.51 162.08,36.79 162.08,37.54 RH351.1 ; U44.6 242.01,76.08 243.11,74.98
  TOP w0.508: v1(256.9,78.35) R772.1 ; RH351.1 161.68,37.94 RH352.1 ; v1(297.92,51.6) 298.13,51.39 R841.1 R838.1 ; v1(282.82,21.4) 283.15,21.07 C780.2 ; v1(238.97,24.29) 238.97,26.44 238.47,26.93 C1304.1 237.95,26.88 JFP1.6 ; v1(253.75,19.78) 253.6,19.63 C782.2 ; v1(136.15,72.92) 136.15,70.61 132.49,66.95 RC19.1 ; v1(176.8,36.1) 175.98,35.28 RH329.1 RH165.1 ; v1(244.99,78.06) 244.85,77.92 R743.1 ; v1(236.5,80.76) C662.1 ; v1(314.36,25.6) C1305.1 315.12,24.76 315.48,24.4 JBT1.9 ; v1(294.51,65.41) R799.1 R1197.1 ; RH332.1 170.44,44.36 RH163.1 173.56,44.36 175.19,42.73 177.12,42.73 v1(178.11,41.74) ; R745.1 244.93,76.92 v1(245,76.84) ; v1(181.21,21.23) 181.15,21.29 181.15,22.31 ; v1(106.56,34.68) 104.93,34.68 103.35,36.27 103.35,44.98 v1(103.6,45.23) ; R457.1 258.13,66.13 257.71,65.71 v1(257.16,65.71) ; R1118.1 v1(295.83,55.89) ; R747.1 244.85,75.89 v1(244.98,75.77) ; v1(145.76,50.82) 145.52,50.58 C1246.1 ; RH203.1 181.15,22.31 ; 181.15,22.31 181.86,22.31 RH173.2 181.87,22.3 RH181.2 182.77,22.29 RH158.1 RH263.2 RH35.1 186.38,22.29 RH171.2 186.39,24.6 185.13,25.85 183.25,25.85 v1(182.73,25.33) ; v1(145.57,32.44) 145.37,32.44 CH51.1 ; RH266.2 RH28.1 186.2,20.33 v1(185.6,20.33) ; RH328.1 179.94,36.52 v1(179.51,36.09) 179.24,35.82 RH326.1 ; RH330.1 171.37,38.43 v1(171.42,38.47) ; 243.11,74.98 243.21,74.87 C661.1 v1(243.33,74.11) ; CH76.1 161.09,36.3 161.09,35.44 CH102.1 162.54,35.17 v1(162.68,35.31) ; v1(176.74,37.44) 176.74,37.44 175.52,36.22 RH269.1 173.81,35.53 RH178.1 ; v1(189.07,19.28) 189.53,18.82 C763.2 ; v1(174.58,28.46) 174.95,28.09 RH365.2 ; C1247.1 287.03,24.64 286.75,24.91 v1(286.37,24.91) ; v1(312.51,20.63) R1710.1 R1708.1 ; CH75.1 161.94,34.48 v1(161.91,34.51) ; v1(82.17,5) 83.23,3.95 93.72,3.95 94.75,4.98 PR300.1 ; R547.1 281.55,76.64 R777.1 280.74,77.31 v1(280.71,77.34) ; v1(278.67,79.55) R780.1 R782.1 ; JSC1.7 v1(84.82,10.15) ; R1081.1 R1082.1 262.31,66.32 262.37,66.25 v1(262.37,65.48) ; R888.1 292.07,69.82 291.67,70.22 v1(291.67,70.44) ; v1(286.14,39.63) 286.15,39.65 C779.2 ; v1(164.79,44.92) 164.93,45.06 C784.2 ; v1(270.2,57.06) 270.68,57.54 C777.2 ; L44.1 v1(274.36,19.81) ; v1(282.39,45.28) 282.19,45.08 R694.1 ; v1(264.32,22.82) 263.96,23.17 R711.1 ; v1(132.9,16.11) 133.62,15.39 133.62,12.89 131.93,11.2 131.93,9.2 131.39,8.66 PR500.2 ; v1(245,78.88) 244.93,78.81 R1594.1 ; R1169.1 v1(300.17,54.1) ; v1(148.86,62.86) 149.19,62.53 R1743.1 ; v1(254.11,73.4) R771.2
  TOP w1.016: 159.17,85.02 159.17,89.44 153.22,95.4 153.22,99.78 150.54,102.46 150.54,104.94 151.77,106.17 ; 153.49,107.73 154.92,109.17 162.87,109.17 ; 201.86,18.02 202.25,18.41 206.13,18.41 206.95,17.59 206.95,10.91
  IN1 w0.508: v1(83.33,13.7) 82.17,12.54 v1(82.17,5) ; v1(155.69,35.89) 155.14,35.33 153.87,35.33 152.85,36.34 146.6,36.34 145.57,35.32 v1(145.57,32.44) ; v1(145.76,50.82) 145.9,50.96 145.9,53.06 145.7,53.26 v1(145.7,53.76) ; v1(165.99,13.87) 165.99,14.68 165.66,15.01 v1(165.66,16.38)
  IN1 w1.016: 74.26,99.15 72.36,99.15 69.68,96.47 69.68,93.72 72.08,91.32 72.12,91.32
  IN2 w0.508: v1(172.4,47.3) 172.4,45.6 175.27,42.73 177.12,42.73 v1(178.11,41.74) ; v1(294.51,65.41) 294.19,65.73 294.19,68.44 292.91,69.72 292.14,69.72 291.67,70.19 v1(291.67,70.44) ; 143.55,13.91 v1(143.55,13.74) ; 143.55,13.91 143.55,14.03 142.57,15.01 138.73,15.01 137.51,16.23 135.61,16.23 135.03,16.8 134.09,16.8 133.4,16.11 v1(132.9,16.11) 130.56,18.45 110.55,18.45 ; 143.55,13.91 144.06,14.42 144.7,14.42 145.01,14.11 146.98,14.11 v1(147.55,13.54) ; 110.55,18.45 110.61,18.51 110.61,23.33 111.68,24.39 111.68,27.56 106.2,33.03 106.2,34.33 v1(106.56,34.68) ; 110.55,18.45 96.26,18.45 93.26,15.45 85.08,15.45 v1(83.33,13.7)
  IN2 w1.016: 52.71,80.81 52.13,80.81 51.63,80.81 50.82,81.62 40.96,81.62 34.3,74.95 34.3,65.41 34.64,65.07 34.64,61.82 34.35,61.53 34.35,60.33
  IN3 w1.016: 251.57,73.6 251.15,73.18 251.15,69.91 247.07,65.83 247.07,60.01 248.49,58.59 248.49,56.18 ; 274.56,67.78 274.56,71.15 ; 274.55,64.5 274.55,53.4 274.54,53.39
  IN4 w0.508: v1(155.69,35.89) 156.41,35.17 161.25,35.17 v1(161.91,34.51)
  IN4 w1.016: 38.69,45.96 41.36,48.63 43.06,48.63 45.15,50.72 45.15,58.01 44.11,59.05 41.9,59.05 40.82,60.13 39.15,60.13 ; 305.95,25.79 305.97,25.81 305.97,35.49 304.56,36.89 304.56,53.34 302.08,55.83 300.69,55.83
  BOTTOM w0.254: v1(155.69,35.89) 156.09,35.49 UH4.AK36 ; UH4.AJ2 156.73,18.35 v1(156.8,18.28) ; v1(106.86,108.03) 106.86,108.29 107.1,108.53 JLVDS1.9 ; UH4.W16 v1(161.1,26.45) UH4.AA16 ; UC1.5 139.17,71.32 139.35,71.14 139.35,70.94 139.11,70.7 CC140.1 ; UH4.BH29 v1(145.57,32.44)
  BOTTOM w0.381: RH363.1 QH5.2 ; Q120.2 97.35,88.3 97.72,87.93 v1(98.71,87.93) ; Q120.5 97.35,91.17 v1(97.52,91.34)
  BOTTOM w0.406: QH6.2 178.49,36.19 v1(178.6,36.09)
  BOTTOM w0.432: UH3.5 181.33,15.96 181.27,15.89 v1(181.27,15.25)
  BOTTOM w0.508: v1(182.73,25.33) RH364.1 181.92,25.19 QH5.5 ; v1(238.17,74.37) 237.89,74.09 R1595.1 ; v1(282.72,30.24) 282.82,30.34 R695.1 ; Q121.2 83.16,93.5 83.42,93.24 R1168.2 83.93,93.79 v1(83.69,94.03) ; R402.1 166.55,100.9 167.56,101.9 167.56,107.44 166.01,108.99 v1(164.53,108.99) ; v1(152.56,80.79) 152.19,80.43 PR728.1 ; v1(70.95,96.35) 70.3,97 C787.1 ; v1(176.74,37.44) 176.66,37.35 RH325.1 RH324.1 ; v1(165.99,13.87) 166.3,14.17 RH268.1 165.38,14.82 RH137.1 ; RH256.1 176.47,36.43 v1(176.8,36.1) ; v1(176.64,38.82) 176.21,39.25 RH327.1 RH215.1 ; RH267.2 147.55,14.13 v1(147.55,13.54) 147.55,13.24 148.32,12.48 154.82,12.48 155.97,13.64 155.97,15.29 156.43,15.75 CH72.1 156.8,15.89 v1(156.8,18.28) ; RH166.1 164.39,14.78 v1(164.39,13.87) ; RH164.2 172.78,46.62 RH331.1 172.78,46.92 v1(172.4,47.3) ; C243.1 134.36,104.69 132.84,106.21 C1331.1 132.85,106.62 C301.1 132.71,107.71 131.35,107.71 v1(130.33,108.72) ; RH316.1 178.49,39.8 QH6.5 v1(178.49,38.12) ; v1(245.39,54.45) R701.2 ; v1(103.6,45.23) 103.6,46.38 104.23,47.01 RC141.2 ; v1(129.62,108.72) 129.62,109 130.04,109.42 C783.2 ; RH355.1 178.88,35.38 178.6,35.67 v1(178.6,36.09) ; DH3.2 184.23,32.02 184.23,31.18 v1(184.24,31.16) ; C776.2 70.68,93.72 v1(70.68,94.04) ; R159.1 R160.1 105.35,89.34 v1(105.06,89.05) ; v1(178.11,41.74) 179.44,41.74 180.07,42.36 CH43.1 180.06,43.04 LH1.1 ; v1(141.12,70.32) CC140.1 ; v1(181.21,21.23) 181.42,21.45 RH363.1 ; R699.2 v1(248.84,54.42) ; v1(84.82,10.15) 84.55,10.42 C1279.1 83.75,12.27 83.33,12.68 v1(83.33,13.7) ; v1(143.55,13.74) PR79.1 ; v1(179.51,36.09) 179.54,36.05 RH317.1
  BOTTOM w1.016: 73.42,90.19 72.54,89.3 68.26,89.3 66.3,87.35 66.3,86.83
  vias: v1(33.69,59.32) v1(34.32,59.32) v1(38.89,44.88) v1(38.91,44.23) v1(42.07,38.91) v1(42.07,38.28) v1(53.7,81.14) v1(53.71,80.46) v1(60.53,86.15) v1(61.17,86.15) v1(66.15,83.98) v1(66.78,83.98) v1(74.11,91.13) v1(74.17,100.42) v1(74.81,100.43) v1(74.81,91.13) v1(152.71,106.31) v1(153.15,106.8) v1(158.27,84.54) v1(158.27,83.91) v1(159.72,23.07) v1(159.7,20.39) v1(161.6,13.88) v1(162.62,13.88) v1(200.9,17.17) v1(201.53,17.17) v1(228.16,42.25) v1(228.16,41.62) v1(228.82,42.25) v1(228.82,41.62) v1(228.89,43.69) v1(228.89,43.06) v1(229.55,43.69) v1(229.55,43.06) v1(252.01,75.04) v1(252.01,74.41) v1(251.99,46.33) v1(252.62,46.33) v1(273.42,74.54) v1(273.49,72.45) v1(273.49,71.56) v1(274.51,66.7) v1(274.51,66.07) v1(274.59,52.46) v1(274.59,51.74) v1(279.28,24.1) v1(279.94,24.1) v1(280.61,24.1) v1(281.25,24.1) v1(286.37,24.28) v1(286.37,23.64) v1(287.03,23.66) v1(289.53,6.75) v1(289.54,6) v1(290.34,6.77) v1(290.31,6) v4(230.6,41.49)
+3.3V_RUN_CARD:
  vias: v1(281.92,10.11) v1(281.92,9.47) v1(282.58,10.11) v1(282.59,9.47) v1(293.81,17.23) v1(293.82,16.55) v1(294.44,17.43) v1(295.1,17.43) v4(293.72,18.03)
+3.3V_RUN_CHG: length 3.2
  BOTTOM w0.127: R929.2 v2(223.93,46.12)
  BOTTOM w0.508: R929.2 225.14,46.82 224.57,47.39 Q69.1
+3.3V_RUN_DVDD: length 3.7
  TOP w0.254: v1(37.11,34.59) 37.08,34.59 v2(36.36,35.31) 36.01,35.66 U72.3
  TOP w0.508: C994.1 37.69,34.59 v1(37.11,34.59)
  vias: v1(39.03,39.35) v1(39.67,39.35) v1(40.15,38.9)
+3.3V_RUN_TPM: length 19.5
  BOTTOM w0.381: v1(258.79,53.41) 259.38,52.83 U37.10 U39.10 ; U39.24 U37.24 268.63,49.58 269.11,49.11 C550.1 ; U39.19 U37.19 268.6,52.83 269.11,53.34 C551.1 271.29,53.34 C552.1 272.05,53.35 272.06,53.36
  BOTTOM w0.508: v1(272.5,55.2) 272.5,53.79 272.06,53.36 ; R658.1 R656.2 v1(256.24,50.82) ; R1663.1 272.09,47.84 v1(273.04,48.79) ; v1(270.92,49.74) 270.67,49.74 270.4,49.48 C550.1 ; C553.1 258.72,53.49 v1(258.79,53.41)
  vias: v1(255.05,48.75) v1(255.02,48.02) v2(270.85,53.32)
+3.3V_RUN_VCC_CLKF33: length 3.4
  TOP w0.508: v1(163.68,36.61) 163.43,36.87 CH74.1
  BOTTOM w0.254: v1(163.68,36.61) 163.43,36.86 UH4.T38
  BOTTOM w0.508: v1(173.91,39.96) 174.25,40.31 RH215.2 ; v3(173.85,41.28) 174.13,41.56 CH73.1
+3.3V_SB3V: length 1.3
  BOTTOM w0.127: R873.2 255.4,49.88 v2(255.12,49.6)
+3.3V_TP: length 35
  TOP w0.254: 218.55,23.75 JTP1.5 218.55,25.22 218.49,25.28 v1(218.49,25.84)
  TOP w0.508: 218.55,23.75 216.65,21.85 216.65,20.41 214.28,18.03 214.28,14.31 ; 214.06,6.82 211.91,6.82 211.78,6.94 v4(211.21,6.94) R1161.2 ; R902.1 v1(223.23,33.28) ; R903.1 v1(225.01,33.28)
  BOTTOM w0.508: v1(225.01,33.28) 225.01,33.64 224.53,34.12 223.7,34.12 223.23,33.65 v1(223.23,33.28) 223.23,32.08 218.49,27.33 v1(218.49,25.84)
+3.3V_WLAN: length 27.9
  IN4 w1.524: 254.76,67.38 255.28,66.86 264.87,66.86 264.89,66.88 ; 252.24,67.38 251.62,66.76 241.66,66.76
  BOTTOM w0.381: Q124.2 236.5,65.81 R718.2 236.64,66 v1(237.53,66.89) ; v1(236.36,61.13) R705.2 236.5,62.09 Q124.5
  BOTTOM w0.508: v1(269.73,65.45) 269.93,65.45 270.74,66.27 C605.1 C607.2
  vias: v1(237.62,64.36) v1(237.65,63.7) v1(238.21,64.74) v1(238.23,64.01) v1(238.23,63.33) v1(240.5,53.18) v1(240.48,52.05) v1(240.85,52.58) v1(241.19,53.18) v1(241.24,52.05) v1(241.48,68.01) v1(241.85,68.54) v1(242.5,68.42) v1(245.27,52.71) v1(245.79,53.12) v1(246.26,57.32) v1(246.36,52.73) v1(246.89,57.32) v1(247.54,57.31) v1(253.46,69.38) v1(253.46,68.62) v1(254.04,69.1) v1(265.66,65.29) v1(265.66,64.6) v1(266.31,64.59) v4(238.26,57.83)
+3.3VDDH:
  vias: v1(283.13,10.97) v1(283.62,10.5) v1(284.13,9.98) v1(285.45,7.03) v1(285.72,7.65) v1(286.08,7.03) v2(286.62,6.03)
+5V_ALW: length 285.9
  TOP w0.254: PU1300.11 33.69,23.05 33.41,23.33 v1(33.41,23.5) ; 122.46,11.9 122.14,12.21 122.01,12.21
  TOP w0.279: 122.46,11.9 122.72,11.64 PU500.7
  TOP w0.508: v1(120.85,13.21) 120.18,13.21 119.98,13.01 PC505.1 122.01,12.21 ; v1(165.13,67.23) 165.13,68.23 158.1,75.27 v1(156.7,75.27) ; v1(227.42,14.23) 228.42,15.22 C785.1 ; PC405.1 157.13,63.33 v1(157.54,62.93) ; v1(52.95,10.34) 52.6,10.69 C775.1 ; v1(189.24,15.9) 189.53,16.19 C763.1 ; v1(37.43,76.22) PR15.1 ; C302.1 108.86,106.74 v1(108.99,106.87) ; 148.71,104.29 148.28,103.86 v4(148.28,102.28) 148.28,98.42 149.27,97.43 v4(149.27,95.83) 149.27,95.04 153.05,91.26 154.91,91.26 156.88,89.29 156.88,83.78 159.06,81.6 159.06,77.99 157.63,76.55 ; v1(190.75,12.28) 190.29,12.74 C774.1 ; v1(41.03,70.57) 41.8,70.57 42.07,70.3 PR202.1
  IN1 w1.016: 107.37,105.93 95.67,105.93 88.75,99.01 88.75,90.33 87.33,88.91 67.91,88.91 67.05,88.05 39.57,88.05 38.94,87.42 38.94,72.73 40.11,71.56 ; 41.04,69.12 41.04,67.94 41.26,67.73 41.26,61.81
  IN2 w0.508: v1(142.27,79.27) 142.69,78.85 148.16,78.85 151.11,75.91 v1(156.7,75.91)
  IN2 w1.016: 148.19,104.67 137.42,104.67 134.3,107.79 117.53,107.79 116.59,108.74 109.61,108.74 109.23,108.35 109.23,107.74
  IN4 w0.508: v1(30.42,6.21) 30.42,7.52 29.2,8.73 27.09,8.73 23.59,12.24 20.25,12.24 19.82,11.81 18.88,11.81 18.13,11.06 18.13,7.9 v1(17.81,7.58) ; v1(157.54,62.93) 157.54,63.59 158.65,64.7 159.85,64.7
  BOTTOM w0.254: PU7.18 145.56,11.35 146.26,12.05 PR82.2 146.26,13.79 PC75.2 ; PU400.7 157.44,63.02 v1(157.54,62.93) ; C715.1 303.95,61.12 304.12,61.29 U2.5 ; 109,107.55 109,108.02 108.6,108.42 JLVDS1.6
  BOTTOM w0.508: R1614.2 305.99,59.31 v1(305.43,58.75) ; PR714.2 144.2,78.75 144.02,78.57 PR720.1 PR717.2 v1(142.27,79.27) ; R816.2 308.7,65.95 v1(307.1,65.95) ; v1(37.43,76.22) 37.43,72.23 39.91,69.76 v1(39.91,69.11) ; v1(17.81,7.58) 18.27,8.04 PR1334.2 18.45,8.98 18.21,9.21 17.47,9.21 17.11,8.85 PU1304.8 ; v1(30.42,6.21) PC1316.1 PC1337.1 PC1336.1 32.33,6.88 v1(33.48,8.04) ; C715.1 303.95,60.08 v1(303.51,59.64) ; PC75.2 146.56,13.99 146.91,13.65 146.91,12.75 147.35,12.3 147.35,11.74 v1(147.74,11.35)
  vias: v1(19.84,41.72) v1(19.84,41.08) v1(20.48,41.72) v1(20.48,41.08) v1(42.23,61.49) v1(42.23,60.86) v1(109.62,106.91) v1(148.38,105.6) v1(149.01,105.6) v1(165.14,66.6) v1(165.6,61.17) v1(165.61,60.54) v1(193.22,16.42) v1(193.55,17.02) v1(193.57,15.82) v1(193.86,16.42) v1(194.19,17.02) v1(194.2,15.82) v1(194.49,16.42) v1(194.82,17.02) v1(194.84,15.82) v1(195.13,16.42) v1(195.46,17.02) v1(195.47,15.82) v1(218.46,3.9) v1(218.46,3.27) v1(219.09,5.22) v1(219.09,4.58) v1(219.09,3.9) v1(219.09,3.27) v1(219.73,5.22) v1(219.73,4.58) v1(219.73,3.9) v1(219.73,3.27) v1(239.35,4.9) v1(239.35,4.26) v1(239.98,4.9) v1(239.98,4.26) v1(240.63,4.91) v1(240.63,4.28) v1(241.27,4.91) v1(241.27,4.28) v1(258.34,4.33) v1(258.34,3.69) v1(258.97,4.33) v1(258.97,3.69) v1(259.62,4.34) v1(259.62,3.71) v1(260.25,4.34) v1(260.25,3.71) v1(302.47,8.39) v1(302.47,7.76) v1(302.75,51.22) v1(302.75,50.58) v1(302.76,49.92) v1(302.76,49.29) v1(302.97,51.85) v1(303.1,8.39) v1(303.1,7.76) v1(303.41,51.22) v1(303.41,50.58) v1(303.42,49.92) v1(303.63,51.85) v1(303.75,8.4) v1(303.75,7.77) v1(304.39,8.4) v1(304.39,7.77) v4(19.2,41.26)
+5V_ALW2: length 6.6
  TOP w0.127: v4(245.59,12.74) PR114.2
  TOP w0.254: 248.25,12.41 248.32,12.41 248.77,11.95 PU100.17
  TOP w0.508: 248.25,12.41 247.11,13.55 PC114.1 PR114.2
+5V_ALW_PCH:
  vias: v1(190.78,34.24) v1(191.22,33.75) v1(191.38,24.84) v1(191.49,22.49) v4(191.66,24.1)
+5V_ALWP: length 47.1
  TOP w0.254: PU100.24 247.17,8.17 246.73,7.73 246.73,6.5 v4(246.39,6.16) 246.39,6.14 v1(245.84,5.6)
  IN4 w0.254: v1(226.65,3.91) 226.78,3.78 230.03,3.78 230.49,3.32 244.71,3.32 245.84,4.45 v1(245.84,5.6) ; v1(246.64,4.38) 245.06,2.8 230.38,2.8 229.85,3.34 226.74,3.34 v1(226.66,3.26)
  BOTTOM w0.254: PC121.1 PR102.2 v1(246.64,4.38)
+5V_HDMI_DDC: length 48.7
  TOP w0.508: v1(85.64,91.26) 83.7,89.32 83.7,67.54 85.24,66 88.7,66 88.71,65.99 D65.1 90.59,65.41 R1163.2 ; v1(96.07,88.66) v4(96.07,90.52) v1(96.07,91.35)
  BOTTOM w0.508: v1(96.07,88.66) 96.03,88.62 R1152.2 94.68,88.62 94.65,88.66 91.28,88.66 88.04,91.89 86.28,91.89 v1(85.64,91.26) ; R1153.2 95.29,91.35 v1(96.07,91.35)
+5V_RUN: length 456.7
  TOP w0.254: v1(222.15,25.85) 222.05,25.75 JTP1.12
  TOP w0.305: 145.68,54.43 145.42,54.43 145.2,54.65 JCAP2.1
  TOP w0.508: 145.68,54.43 146.66,54.43 v1(146.94,54.15) C1317.1 ; C774.2 187.08,12.74 v1(186.68,12.34) ; C786.1 44,73.02 v1(45.46,74.48) ; C775.2 51.92,11.61 v1(51.29,12.24) ; R846.1 277.58,58.81 277.94,59.18 R851.1 R845.1 R852.1 v1(278.52,60.96) ; v1(85.21,94.42) 85.21,92.15 83.01,89.95 83.01,67.19 84.84,65.36 88.44,65.36 D65.2 90.6,63.79 R1163.1 ; C758.1 v1(223.86,25.85)
  TOP w0.762: 169.16,103.78 169.16,106.18 167.86,107.48 v4(165.08,107.48) 161.96,107.48 161.77,107.67 160.39,107.67 160.11,107.39 155.43,107.39 v1(153.7,105.66)
  TOP w1.143: 169.16,101.71 168.46,101.71 168,101.25 168,99.9 166.46,98.36 166.46,82.76 169.93,79.3 169.93,77.45 171.42,75.97 171.42,71.24 172.56,70.1 172.56,67.59 170.99,66.01 ; 169.04,64.07 169.04,61.97 168.36,61.29 168.36,58.39 169.68,57.07 169.68,51.85 173.25,48.28 174.55,48.28 179.7,43.14 181.54,43.14 182.31,42.36 182.31,39.38 184,37.69 184,32.29
  IN1 w0.508: v1(190.51,11.38) 190.13,11.76 v1(187.01,11.76)
  IN2 w1.016: 25.2,53.85 25.2,54.8 24.1,55.9 20.14,55.9 18.28,57.76 18.28,58.84 16.26,60.86 14.15,60.86 13.25,61.76 11.94,61.76
  IN3 w0.508: v1(235.62,51.53) 232.43,51.53 231.32,50.43 231.32,46.09 232.23,45.17 232.23,40.24 228.02,36.03 228.02,30.02 v1(223.86,25.85) ; 157.35,90.89 157.35,96.59 158.46,97.71 158.46,99.98 154.29,104.16 154.29,105.08 v1(153.7,105.66) ; 157.35,90.89 157.35,71.48 159.56,69.27 159.56,61.64 158.96,61.05 152.98,61.05 150.78,58.85 150.78,52.75 149.45,51.42 147.63,51.42 146.94,52.11 v1(146.94,54.15) ; 157.35,90.89 157.23,91.01 v1(149.78,91.01) 147.11,91.01 v1(145.62,92.49) ; v1(190.51,11.38) 190.61,11.48 191.9,11.48 192.84,10.54 202.21,10.54 204.21,8.54 209.67,8.54 213.94,12.81 214.76,12.81 222.15,20.2 v1(222.15,25.85)
  IN3 w2.032: 41.2,30.49 38.11,30.49 35.74,28.13 30.65,28.13 28.63,26.11 26.07,26.11 23.28,28.89 21.24,28.89
  IN4 w0.508: v1(222.15,25.85) 222.15,25.47 222.42,25.21 223.56,25.21 223.86,25.5 v1(223.86,25.85) ; v1(278.52,60.96) 278.28,61.2 273.84,61.2 270.36,57.72 269.64,57.72 267.81,55.89 257.28,55.89 256.18,54.79 251.45,54.79 248.72,52.05 243.43,52.05 242.73,51.36 235.79,51.36 v1(235.62,51.53)
  BOTTOM w0.508: v1(187.06,21.55) 186.73,21.55 186.31,21.13 R923.1 ; QH7.2 181.57,32.11 RH213.1 182.36,31.66 v1(182.86,31.17) ; v1(70.77,91.36) 71.43,92.02 C776.1 ; v1(86.68,12.84) 87.25,12.27 C1278.1 ; v1(278.52,60.96) 278.52,59.5 277.09,58.07 v1(277.09,49.76) ; PR713.1 144.54,93.57 v1(145.62,92.49) ; PR732.1 v1(149.78,91.01) ; C219.1 167.23,99.6 167.73,100.11 D2.1 167.73,101.18 168.95,102.4 v1(169.16,102.4)
  BOTTOM w1.016: 27.48,52.56 29.66,50.38 44.91,50.38 45.99,51.46
  vias: v1(11.04,62.06) v1(11.05,61.43) v1(19.2,27.84) v1(19.2,27.2) v1(19.92,27.84) v1(19.92,27.2) v1(25.13,52.69) v1(25.76,52.69) v1(44.29,33.61) v1(44.29,32.98) v1(44.25,32.33) v1(44.25,31.7) v1(47.31,51.91) v1(47.31,51.27) v1(74.92,87.39) v1(75.61,87.37) v1(84.56,94.42) v1(85.98,12.84) v1(86.34,13.38) v1(162.2,95.35) v1(162.22,94.7) v1(169.16,103.1) v1(183.62,11.17) v1(183.83,11.8) v1(184.26,11.15) v1(184.46,11.77) v1(184.9,11.14) v1(185.11,11.76) v1(185.54,11.14) v1(185.74,11.76) v1(186.17,11.14) v1(186.38,11.76) v1(186.81,11.14) v1(187.46,21.04)
+5V_RUN_CHG: length 2.5
  BOTTOM w0.127: R923.2 v2(184.83,22.04)
  BOTTOM w0.508: Q67.1 R923.2
+5V_USB_CHG_PWR: length 1.7
  TOP w0.102: JUSB1.1 v4(314.95,54.4)
+5V_USB_PWR:
  vias: v1(17.79,52.87) v1(17.8,52.19) v1(18.42,52.87) v1(18.43,52.19) v4(19.42,51.52)
+DVDD_CORE:
  vias: v2(36.35,33.46)
+V1.05S_VCCPP_B+:
  vias: v4(126.42,6.21)
+V1.05SP_B+:
  vias: v2(154.62,67.7)
+VCC_4022: length 5.2
  TOP w0.508: v1(153.03,104.97) 153.14,104.86 v2(153.76,104.86) 154.03,104.86 155.72,106.55 v1(156.59,106.55)
  BOTTOM w0.508: R393.2 153.42,104.58 v1(153.03,104.97)
+VCC_CORE: length 18.7
  TOP w0.508: 138.02,63.65 138.02,64.51 142.31,68.81 142.31,71.9 141.61,72.6 v4(141.61,74.39) 140.75,75.26 RC120.1 ; v1(144.76,51.78) 145.06,51.47 RC66.1
  vias: v1(124.76,55.45) v1(124.77,53.78) v1(124.78,51.93) v1(124.8,50.12) v1(124.78,48.46) v1(132.36,52.42) v1(132.36,47.1) v1(134.97,53.55) v1(134.97,52.54) v1(135.01,50) v1(135.01,49.04) v1(134.97,48.03) v1(134.96,47.04) v1(136.24,57.68) v1(136.24,56.54) v1(136.24,53.55) v1(136.24,52.54) v1(136.24,50) v1(136.24,49.04) v1(138.65,57.68) v1(138.65,56.54) v1(138.65,53.62) v1(138.65,52.66) v1(138.65,50.06) v1(138.65,49.11) v1(139.98,61.81) v1(140.62,61.81) v1(141.01,53.83) v1(140.99,53.05) v1(141.14,49.17) v1(141.14,48.54) v1(141.14,47.9) v1(141.29,61.81) v1(141.65,53.55) v1(141.65,52.89) v1(141.66,59.87) v1(141.66,59.22) v1(141.67,58.54) v1(141.67,57.87) v1(141.83,50.89) v1(141.93,61.81) v1(141.89,52.16) v1(142.52,50.89) v1(142.59,52.16) v1(143.22,50.89) v1(143.29,52.16) v1(143.93,52.14) v1(143.92,50.89) v1(144.85,59.8) v1(144.86,59.09) v5(126.38,55.48) v5(126.4,53.77) v5(126.42,51.97) v5(126.4,50.23) v5(126.4,48.38) v5(127.94,55.49) v5(128.2,54.52) v5(128.2,53.71) v5(128.2,52.89) v5(128.2,51.45) v5(128.2,50.01) v5(128.2,49.2) v5(128.2,48.35) v5(128.19,47.33) v5(128.85,51.45) v5(129.52,55.38) v5(129.5,53.71) v5(129.5,51.45) v5(129.5,49.2) v5(129.55,47.36) v5(130.85,53.98) v5(130.85,53.14) v5(130.85,51.4) v5(130.85,50.55) v5(130.85,48.81) v5(132.37,53.9) v5(132.36,50.8) v5(132.37,49.98) v5(135.03,56.52) v5(135.06,57.67)
+VCC_GFXCORE: length 44
  TOP w0.508: v1(135.45,71.2) 130.15,71.2 129.22,72.13 124.53,72.13 124.53,72.14 ; RC99.1 150.22,62.2 v1(150.07,62.35) ; v1(136.99,76.21) 137.02,76.17 RC122.1
  IN1 w0.508: v1(150.07,62.35) 149.79,62.35 149.36,61.92 144.44,61.92 143.82,62.54 136.49,62.54 134.47,64.56 134.47,70.22 v1(135.45,71.2)
  IN3 w0.508: v1(135.45,71.2) 136.47,71.2 136.99,71.72 v1(136.99,76.21)
  vias: v1(117.08,76.48) v1(117.53,76.03) v1(118,75.58) v1(118.1,85.38) v1(118.14,84.74) v1(118.47,75.15) v1(118.83,84.93) v1(118.95,77.46) v1(118.87,74.66) v1(119.38,76.99) v1(119.36,74.25) v1(119.53,84.93) v1(119.84,73.8) v1(119.85,76.52) v1(120.2,84.9) v1(120.33,76.06) v1(120.47,73.21) v1(120.55,84.27) v1(120.83,75.66) v1(120.92,84.92) v1(120.88,77.61) v1(121.11,72.57) v1(121.13,69.3) v1(121.11,67.7) v1(121.3,84.31) v1(121.7,87.06) v1(121.7,86.36) v1(121.7,85.66) v1(121.7,84.96) v1(121.7,74.71) v1(121.89,76.96) v1(122.09,76.12) v1(122.15,74.23) v1(122.29,67.99) v1(122.29,67.15) v1(122.48,77.66) v1(122.81,75.38) v1(122.89,76.27) v1(123.11,68.49) v1(123.61,75.64) v1(123.55,74.75) v1(123.61,67.8) v1(123.75,77.62) v1(124.16,74.3) v1(124.33,75.08) v1(124.59,68.65) v1(125,74.57) v1(125.1,67.8) v1(126.84,68.93) v4(120.26,86.17) v5(120.93,63.09) v5(120.93,62.44) v5(120.93,61.79) v5(120.94,61.15) v5(120.94,60.49) v5(121.02,66.3) v5(121.1,64.67) v5(121.09,63.87) v5(121.11,59.17) v5(121.24,57.78) v5(121.99,64.72) v5(122.03,63.92) v5(122.1,57.77) v5(122.3,66.32) v5(122.93,59.12) v5(123.21,63.79) v5(123.19,63.09) v5(123.19,62.44) v5(123.19,61.79) v5(123.18,60.49) v5(123.84,64.64) v5(124.1,57.88) v5(124.26,66.3) v5(124.68,64.68) v5(124.72,59.15) v5(125.47,63.75) v5(125.47,63.1) v5(125.47,62.45) v5(125.47,61.8) v5(125.47,61.15) v5(125.46,60.53) v5(125.55,58.37) v5(125.57,59.15)
+VCC_PWR_SRC: length 42
  TOP w0.127: v2(152.32,75.64) 152.32,74.58 v1(152.3,74.57)
  IN3 w1.778: 132.81,70.72 131.47,70.72 125.15,77.05 125.15,79.14 123.44,80.86 118.69,80.86 116.69,82.85 116.69,84.21
  IN4 w2.032: 137.9,67.74 139.2,66.44 142.14,66.44 144.49,68.79 148.14,68.79 151.48,72.13 151.48,72.86
  vias: v1(116.31,88.15) v1(116.35,86.27) v1(116.35,85.6) v1(116.97,88.15) v1(136.17,69.61) v1(136.17,68.91) v1(136.84,69.61) v1(136.82,68.92) v1(150.4,74.57) v1(151.03,74.57) v1(151.67,74.57)
+VCC_SA:
  vias: v1(123.83,45.22) v1(125.68,44.83) v1(127.83,41.09) v1(127.86,39.21) v1(127.97,43.43) v1(127.98,24.42) v1(128.4,38.19) v1(128.45,23.95) v1(128.91,23.49) v1(129.37,23.02) v1(129.83,22.57) v1(130.29,22.11) v1(131.76,21.08) v1(131.98,31.26) v1(132.36,34.91) v1(132.36,34.28) v1(132.4,21.07) v1(132.61,31.26) v1(133,34.91) v1(133,34.28) v1(133.03,21.08) v1(133.25,31.26) v1(133.63,34.91) v1(133.63,34.28) v1(133.67,21.08) v1(133.93,31.26) v1(134.27,34.91) v1(134.27,34.28) v1(134.57,31.26) v1(134.63,21.07) v1(134.9,34.91) v1(134.9,34.28) v1(135.26,21.07) v1(135.54,34.91) v1(135.54,34.28) v1(136.17,34.91) v1(136.17,34.28) v1(136.46,33.67) v1(136.66,18.94) v1(136.66,18.31) v1(137.3,18.94) v1(137.3,18.31) v1(137.96,18.91) v1(137.96,18.28) v4(128.19,36.93) v5(122.89,46.61) v5(122.92,45.18) v5(123.82,43.86) v5(124.21,42.53) v5(124.7,46.55) v5(124.66,45.22) v5(124.7,43.86) v5(124.68,43) v5(125.94,42.72) v5(126.41,46.64) v5(126.4,44.84) v5(127.11,44.79) v5(127.09,43.96)
+VCCADAC: length 19.3
  TOP w0.508: v1(174.79,44.27) 174.78,44.27 v2(174.31,44.74) 174.01,45.04 169.96,45.04 168.83,43.91 v1(168.83,43.38)
  IN3 w0.508: v1(168.83,43.38) 167.73,43.38 166.34,41.98 163.22,41.98 v1(162.67,42.54)
  BOTTOM w0.508: v1(174.79,44.27) CH35.1 CH34.1 176.56,44.43 CH36.1 178.88,44.43 LH1.2
+VCCDIFFCLKN: length 16.9
  TOP w0.102: v1(159.24,44.07) v4(159.24,45.02)
  TOP w0.508: RH100.2 RH359.2 158.53,41.81 158.53,43.74 158.86,44.07 v1(159.24,44.07)
  IN2 w0.508: v1(158.67,34.47) 158.65,34.48 158.65,36.51 158.6,36.56 158.6,43.76 158.91,44.07 v1(159.24,44.07)
  BOTTOM w0.254: UH4.AF34 158.24,34.86 v1(157.85,34.46) 157.44,34.87 UH4.AG34 ; v1(158.67,34.47) 158.32,34.12 UH4.AF33
+VCCDSW3_3: length 25.1
  TOP w0.508: v1(162.73,26.5) 162.73,26.1 CH55.1
  IN1 w0.254: v1(162.73,26.5) 163.19,26.04 163.19,21.52 162.78,21.12 162.78,19.75 164.04,18.49 164.04,17.51 163.71,17.18 v1(163.71,16.42)
  IN3 w0.508: v1(163.71,16.42) 164.61,15.52 170.27,15.52 v1(171.68,16.93)
  BOTTOM w0.102: v2(173.82,15.43) 173.51,15.73 RH202.2
  BOTTOM w0.254: v1(162.73,26.5) 163.13,26.09 UH4.T16
  BOTTOM w0.508: RH202.2 172.52,16.09 v1(171.68,16.93) ; RH201.2 163.49,16.2 v1(163.71,16.42)
+VCCRTCEXT: length 1.3
  TOP w0.508: v1(164.78,25.51) 164.71,25.58 CH78.1
  BOTTOM w0.254: v1(164.78,25.51) 164.43,25.87 UH4.N16
+VCCSA_BT:
  vias: v2(140.95,10.98)
+VCCSA_BT_1: length 1.2
  BOTTOM w0.102: 138.96,12.7 138.96,13.41 v2(139.32,13.78)
+VCCSA_EN: length 2.6
  BOTTOM w0.254: PR83.1 141.89,11.57 v2(142.26,11.19) 143.06,10.39 PU7.13
+VCCSA_P: length 37.1
  IN1 w0.254: v1(142.27,2.56) 142.79,3.08 146.97,3.08 148.95,5.06 148.95,8.65 147.94,9.66 146.57,9.66 145.19,11.03 139.5,11.03 138.37,12.16 130.9,12.16 128.99,10.25 v1(128.99,7.58)
  BOTTOM w0.254: PR87.1 142.58,2.87 v1(142.27,2.56)
  vias: v2(128.81,9.97)
+VCCSA_PHASE: length 4.4
  BOTTOM w0.102: v4(137.57,13.76) 137.69,13.65 PC76.2
  BOTTOM w0.508: PC77.1 137.37,6.51
+VCCSA_PWR_SRC: length 1.2
  BOTTOM w0.127: v2(150.68,2.72) 149.81,3.58
+VCCSA_PWRGD: length 3.1
  BOTTOM w0.254: PU7.16 v2(144.56,11.16) 144.56,12.07 PR80.2 PR79.2
+VCCSST: length 1.5
  TOP w0.508: v1(161.91,26.45) 161.78,26.32 161.78,26.13 CH84.1
  BOTTOM w0.254: v1(161.91,26.45) UH4.V16
+VDDA_AVDD: length 11.3
  TOP w0.508: R1078.1 32.73,42.9 v1(32.72,42.91) ; R1083.1 v1(21.34,38.8)
  IN4 w0.508: v1(32.72,42.91) 29.2,42.91 28.25,41.96 28.25,40.85 ; 24.97,39.43 23.81,39.43 23.17,38.8 v1(21.34,38.8)
  vias: v1(26.32,31.48) v1(26.32,30.85) v1(26.51,39.77) v1(26.95,39.27) v1(28.53,31.77) v4(23.16,30.85)
+VDDA_PVDD: length 6.5
  TOP w0.381: 32.64,33.08 33.75,31.98 33.75,31.65 ; 29.63,33.02 29.64,33.02 v2(29.64,30.82) v1(29.64,29.88)
  TOP w0.508: v1(29.64,29.88) 29.44,29.69 C959.1
  vias: v1(34.51,31.01)
+VDDH_SD:
  vias: v2(278.1,9.97)
GND: length 1822.3
  TOP w0.127: v4(153.75,77.51) 154.12,77.87 v1(154.12,78.19) ; v1(62.69,11.27) 62.68,11.26 v4(62.01,11.26) ; v1(286.51,27.79) 286.5,27.79 v4(286.5,28.57) ; PC8.2 v4(43.13,75.44) ; v1(187.76,33.97) v4(187.76,34.88) ; C39.2 v4(305.21,85.4) ; v1(50.04,18.1) 49.31,18.1 v4(49.08,17.87) ; v4(265.75,88.33) v1(265.75,89.01) ; v1(181.7,10.14) 182.15,10.14 v4(182.49,9.8) ; v4(161.89,53.18) v1(161.89,52.47) ; v1(218.01,32.76) v4(218.01,33.61)
  TOP w0.254: v1(37.07,37.31) 36.72,37.66 U72.7 ; v1(284.92,54.54) 285.01,54.45 U51.B54 ; JLED1.2 165.25,63.96 165.38,64.09 ; U46.B27 268.01,75.81 v1(268,75.81) ; PQ104.1 242.58,14.9 242.93,15.25 v1(242.93,15.94) ; 288.96,59.29 292.1,59.29 292.16,59.35 U51.B11 ; v1(31.41,35.03) 31.14,34.76 U72.42 ; v1(219.98,25.84) 219.98,25.49 220.05,25.42 JTP1.8 ; v1(240.25,77.74) 239.55,78.44 U44.13 ; U51.B60 288.01,54.03 288.08,54.1 288.08,54.84 287.82,55.09 v1(287.57,55.09) ; U44.3 v1(239.55,77.08) ; v1(249.9,12.56) 249.77,12.43 PU100.15 ; v1(238.87,77.75) 238.7,77.58 U44.17
  TOP w0.279: U51.B66 291.01,54.45 v1(291.03,54.47)
  TOP w0.305: CH1.2 123.3,21.17 123.11,20.98 123.11,20.65 122.92,20.46 JXDP2.19 ; v1(115.14,20.81) 114.92,20.59 JXDP2.3 ; v1(89.18,84.95) 89.18,84.27 88.08,83.17 88.08,82.62 88.43,82.28 JXDP1.3 ; JCAP2.4 143.7,56.7 v1(144.05,57.05) 144.2,56.89 JCAP2.3 ; v1(264.62,57.28) 264.95,57.61 JDEG2.10 ; JXDP1.9 88.58,79.28 84.54,83.32 84.54,86.59 85.92,87.97 87.36,87.97 v1(87.97,87.36) ; JXDP2.6 116.42,20.59 v1(116.18,20.84) ; JXDP2.9 117.92,20.57 117.73,20.76 117.23,20.76 v1(117.17,20.82) ; v1(87.17,87.39) 86.2,87.39 85.08,86.27 85.08,83.89 88.2,80.78 JXDP1.6 ; JXDP1.19 88.6,74.28 88.23,73.91 88.23,71.6 88.56,71.27 89.13,71.27 JXDP1.25 90.07,71.28 v1(90.07,71.27) ; 288.96,59.29 v1(288.01,58.35) ; v1(124.91,20.84) 125.58,20.84 125.92,20.5 JXDP2.25
  TOP w0.381: C778.2 256.86,84.91 v1(256.56,84.91) ; PQ1306.1 34.57,28.1 34.37,28.31 34.37,29.03 34.55,29.21 v1(34.55,29.61) ; v1(255.97,89.77) 256.94,89.77 257.38,89.33 U58.3 ; v1(167.96,27.49) 167.96,27.42 168.5,26.88 169.13,26.88 169.98,27.73 CH90.2 ; PC1191.2 119.18,61.6 118.77,61.19 v5(118.61,61.19) ; PQ1306.4 37.4,26.8 v1(37.8,26.4) ; v1(18.32,42.15) 18.72,42.55 U48.1 ; v1(244.76,12.71) 244.76,13.31 244.47,13.6 PQ104.4 ; v1(31.15,73.05) 30.91,73.29 PQ1311.4 ; v1(27.29,74.7) 27.4,74.59 PQ1311.1 ; v1(291.24,86.23) 291.92,86.91 U15.3 ; PQ1307.4 v1(42.92,25.8) ; PQ1307.1 v1(44.22,29.99)
  TOP w0.406: v1(40.41,25.57) 40.1,25.26 PU1302.3 ; CH55.2 162.86,24.97 163.18,24.65 163.18,24.05 162.84,23.72 v1(162.63,23.72)
  TOP w0.432: Q41.1 315.52,35.56 315.3,35.33 315.3,34.92 v1(315.37,34.85) ; Q41.4 v1(314.54,36.86)
  TOP w0.457: v1(18.33,76.82) 18.86,77.35 U73.3 ; CC255.2 112.58,55.52 112.96,55.9 v5(112.96,56.04) ; R1669.2 17.44,78.27 17.06,78.65 U74.3 ; v1(101.16,8.8) 100.66,9.3 QC4.4 ; v1(102.67,8) QC4.1 ; 153.59,30.9 153.92,31.23 v1(153.92,31.43) 154.02,31.53 CH46.2
  TOP w0.508: v1(52.22,53.73) 52.22,53.42 52.6,53.05 54.5,53.05 54.63,53.17 CD34.2 ; v5(116.11,35.58) 115.78,35.58 115.35,35.15 PC1161.2 ; v1(233.74,23.05) 232.95,23.83 JFP1.1 ; C1304.2 236.95,26.79 JFP1.5 236.95,23.77 v1(236.96,23.76) ; C1201.2 11.82,77.61 v1(12.06,77.85) ; v5(116.42,51.95) 116.54,52.08 CC258.2 ; CC162.2 CC164.2 118.35,48.07 v5(117.78,47.5) ; CH1.2 123.5,21.75 v1(123.5,22.49) ; v1(77.92,7.58) 77.17,8.33 JSC1.11 ; PC1198.2 117.76,56.43 v5(117.8,56.39) 118.05,56.64 CC166.2 CC180.2 ; v1(251.94,16.09) 251.49,16.53 PC115.2 250.4,16.53 PR111.2 ; RC133.2 116.65,44.83 v5(117.16,44.83) ; CD39.2 CD40.2 63.02,82.56 60.97,82.56 60.56,82.16 v1(60.56,81.86) ; v1(253.32,75.98) 253.75,76.41 R878.1 254.51,76.51 C710.2 R803.2 ; v1(135.74,87.26) PC703.2 PC701.1 ; PC1147.2 120.38,59.28 v5(120.27,59.17) ; R892.1 C739.2 278.55,57.4 v1(278.52,57.43) ; PC1192.2 115.81,61.01 v5(115.2,61.01) ; v1(118.91,38.69) 118.9,38.7 118.9,39.33 ; Q66.3 197.09,11.12 197.97,10.23 v1(197.97,9.18) 198.07,9.28 C760.2 ; RC43.2 111.63,58.3 v1(111.63,58.73) ; JSC1.6 v1(83.82,10.19) ; RH126.2 165.17,38.86 164.79,38.48 v1(164.59,38.48) ; C751.2 222.5,32.38 v1(222.5,33.3) ; v1(146.33,34.82) 147.05,34.1 CH44.2 ; PC1183.2 114.86,46.34 114.34,45.82 v1(114.34,45.78) ; v1(308.25,47.69) 308.7,47.23 C759.2 ; C468.2 294.71,79.83 v1(295.18,80.3) ; PR24.2 21.51,71.69 v1(22.13,72.31) ; v1(27.95,27.53) 28.53,28.12 C959.2 ; C741.2 291.16,49.34 v1(290.94,49.11) ; PC1317.2 29.99,14.45 29.99,14.42 v1(29.14,13.57) 28.63,14.08 PC1306.2 ; v1(267.81,57.17) 267.35,57.17 267.05,56.87 JDEG2.11 ; PC1205.2 129.51,54.53 v5(129.5,54.52) 129.43,54.59 PC1211.2 ; v1(156.22,31.33) 156.15,31.26 CH82.2 ; v1(319.69,7.3) JRTC1.3 ; v1(296.5,67.13) 296.53,67.16 Q45.3 ; R889.1 v1(278.52,61.91) ; CH104.2 154.33,37.73 v1(154.74,37.32) ; v5(126.41,45.69) 126.25,45.53 CC171.2 ; CD4.2 74.44,46.76 v1(74.43,46.75) ; C726.2 v1(286.63,67.8) R942.2 ; v1(275.95,50.24) 276.38,50.67 278.13,50.67 R812.1 ; v1(317.77,25.4) JBT1.10 ; v1(67.32,44.99) 67.54,45.21 CD5.2 ; v1(34.55,29.61) 34.91,29.61 35.11,29.82 C960.2 ; v1(167.32,32.51) 167.21,32.62 CH60.2 ; C1177.2 296.26,86.09 296.86,85.49 v1(297.13,85.49) ; PC1203.2 126.46,54.53 v5(126.4,54.58) 126.37,54.56 PC1214.2 ; v1(54.51,6.06) 55.21,6.75 PD5.1 ; v1(159.7,36.57) 160.32,36.57 CH76.2 ; C466.2 280.55,79.88 279.99,79.32 v1(279.57,79.32) R804.2 ; v1(264.89,19.83) 264.51,19.83 C626.2 264.5,20.96 C625.1 C624.1 v1(265.91,19.83) ; CC256.2 116.54,53.86 v5(116.42,53.73) ; C743.2 290.35,50.3 v1(290.67,50.62) ; v1(274.58,50.07) 274.84,49.81 Q47.3 ; v1(66.68,44.99) 66.63,45.04 CD31.2 ; RC123.1 137.64,73.09 v1(138.02,72.7) ; C958.2 v1(41.18,28.42) ; v1(139.26,22.32) 138.66,22.92 CC177.2 ; PC1190.2 PC1175.2 118.47,59.11 v5(118.48,59.12) ; C565.2 287.32,10.97 v1(287.86,10.42) ; v1(112.13,22.73) 110.85,22.73 110.19,22.07 R883.1 ; PC1149.2 120.19,64.73 v5(120.24,64.68) ; v1(156.21,34.46) 156.82,35.08 CH81.2 ; CH112.2 169.87,49.04 170.74,49.04 v1(170.82,48.97) ; CH30.2 158.55,32.92 v1(158.62,32.85) ; RH74.2 145.62,29.16 CH53.2 144.26,28.38 v1(144.18,28.29) ; PC1177.2 117.71,43.86 v5(117.79,43.94) ; C471.1 292.31,78.42 v1(291.71,77.82) 291.36,77.82 290.7,77.16 R562.2 ; JSC1.4 81.82,9.75 v1(81.5,9.43) ; PR203.2 31.5,65.97 v1(31.27,65.75) ; C731.2 C735.2 v1(286.02,47.95) ; v1(37.14,40.56) 37.48,40.9 C952.2 ; v1(80.61,10.36) 80.82,10.57 JSC1.3 ; R1642.2 C1203.2 11.91,72.33 v1(12.38,71.87) ; v1(219.13,25.84) 219.13,26.48 220.46,27.81 C750.2 ; JXDP1.27 v1(89.18,85.73) ; JFP1.7 232.13,21.75 v1(232.17,21.79) ; v1(253.08,80.22) 253.08,80.41 253.5,80.83 254.09,80.83 254.48,81.21 C716.2 ; v1(279.04,65.94) 279.2,65.77 C730.2 ; PC1176.2 121.98,48.89 122.27,49.18 v5(122.9,49.18) CC263.2 ; RC130.2 CC141.2 127.51,67.57 v1(127.27,67.33) ; RC100.2 149.54,55.84 v1(148.95,55.84) ; C742.2 v1(295.19,58.61) ; v1(141.66,45.6) 142.82,45.6 143.17,45.25 R1611.2 143.17,44.29 142.76,43.88 Q64.3 ; JBT1.13 v1(318.7,15.1) ; v5(122.37,61.79) 122.28,61.7 PC1150.2 ; R882.1 v1(287.52,67.8) R941.2 ; PC1139.2 v1(120.44,57.78) ; v5(127.64,60.43) 127.53,60.32 RC56.2 ; PC1142.2 123.13,57.96 v5(122.99,57.81) ; CD25.2 64.53,43.03 v1(64.57,42.99) ; PC1194.2 122.14,44.05 122.61,44.52 v5(122.92,44.52) 122.92,43.64 PC1184.2 ; JSC1.12 v1(88.93,8.33) ; v1(157.66,65.62) 158.36,65.62 158.93,65.05 JLED1.10 ; CH49.2 153.36,30.67 153.59,30.9 ; Y3.4 293.81,75.01 v1(294.3,74.52) ; v5(121.12,43.15) 121.09,43.18 PC1186.2 ; v5(129.56,48.29) 129.42,48.14 PC1212.2 ; v1(42.21,60.11) 41.69,59.59 PC282.2 ; v1(41.69,76.22) PC8.2 ; C575.2 v1(283.67,7.28) ; C1318.2 C1319.2 245.52,59.66 v1(245.52,60.51) ; v1(40.67,37.35) C977.2 C978.2 ; v1(152.27,81.78) 152.23,81.82 PC729.2 150.41,81.82 PR742.2 ; R767.1 R1627.2 v1(267.94,85.02) ; v1(111.69,48.2) 111.69,47.51 CC252.2 ; C469.2 291.58,85.89 v1(291.24,86.23) ; v1(254.11,71.43) 254.26,71.59 R1629.2 ; v1(306.19,83.56) C39.2 ; v1(156.64,39.75) 156.72,39.67 CH96.2 ; CD35.2 56.68,47.71 v1(56.79,47.6) ; PD6.1 v1(51.21,10.34) ; C714.2 257.36,85.08 C778.2 ; v1(287.81,9.51) 287.43,9.89 C566.2 ; v1(64.8,55.74) 64.23,55.17 CD32.2 ; C737.2 279.01,53.72 278.24,52.94 v1(277.79,52.94) ; v1(220.53,33.33) 219.92,32.73 219.92,31.06 C749.2 ; C662.2 237.28,82.24 v1(237.67,82.64) ; v5(115.64,45.82) 115.72,45.91 PC1189.2 ; v1(66.59,81.91) 66.64,81.96 RD8.1 ; v1(15.78,66.57) 15.58,66.37 PC16.2 ; v1(160.3,34.46) 160.44,34.61 CH102.2 ; v1(218.01,32.76) 217.79,32.53 D37.1 ; v1(297.97,50.41) C721.2 ; v1(111.1,49.16) 110.75,49.51 CC251.2 ; CC156.2 v1(110.51,81.62) ; RC78.2 RC45.2 102.53,56.74 v1(103.13,57.34) ; JCAP2.9 147.3,60.93 147.22,61.01 v1(147.22,61.26) ; JLID1.6 v1(32.65,9.58) ; CD3.2 78.38,63.76 78.71,64.08 v1(78.71,64.45) ; v1(289.49,11.19) 289.18,11.49 CE757.2 ; PC114.2 247.6,15.94 v1(248.21,16.55) ; RC40.1 129.32,64.06 129.74,63.64 129.74,63.4 v5(129.73,63.39) 129.09,62.75 RC41.1 ; v1(28.42,19.96) 28.35,19.9 PC1311.2 ; RC70.2 148.14,49.25 v1(147.65,49.25) ; PC1197.2 117.76,58.21 v5(117.78,58.19) ; C732.2 v1(278.52,63.81) ; v5(123.57,66.34) 123.57,66.81 PC1151.2 ; v5(118.51,64.83) 117.63,63.95 PC1172.2 ; v1(270.44,61) 270.92,60.53 C1249.2 ; PQ105.3 245.64,19.15 v1(244.96,18.48) ; PC116.2 248.96,15.66 v1(249.2,15.9) ; v5(119.36,45.93) 119.46,45.83 PC1193.2 ; PC1120.2 139.17,47.85 v1(138.65,47.33) ; JCAP2.10 139.41,58.04 138.59,58.86 v1(138.59,58.89) ; C755.2 C765.2 213.2,9.88 v1(213.2,10.69) ; CD43.2 CD44.2 v1(56.74,79.29) ; CC261.2 v1(126.4,47.5) CC262.2 ; CH68.2 163.67,26.16 v1(164.07,26.57) ; v1(317.39,33.11) 316.97,33.53 R726.2 ; Q71.3 100.17,10.51 v1(99.99,10.69) ; JLED1.9 167.67,64.87 v1(166.62,64.87) 166.16,64.87 165.38,64.09 ; C705.2 272.18,67.21 v1(272.35,67.38) ; v1(17.75,78.99) R1669.2 ; PC405.2 v1(158.73,63.79) ; C744.2 v1(297.48,59.62) C728.2 ; PC14.2 PC11.2 PC13.2 PR22.2 13.24,65.78 v1(13.91,66.46) ; PC1213.2 129.43,52.82 v5(129.5,52.89) 129.64,52.75 PC1204.2 ; v1(9.33,3.68) 8.68,4.33 JSNIF1.6 ; PWRSW1.2 v1(310.61,46.86) ; PC1180.2 116.01,41.86 v1(115.86,42.01) ; v1(169.29,37.51) 169.34,37.46 RH273.2 ; v1(257.16,64.42) 257.63,63.95 C595.2 ; RC50.2 138.66,26.35 138.25,26.77 v1(137.74,26.77) ; v1(262.76,27.77) 262.76,28.1 262.2,28.66 C623.2 C621.2 ; C713.2 276.9,78.88 v1(276.7,79.08) ; C463.2 288.23,74.95 v1(288.61,74.57) ; v1(241.32,65.45) 241.01,65.76 241.01,65.77 C606.1 C603.2 239.73,66.14 C609.2 ; C574.2 v1(277.5,20.51) ; RC96.1 111.08,41.82 v1(111.49,41.41) ; RD9.1 71.33,83.94 v1(71.1,83.72) ; C564.2 274.11,10.66 v1(274.11,10.83) 274.38,11.1 C563.2 ; v5(114.4,53.6) 114.84,53.16 CC253.2 ; v1(317.58,16.4) JBT1.1 ; v1(321.61,28.7) JBT1.14 ; CH50.2 161.11,32.8 v1(161.1,32.8) ; CH106.2 161.91,31.27 v1(161.91,31.28) ; v1(261.96,40.6) 261.6,40.6 C619.2 ; Y3.2 296.21,78.43 v1(296.6,78.81) ; JXDP1.28 89.25,68.33 91.59,70.66 v1(91.59,71.27) ; CC574.2 116.2,55.24 115.86,55.24 v5(115.59,55.51) ; v1(70.47,64.45) 70.47,64.18 69.07,62.77 CD15.2 ; v1(56.58,43.87) 56.57,43.85 CD26.2 ; SW1.3 316.7,42.21 v1(317.35,41.55) ; v5(122.96,64.6) 122.88,64.67 PC1148.2 PC1140.2 ; PC1156.2 124.19,35.35 v5(124.21,35.37) ; v1(13.62,68.58) 13.62,69.32 PR23.1 ; CC254.2 116.54,50.3 v5(116.42,50.18) 116.29,50.05 CC250.2 ; CH47.2 CH32.2 157.93,30.54 v1(157.82,30.42) 157.97,30.27 CH45.2 ; v1(226.2,25.85) 226.15,25.8 JTP1.18 ; v1(128.36,13.99) 128.69,13.66 PR505.2 ; v1(289.92,86.05) 290.14,86.27 C1323.2 ; v1(261.42,68.53) 261.38,68.5 C708.2 ; C729.2 v1(289.04,48.75) ; RH174.2 v1(183.88,20.14) ; PC1185.2 117.79,59.84 v1(117.54,60.08) ; CC183.2 128.7,45.53 v5(128.78,45.61) ; v1(145.27,52.47) 145.53,52.21 C1316.2 146.67,52.21 C1317.2 ; C752.2 v1(224.12,33.28) ; R1643.2 C1204.2 12.23,73.3 v1(12.32,73.39) ; C1178.2 v1(279.15,82.2) ; C727.2 v1(296.74,55.93) ; v1(33.64,78.25) PR16.1 ; v1(244.25,74.18) C661.2 ; v1(312.83,5.31) PC3.2 ; v1(169.52,31.45) 170.05,30.93 CH88.2 CH89.2 ; C961.2 33.84,30.26 v1(34.51,30.26) ; CH75.2 163.45,35.75 v1(163.59,35.88) 163.53,35.95 CH74.2 ; v5(113.15,54.61) 113.44,54.9 CC259.2 ; v1(69.69,83.97) 69.66,84.01 CD22.2 CD21.2 ; v1(261.89,27.77) C620.2 ; PC1181.2 112.63,42.43 v1(113.11,42.91) ; C627.2 258.77,24.04 v1(257.89,23.16) ; v1(241.05,24.32) 240.55,23.82 JFP1.8 ; v1(157.68,37.24) 158.35,37.24 RH344.1 ; CD9.2 75.04,54.9 v1(75,54.86) ; v5(112.42,44.8) 112.37,44.85 PC1178.2 ; CH66.2 161.92,27.18 v1(161.91,27.17) ; R876.1 v1(297.52,62.86) ; v1(275.66,78.99) 275.43,79.22 C712.2 ; v5(121.14,45.91) 121.89,45.91 PC1201.2 ; C723.2 v1(295.85,49.4) ; C577.2 287.59,8.62 v1(287.81,8.85) ; PR1350.2 v1(37.16,2.76) ; v1(42.13,72.83) 43.08,71.88 C786.2 ; v1(64.78,59.88) 64.74,59.92 CD27.2 63.07,59.92 CD36.2 ; R1659.2 v1(33.24,25.8) ; C1246.2 145.27,49.67 v1(145.71,49.22) ; CH111.2 167.04,41.58 v1(167.59,41.02) ; v1(39.53,34.54) 39.18,34.88 C994.2 ; v5(121.65,35.7) 121.34,35.7 120.66,35.01 PC1155.2 ; C983.2 v1(18.38,27.25) ; PC1141.2 120.19,66.28 v5(120.18,66.27) ; C740.2 299.69,62.21 v1(300.04,62.57) ; v1(43.66,66.13) PC255.2 ; v1(164.61,40.38) 164.06,40.92 RH183.2 ; v1(316.49,7.3) JRTC1.4 ; v1(317.54,39.1) R1625.2 C644.2 ; v1(248.98,16.52) 248.98,16.85 248.82,17 PC117.2 ; CD33.2 56.28,55.11 v1(56.6,55.43) ; C610.2 v1(299.43,44.18) ; v1(294.65,80.67) 294.42,80.9 C464.2 ; v1(42.91,61.72) PR238.1 ; v1(281.77,67.64) 281.67,67.74 R843.1 ; v1(104.64,87.77) 104.64,86.97 104.39,86.71 R1137.2 ; C1320.2 248.58,60.13 v1(249,60.55) 249.42,60.13 C1321.2 ; v1(312.73,24.76) C1305.2 ; v1(85.51,10.26) 85.82,10.56 JSC1.8 ; v5(119.81,41.28) 120.29,41.28 PC1196.2 ; CC257.2 116.26,48.24 v5(116.42,48.4) 116.57,48.55 CC573.2 ; v1(109.9,19.27) 111.06,18.11 JXDP2.27 ; v1(32.58,63.23) PC263.2 ; R677.1 274.62,15.73 v1(274.17,15.29) ; CH56.2 159.46,31.04 v1(159.46,31.34) ; CH69.2 158.61,31.82 v1(158.61,31.32) ; JSNIF1.4 11.5,2.85 11.28,3.07 v1(10.23,3.07) ; R908.2 201.62,10.55 201.95,10.88 v1(201.95,11.74) ; PC1215.2 126.34,52.78 v5(126.4,52.84) 126.56,52.69 PC1209.2 ; R786.1 v1(266.12,66.08) ; v1(101.22,73.62) 101.92,74.31 RC81.2 ; v1(146.55,31.33) 146.18,30.96 CH51.2 144.8,30.59 145.29,30.1 RH75.2 ; R791.1 272.74,77.4 C706.2 272.89,77.25 v1(273.77,77.25) ; v1(276.22,41.03) C612.2 ; v5(130.85,49.68) 130.67,49.86 PC1202.2 PC1207.2 ; v1(141.15,49.9) 141.71,49.9 PC1136.2 ; v1(294.79,86.5) 294.44,86.16 C462.2 ; QC1.3 105.35,80.4 104.91,79.96 v1(104.91,79.12) ; PC1122.2 139.77,53.9 v1(138.65,55.01) ; PC1208.2 126.56,50.91 v5(126.4,51.07) 126.34,51 PC1216.2 ; v5(121.14,44.54) 120.93,44.54 120.44,44.05 PC1200.2 ; PC277.2 37.9,61.17 v1(37.65,60.92) ; C954.2 39.27,32.03 v1(40.52,33.27) ; v1(41.31,41.02) R1141.2 R1142.2 ; v1(173.04,41.28) 170.3,41.28 RH333.2 ; R793.2 264.22,65.17 v1(264.47,64.91) ; v1(38,70.19) 38.38,69.81 PC272.1 40.86,69.81 ; CH67.2 159.49,34.46 v1(159.48,34.48) ; C967.2 v1(37.17,43.9) ; R557.2 285.15,69.38 C747.2 285.96,69.59 v1(285.96,70.08) ; CH59.2 165.09,27.94 165.41,27.62 v1(165.41,27.43) 165.04,27.06 CH78.2 ; C576.2 v1(284.56,7.28) ; v1(121.18,70.77) 121.93,70.03 PC1135.2 ; Q50.3 283.53,67.38 v1(283.52,67.4) ; v5(127.03,42.86) 126.55,42.38 CC170.2 ; v1(13.94,67.22) 13.65,67.22 13.51,67.08 D83.1 ; PC1124.2 117.61,36.06 v5(118.09,35.58) ; v1(66.82,57.33) 67.59,58.11 CD12.2 ; v1(254.11,72.51) R790.1 ; CD10.2 74.14,59.7 v1(74.12,59.72) ; PC1210.2 126.56,49.13 v5(126.4,49.29) 126.27,49.16 PC1217.2 ; v1(31.91,76.59) PQ3.3 ; v1(298.6,47.79) C722.2 ; v1(250.11,72.77) 250.95,71.92 JSPK1.5 ; v1(124.5,70.84) 124.52,70.84 125.42,69.94 PC1111.2 ; R826.2 v1(282.78,7.28) ; DE2.1 248.61,63.8 248.34,64.07 v1(248.34,64.65) ; v5(129.5,50.01) 129.38,49.89 PC1206.2 ; C1306.2 313.15,22.92 v1(312.74,23.33) 313.22,23.81 R1709.2 ; CH33.2 154.02,34.4 v1(153.99,34.43) 153.76,34.65 CH103.2 ; CH79.2 158.73,24.32 v1(158.67,24.38) ; C1224.1 23.5,78.55 v1(23.5,78.1) ; C1208.2 v1(10,82.41) ; C573.2 v1(278.39,20.51) ; C594.2 v1(298.42,44.24) ; v1(128.29,20.23) 128.87,19.65 JXDP2.28 ; v1(31.68,71.85) 32.04,72.21 PQ6.3 ; PC1179.2 120.17,37.01 v5(119.66,36.5) ; v1(141,51.4) 140.46,50.86 PC1119.2 ; C467.2 v1(280.55,85.38) ; PC1341.2 36.75,5.42 v1(37.15,5.83) ; v1(109.61,106.26) 109.17,105.83 C302.2 ; v1(33.56,76.18) 33.38,76.01 PC17.2 ; C1307.2 v1(312.72,22.03) ; v1(52.98,60.55) 52.98,60.05 53.47,59.56 CD28.2 ; RH76.2 166.26,31.32 v1(166.14,31.44) ; CD17.2 CD18.2 69.92,82.17 70.45,82.7 v1(70.45,82.93) ; v5(128.67,42.82) 128.96,42.53 CC168.2 ; v5(124.7,45.91) 124.69,45.92 CC169.2 ; PC1137.2 125.04,60.08 v5(124.63,60.49) ; CH109.2 173.92,46.64 174.21,46.35 v1(174.21,45.96) ; R869.2 v1(278.52,58.29) ; CH48.2 159.42,28.1 v1(159.47,28.05) ; R1138.2 98.33,88.96 v1(98.72,88.57) ; v1(78.87,83.19) 78.87,83.33 77.97,84.24 CD20.2 CD19.2 ; v5(124.78,47.51) 124.13,47.51 CC260.2 ; R1660.2 v1(31.34,25.8) ; v1(33.41,60.94) PC280.2 ; R561.2 v1(287.09,88.25) ; C758.2 v1(224.77,25.85) ; JDEG2.12 258.35,57.32 257.57,58.1 v1(257.18,58.1) ; C1225.1 v1(9.47,77.61) ; PC1195.2 118.71,44.05 119.2,44.54 v5(119.37,44.54) ; JSPK1.6 v1(245.05,72.78) ; CD42.2 CD41.2 56.17,81.07 v1(56.56,81.46) ; R879.1 296.97,52.32 v1(297.36,51.93) ; RH77.2 168.98,29.83 v1(168.66,29.51) ; C37.2 v1(306.18,79.69) ; v1(119.82,39.19) 120.01,39.19 120.44,39.62 PC1188.2 ; R836.2 284.12,44.94 JTAG1.2 283.89,44.92 283.58,44.6 v1(283.58,44.17) ; CD6.2 72.68,63.77 v1(72,64.45) ; R789.1 268.76,66.7 v1(268.76,66.01) ; C579.2 v1(281.9,7.25) ; JLID1.1 28.5,12.06 28.8,11.77 v1(28.8,11.52) ; JSNIF1.5 v1(15.14,5.61) ; v5(117.78,45.74) 117.87,45.83 PC1199.2 ; CH70.2 166.04,29.44 165.42,28.82 v1(165.42,28.54) ; v1(65.66,46.86) 66.09,47.28 CD13.2 ; v1(170.01,20.71) 170.22,20.49 RH59.2 ; v1(66.57,53.88) 67.05,54.36 CD14.2 ; C1247.2 v1(288.59,24.42) ; C478.2 v1(295.88,87.3) ; JLID1.5 v1(27.43,9.58) ; v1(318.62,8.95) JRTC1.2 ; v1(181.21,20.58) 181.34,20.46 RH172.2 ; v1(154.02,28.51) 154.4,28.51 154.72,28.83 CH91.2 ; v1(315,31.18) 314.64,31.54 Q73.3 ; R1658.2 v1(32.29,25.8) ; C38.2 v1(306.18,82.29) ; JSNIF1.3 v1(12.5,3.59) ; v1(244.98,65.35) 245.01,65.31 DE1.1 ; CC161.2 CC163.2 118.6,51.88 v5(117.79,51.07) ; C981.2 16.97,40.55 v1(17.6,41.17) ; C1324.2 C1325.2 297.93,70.03 v1(297.49,70.47) ; C36.2 v1(306.16,78.42) ; v1(297.08,16.6) 296.19,16.6 ; PC12.2 v1(25.51,67.52) ; PC1342.1 v1(39.09,27.71) ; C611.2 287.46,41.78 v1(287.06,41.38) ; v5(122.37,60.49) 122.28,60.4 PC1138.2 ; v1(261.55,84.73) 261.52,84.71 R775.1 C709.2 ; v1(121.52,22.49) CH6.2 ; SW1.1 v1(312.62,46.89) ; v1(64.89,54.06) 64.64,53.81 CD37.2 ; C1244.2 v1(18.12,55.24) ; v1(291.94,74.6) 292.5,75.16 C470.1 ; v1(57.22,81.91) 57.23,81.9 57.23,81.21 56.66,80.64 RD14.2 ; v1(290.33,70.2) 290.79,69.74 Q127.3 ; C601.2 252.89,65.71 v1(252.68,65.5) ; RH260.2 v1(169.09,39.38) ; PD7.1 31.16,83.97 v1(30.79,83.6) ; v1(161.16,27.19) 161.14,27.18 CH77.2 160.47,27.12 160.47,25.81 CH84.2 ; CC181.2 CC165.2 118.12,54.29 v5(117.79,54.62) ; v1(272.37,68.03) 271.76,68.03 C707.2 ; v1(106.14,11.63) 106.06,11.71 RC143.2 105.36,11.7 CC136.2 ; C578.2 v1(276.42,21.43) ; CH31.2 159.64,29.82 v1(159.47,29.65) ; v1(29.24,77.07) 28.49,77.07 28.03,77.53 D77.1 ; CC65.2 93.78,84.73 v1(93.77,84.74) ; PC505.2 v1(117.62,12.21) ; R1661.2 v1(30.38,25.8) ; R880.1 C725.2 v1(289.36,67.76) ; C953.2 v1(39.54,38.51) ; v1(261.99,41.42) C622.2 ; R3.1 v1(260.6,84.7) ; v1(74.63,50.57) 74.64,50.56 CD11.2 ; CC264.2 v5(130.87,46.62) ; C593.2 v1(278.63,44.17) ; RC121.1 v1(139.93,77.04)
  BOTTOM w0.127: v4(31.91,77.3) v1(31.91,76.59) ; v4(181.72,43.94) CH43.2 ; v4(101.22,74.3) v1(101.22,73.62) ; v4(34.23,45.15) v1(33.38,45.15) ; v4(167.43,13.18) 167.91,13.66 v1(167.91,13.84) ; v4(50.54,10.34) v1(51.21,10.34) ; v4(28.32,36.71) v1(29,37.39) ; v4(28.24,87.79) Q72.3
  BOTTOM w0.178: v1(110.96,56.16) 110.9,56.22 110.9,56.77 U1.BD44
  BOTTOM w0.203: U1.AJ20 117.78,45.65 v5(117.78,45.74) 117.78,45.85 U1.AL21 ; D88.3 255.72,93.24 v1(256.02,92.94) ; U1.AY49 112.5,60.28 v5(112.5,60.46) ; U1.AF17 119.47,44.54 v5(119.37,44.54) 119.26,44.54 U1.AG18 ; U1.D43 130.36,56.34 130.67,56.03 130.67,55.53 130.76,55.44
  BOTTOM w0.229: U1.AN54 115.92,62.71 U1.AP55 ; U1.A9 132.31,40.13 132.31,40.14 v5(132.32,40.14) ; v5(132.35,44.11) 131.81,44.11 U1.A17 ; U1.BE5 110.13,38.43 110.59,38.89 U1.BD8 ; v5(132.3,42.11) U1.A13 ; v1(314.58,57.78) D78.3 ; D89.3 v1(21.89,50.35) ; v5(130.89,42.66) U1.D14
  BOTTOM w0.254: v5(114.1,58.94) 114.1,59.15 113.86,59.4 U1.AV48 ; U1.C58 131.03,64.32 U1.D58 130.22,64 129.73,63.51 v5(129.73,63.39) 129.73,63.38 U1.F55 ; v5(122.99,57.81) 122.92,57.88 U1.W46 ; U1.AN43 116.08,56.97 v5(116.42,57.31) 116.76,57.66 U1.AM45 ; U1.AM30 116.76,50.52 v5(116.42,50.18) 116.08,49.83 U1.AN28 ; UH4.AW34 151.65,34.86 v1(151.98,34.53) 151.98,34.26 UH4.AW32 ; U1.AA53 122.3,61.79 v5(122.37,61.79) 122.05,61.47 U1.AA52 ; U1.W18 122.48,44.84 122.81,44.52 v5(122.92,44.52) ; v1(148.16,27.47) 148.13,27.49 UH4.BH19 ; U1.BA51 112.09,60.87 v5(112.5,60.46) ; UH4.AP1 154.7,19.1 UH4.AN2 ; v1(120.44,57.78) 120.57,57.78 121.13,58.35 U1.AC46 ; UH4.AW48 151.78,41.25 151.55,41.03 ; U1.N25 126.06,47.84 v1(126.4,47.5) 126.74,47.15 U1.L22 ; U1.P16 125.14,43.21 v5(125.34,43.01) 125.34,42.36 U1.P14 ; v5(108.25,61.67) 108.32,61.59 U1.BG53 ; v1(115.44,40.06) 115.56,40.19 115.79,40.19 U1.AP10 ; v5(119.36,45.93) 119.69,46.26 U1.AF21 ; U1.BA26 112.04,48.56 v1(111.69,48.2) ; v5(119.07,66.25) 119.02,66.21 U1.AG61 ; v5(130.86,62.33) 130.77,62.42 U1.D54 ; UH4.Y4 160.93,20.23 v1(160.62,20.53) ; U1.AB48 121.94,59.16 v5(122.04,59.16) 122.14,59.16 U1.Y47 ; U1.D6 130.78,38.71 v5(130.87,38.62) 130.87,38.48 130.47,38.07 U1.D4 ; v5(122.37,63.09) 122.05,63.42 U1.AA56 ; U1.AP7 115.76,38.86 115.63,38.86 v1(115.51,38.73) ; v5(112.44,53.57) 112.44,53.5 U1.AY36 ; UH4.AE2 UH4.AE3 ; v1(132.29,57.82) 131.88,57.82 U1.A45 ; v1(117.86,41.29) 117.62,41.29 U1.AL13 U1.AM13 ; v5(132.38,48.02) 132.27,48.13 U1.A25 ; v1(114.42,49.14) 114.36,49.21 114.36,49.38 U1.AU28 ; U1.AJ34 117.82,52.72 v5(117.82,52.84) 117.45,53.21 U1.AL36 ; v1(91.94,108.09) 91.94,108.48 92.1,108.64 JLVDS1.39 ; UH4.AG48 157.7,41.81 157.7,41.14 v1(157.68,41.12) ; U1.BD40 110.08,55.11 v5(110.05,55.13) ; UH4.T12 162.83,23.72 v1(162.63,23.72) ; v5(127.03,42.86) 127.01,42.88 U1.M15 ; U1.A49 131.79,60.26 131.91,60.39 v5(131.91,60.39) ; JLVDS1.16 v1(103.6,108.15) ; U1.AL28 117.45,49.63 v5(117.78,49.3) 118.13,48.95 U1.AJ26 ; U1.AF55 120.05,63.09 v5(120.12,63.09) 119.79,63.42 U1.AF56 ; U1.AF59 119.8,64.99 120.1,64.68 v5(120.24,64.68) 119.89,64.33 U1.AF58 ; UH4.AC2 159.7,19.74 v1(159.71,19.75) ; U1.N33 126.06,51.41 v5(126.4,51.07) 126.74,50.72 U1.L30 ; v1(111.1,49.16) 111.08,49.18 U1.BD27 ; U1.AD4 120.75,37.51 121.22,37.97 v1(121.35,37.97) 121.35,38.11 120.89,38.58 U1.AC6 ; UH4.BH33 146.72,34.43 v1(146.33,34.82) ; UH4.BH33 UH4.BH31 ; UH4.BH33 UH4.BG33 ; U1.AG14 119.01,41.94 v5(118.89,41.94) 118.56,41.61 U1.AJ13 ; U1.AY19 112.44,45.56 v5(112.44,45.82) 112.44,45.92 U1.BA21 ; U1.BD16 110.12,43.25 v5(110.03,43.33) ; v5(108.53,39.72) 109.02,39.72 U1.BG9 ; UH4.BH7 147.44,21.69 UH4.BG8 147.79,21.89 v1(148.17,21.51) ; v1(160.71,38.46) 161.04,38.79 UH4.Y42 ; v5(108.44,49.58) 108.59,49.74 U1.BG28 ; JLVDS1.33 v1(95.1,108.19) ; v5(128.15,35.51) 127.97,35.69 U1.J1 ; U1.AJ30 118.13,50.72 v5(117.79,51.07) 117.79,51.17 U1.AL33 ; U1.AU7 114.21,38.98 v1(114.51,38.67) 114.63,38.79 114.71,38.79 U1.AR7 ; v5(131.82,36.62) 131.82,36.63 131.32,36.63 U1.C3 ; UH4.BH11 147.37,23.55 v1(147.97,23.55) ; U1.AA55 122.28,62.46 v5(122.37,62.46) ; U1.R4 124.95,37.9 125.52,37.9 v5(125.67,38.05) ; U1.AU51 114.18,60.96 U1.AT52 114.69,61.27 114.94,61.01 v5(115.2,61.01) 115.43,61.01 U1.AP51 116,60.44 U1.AN50 ; UH4.BF38 147.98,37.4 UH4.BH39 ; UH4.BH35 v1(146.68,35.42) ; v1(113.78,51.6) 114.11,51.28 U1.AU32 ; UH4.AL48 v1(155.74,41.02) 155.42,40.7 UH4.AM46 ; U1.AL17 117.16,44.69 v5(117.16,44.83) 117.16,44.89 U1.AM20 ; v5(126.47,66.43) 126.7,66.2 126.7,66.03 U1.L61 ; U1.E1 129.99,36.54 U1.E3 129.75,36.84 v5(130.09,37.19) ; v5(124.7,45.91) 124.68,45.91 124.34,45.57 U1.R20 ; JTAA1.12 197.2,21.5 197.01,21.69 v1(197.01,21.94) 197.07,22 JTAA1.10 ; v1(122.35,37.97) 122.6,37.72 U1.Y4 ; U1.H17 128.34,43.9 v5(128.67,43.56) 128.68,43.56 129.09,43.15 U1.F15 ; v5(124.63,61.79) 124.56,61.79 U1.T53 ; UH4.AV16 152.31,26 151.99,25.68 v1(151.99,25.47) 151.65,25.14 UH4.AW14 ; v5(111.07,45.82) 110.59,45.34 U1.BD19 ; U1.W13 122.87,41.61 123.23,41.97 v5(123.29,41.97) ; U1.T55 124.23,62.64 124.42,62.45 v5(124.63,62.45) ; UH4.B27 v1(169.52,31.45) 168.76,31.45 v1(168.72,31.41) ; T108.1 132.64,69.63 v1(132.34,69.33) ; U1.AB16 121.59,43.5 121.23,43.15 v5(121.12,43.15) 120.89,42.91 U1.AC14 ; v5(117.79,43.94) 118.13,43.59 U1.AJ16 ; U1.A57 131.85,63.66 v5(132.15,63.96) ; U1.BD23 110.71,47.33 111.06,47.33 v5(111.07,47.34) ; U1.N21 126.06,46.05 v5(126.41,45.69) 126.74,45.36 U1.L20 127.18,45.72 U1.K21 ; v1(114.67,36.99) 114.69,37.01 U1.AT4 ; v5(112.42,44.8) 112.42,44.6 U1.BA17 ; U1.AR17 115.07,43.99 v5(115.07,43.83) ; JTAA1.2 198.77,24 199.38,23.39 v1(199.38,21.92) ; U1.AM38 116.42,53.83 v5(116.42,53.73) 116.08,53.39 U1.AN36 ; U1.P9 125.01,39.95 124.05,39.95 U1.U8 123.44,39.94 v5(123.32,39.94) ; U1.AB61 121.72,66.21 v5(121.66,66.27) ; PR405.2 159.61,69.28 158.88,70 158.15,70 157.76,69.62 v1(157.76,69.49) ; U1.P59 125.14,65.23 U1.N61 v5(125.62,66.35) ; v5(109.52,46.22) 109.16,45.86 U1.BG21 ; v5(115.64,45.82) 115.72,45.82 116.07,46.18 U1.AN21 116.08,46.18 116.76,46.85 U1.AM22 117.11,47.41 117.11,47.62 U1.AL25 117.78,47.62 v5(117.78,47.5) 118.13,47.14 U1.AJ22 ; U1.AR48 115.42,59.07 v5(115.42,58.96) ; UH4.BH17 UH4.BG17 148.48,26.16 UH4.BF16 148.16,25.69 v1(148.16,25.54) 147.38,25.54 UH4.BH15 ; U1.M58 126.46,63.33 v5(126.28,63.15) 126.17,63.15 125.9,63.42 U1.N56 ; v5(118.09,35.58) 118.09,35.58 U1.AK1 ; v1(161.74,43.25) 161.6,43.11 161.6,41.92 UH4.W48 ; U1.T47 124.15,58.82 v5(123.81,59.17) ; v5(110.5,64.25) 110.83,63.92 U1.BC57 ; v5(110.5,64.25) 110.5,63.24 U1.BD56 ; v5(110.5,64.25) 110.56,64.31 U1.BD59 U1.BC61 ; UH4.AL2 155.79,19.1 UH4.AK3 ; v5(121.38,40.92) 121.06,40.6 U1.AC10 ; JLVDS1.22 v1(100.6,108.19) ; v5(121.65,35.7) 121.74,35.7 122.04,36 U1.AA1 ; U1.AH58 118.47,64.29 118.47,64.79 v5(118.51,64.83) ; v5(113.09,66.33) U1.AW61 ; U1.T1 124.21,35.89 v5(124.21,35.37) ; U1.T51 124.56,60.49 v5(124.63,60.49) 124.3,60.17 U1.T50 ; v5(108.63,47.68) 108.71,47.76 U1.BG24 ; U1.BA48 111.63,59.18 v1(111.63,58.73) 112.13,58.23 112.13,57.92 U1.AY45 ; v5(114.4,53.6) 114.4,53.49 U1.AT36 ; U1.K51 128.03,61.32 v5(128.03,61.38) 128.03,61.74 U1.H53 ; U1.N1 125.94,36.03 v5(125.94,35.56) ; U1.N51 125.96,60.82 v1(126.27,61.13) 125.93,61.47 U1.N52 ; v5(108.66,57.64) U1.BG45 ; JLVDS1.29 97.1,108.25 v1(97.17,108.19) ; U1.AG47 118.77,58.82 v5(118.48,59.12) 118.13,59.46 U1.AJ48 ; UH4.AC48 159.7,41.07 v1(159.68,41.04) ; U1.L34 126.4,52.74 v5(126.4,52.84) 126.06,53.19 U1.N36 ; 162.65,20.74 162.65,21.02 UH4.V7 162.03,21.64 v1(161.68,21.64) 161.19,22.13 UH4.Y8 ; v5(113.75,44.82) 113.75,44.62 U1.AV17 ; U1.BA11 112.09,40.42 v5(112.27,40.24) 112.27,40.07 112.64,39.7 U1.AY9 ; UH4.B23 169.63,29.03 UH4.C22 ; v5(123.57,66.34) 123.67,66.23 U1.V61 ; JLVDS1.4 109.6,108.49 v1(110.21,107.88) ; U1.AB18 121.49,44.89 v5(121.14,44.54) 120.8,44.2 U1.AD17 ; U1.Y59 122.57,64.99 v5(122.96,64.6) 122.65,64.29 U1.Y58 ; U1.T56 124.28,63.42 v5(124.63,63.07) ; U1.AJ38 117.79,54.52 v5(117.79,54.62) 117.79,54.73 117.45,55.07 U1.AL40 ; v5(132.35,51.61) 132.12,51.38 U1.A33 ; v1(112.6,63.5) 112.54,63.56 U1.AY58 ; v5(119.66,36.5) 119.73,36.43 119.73,36.42 U1.AF1 ; U1.D26 130.39,48.29 v5(129.56,48.29) 129.56,48.15 129.86,47.86 U1.E25 ; v5(120.18,66.27) 120.18,65.96 U1.AD61 ; v5(111.82,51.59) 111.82,51.52 112.14,51.2 U1.BA32 112.48,50.87 U1.AY30 ; U1.AN1 116.11,35.58 v5(116.11,35.58) ; U1.AN54 116.54,62.09 v5(116.64,62.09) ; U1.N43 126.06,56.78 v5(126.4,56.44) 126.74,56.79 U1.L43 ; U1.BG37 108.59,53.69 v5(108.49,53.79) ; U1.H10 127.85,40.28 v5(127.85,40.18) 127.35,39.68 U1.K8 ; v1(196.39,24.53) 196.39,23.68 197.07,23 JTAA1.6 ; U1.AA50 122.3,60.49 ; 122.3,60.49 U1.AA51 ; 122.3,60.49 v5(122.37,60.49) ; U75.1 306.04,50.88 v1(305.8,50.63) ; U1.J49 127.95,60.12 v5(127.64,60.43) 127.12,60.43 126.74,60.06 U1.L48 126.74,59.46 v5(126.39,59.1) ; v5(114.57,40.72) U1.AU11 ; v1(110.07,59.05) 110.08,59.06 U1.BD48 ; U1.U13 123.75,41.59 123.93,41.77 v5(124.22,41.77) ; U1.W8 122.63,39.87 v1(122.34,39.87) 122.11,39.87 U1.AA8 ; U1.N28 126.4,49.39 v5(126.4,49.29) 126.4,49.19 U1.L26 ; U1.BG17 108.58,43.81 v5(108.45,43.68) ; U1.BG13 108.87,41.83 108.69,41.65 v5(108.25,41.65) ; U1.N17 126.06,44.3 v5(126.4,43.96) 126.4,43.93 126.74,43.59 U1.L16 ; U1.AD20 120.8,45.57 v5(121.14,45.91) 121.25,45.91 U1.AB21 ; U1.D22 v5(130.87,46.62) ; U1.AU1 114.14,35.67 v5(114.06,35.6) ; U1.K11 127.13,41.11 v5(126.73,41.11) 126.44,41.11 U1.M11 ; U1.AT58 114.51,64.68 v5(114.41,64.78) ; U1.AH4 118.64,37.03 v1(118.67,37) ; v5(128.67,42.82) 128.46,42.61 U1.H14 ; v1(113.11,42.91) 113.09,42.89 113.09,42.7 U1.AY14 112.82,42.19 U1.AW13 ; U1.D10 130.28,40.69 v5(129.76,41.21) 129.76,41.31 U1.F13 ; U1.P18 125.04,44.89 v5(124.68,44.53) 124.58,44.53 U1.R17 ; U1.N40 126.06,54.93 v5(126.4,54.58) 126.74,54.24 U1.L38 ; v5(117.19,66.27) 117.05,66.13 U1.AL61 ; U1.AJ42 118.13,56.06 v5(117.8,56.39) 117.45,56.74 U1.AL43 117.14,56.53 117.14,56.33 U1.AM42 ; v5(126.39,59.1) 126.06,59.43 U1.N48 ; v5(126.39,59.1) 126.06,58.77 U1.N47 ; U1.AV55 113.65,62.77 v1(113.24,63.18) 113,62.94 U1.AY55 ; v5(110.04,51.16) U1.BD32 ; U1.H4 129.16,38.15 v5(129.16,38.24) 129.16,38.36 U1.G6 ; U1.AR61 115.08,65.72 115.08,66.24 v1(115.1,66.27) ; v5(112.02,35.57) 112.16,35.71 U1.BA1 ; U1.AK52 118.45,61.19 v5(118.61,61.19) 118.8,61.19 U1.AG52 U1.AF52 U1.AF51 ; U1.M4 126.68,37.65 v5(126.68,38.01) 126.59,38.01 U1.M6 ; U1.R46 124.7,58.03 v5(124.89,57.84) ; U1.A37 132.29,53.33 v5(132.37,53.25) ; U1.J55 127.95,63.16 v5(128.16,63.36) 128.44,63.64 U1.H58 ; U1.AF50 119.81,60.08 U1.AF48 119.92,59.51 v5(120.27,59.17) 119.92,58.82 U1.AF47 ; U1.F19 129.9,44.64 U1.D18 v5(130.87,44.64) ; v5(110.43,37.64) 110.13,37.94 U1.BE5 109.4,38.13 U1.BG5 109.4,38 U1.BE4 ; v5(110.43,37.64) 110.56,37.78 110.85,37.78 U1.BC5 ; v5(110.43,37.64) 110.43,36.97 U1.BD3 ; U1.AE13 120.02,41.28 v5(119.81,41.28) 119.81,40.82 119.33,40.34 U1.AG10 ; v1(151.34,26.57) 151.34,26.69 151.64,27 UH4.AW18 151.65,27.01 151.99,27.35 v1(151.99,27.47) 151.99,27.64 152.31,27.96 UH4.AV20 ; U9.6 160.19,106.3 160.76,106.87 v1(161.4,106.87) ; U1.T52 124.55,61.15 v5(124.63,61.15) ; v5(113.09,45.83) 113.41,46.14 U1.AV21 113.41,46.49 U1.AV22 ; v1(64.85,37.5) 64.85,38.44 64.54,38.75 JDIMM2.66 ; U1.AY4 112.58,37.51 112.22,37.87 v5(112.22,38.18) 112.77,38.18 112.78,38.17 113.06,38.45 U1.AW7 ; v1(132.68,37.5) 132.29,37.89 U1.A5 ; U1.AA13 122.09,41.58 v5(122.41,41.9) 122.41,42.43 U1.W15 ; v5(113.15,54.61) 113.15,54.7 U1.AV40 ; U1.D46 v5(130.89,58.47) ; v1(110.05,61.02) 110.07,61.04 U1.BD52 111.44,61.89 U1.BB53 ; U1.BG49 108.62,59.62 v1(108.45,59.79) ; U1.AJ7 118.65,38.69 v1(118.91,38.69) ; U1.AY41 112.5,55.58 v5(112.96,56.04) 112.96,56.31 U1.AW43 ; U1.AE8 120.32,39.61 119.85,39.14 119.85,39.16 v1(119.82,39.19) 119.64,39.01 U1.AG7 ; U1.AM58 116.49,64.78 v5(116.46,64.8) ; v1(115.86,42.01) 115.84,41.98 115.21,41.98 U1.AR13 114.77,42.19 U1.AT14 ; T109.1 131.09,69.68 v1(131.45,69.33) ; U1.AF53 120.05,62.44 v5(120.12,62.44) ; v5(128.93,66.24) 128.97,66.2 U1.G61 129.07,65.61 U1.E61 U1.D59 ; U1.AN33 116.08,51.61 v5(116.42,51.95) 116.76,52.3 U1.AM34 ; U1.AV34 113.09,52.51 v5(113.09,52.59) ; U1.BD12 111.35,41.28 v1(111.49,41.41) 111.49,41.57 U1.BC13 ; v5(114.61,58.04) 114.44,57.87 U1.AT45 ; U1.AM4 116.63,37.51 116.35,37.79 116.35,39.56 116.73,39.94 v5(116.9,39.94) 117.02,39.94 117.34,40.26 U1.AL10 ; U1.A53 132,61.87 v5(132.28,62.15) ; U1.AR21 114.89,45.78 v1(114.34,45.78) 114.34,45.6 U1.AT19 ; JLVDS1.13 v1(105.1,108.17) ; JLVDS1.19 v1(102.1,108.15) ; U1.P58 125.04,64.29 v5(124.62,63.87) ; U1.D50 130.77,60.45 v5(130.86,60.53) ; U1.BG41 108.7,55.67 v1(108.64,55.72) ; v1(150.06,27.47) 150.06,27.32 149.75,27.01 UH4.BC18 ; UH4.D34 168.66,34.63 v1(168.66,34.43) ; U1.AN25 116.08,48.06 v5(116.42,48.4) 116.76,48.74 U1.AM26 ; UH4.D8 168.68,22.32 v1(168.68,22.6) ; U1.AM48 116.76,59.36 v5(116.43,59.03) 116.08,58.67 U1.AN47 ; U1.G51 128.93,60.95 v5(129.37,61.39) ; U1.AR41 115.12,55.56 115.55,55.56 v5(115.59,55.51) 116.04,55.07 U1.AN40 ; v5(132.3,46.06) U1.A21 ; v5(110.08,53.15) 110.1,53.13 U1.BD36 ; v5(128.78,45.61) 128.46,45.93 U1.H21 ; v1(107.88,64.13) 108.35,63.66 U1.BG57 U1.BE58 ; U1.AL47 117.45,58.52 v5(117.78,58.19) 118.13,57.84 U1.AJ45
  BOTTOM w0.279: U1.V20 123.33,45.57 123.04,45.86 v5(122.92,45.86) 122.88,45.86 122.48,46.26 U1.W21 ; v5(124.7,45.91) 124.78,45.91 125.12,46.26 U1.P21
  BOTTOM w0.356: v1(52.98,71) 52.98,71.33 53.32,71.67 53.96,71.67 54.17,71.45 JDIMM2.167 ; v1(51.46,21.24) 51.46,21.22 52.83,19.85 JDIMM2.3 ; v1(78.71,64.45) 78.71,64.67 78.22,65.15 76.93,65.15 JDIMM1.136 ; v1(51.46,79.26) 51.46,78.94 52.13,78.27 54.06,78.27 54.28,78.05 JDIMM2.189 ; JDIMM2.185 56.36,76.85 56.62,76.58 v1(56.62,75.77) ; JDIMM2.144 64.98,64.55 65.56,63.97 v1(65.56,62.36) 65.56,62.3 64.81,61.55 JDIMM2.134 ; v1(74.77,67.28) 75.04,67.55 JDIMM1.144 ; JDIMM1.185 66.95,79.85 66.59,80.22 v1(66.59,81.91) 66.59,82.36 67.08,82.85 JDIMM1.195 ; JDIMM2.172 65.31,72.95 v1(66.02,73.66) ; JDIMM1.189 70.87,81.05 71.98,79.94 v1(71.98,79.83) ; v1(70.07,35.41) 69.51,34.85 JDIMM1.43 ; v1(72,64.45) 72,64.36 70.84,63.2 70.07,63.2 69.32,62.45 JDIMM1.127 ; JDIMM1.65 66.84,41.45 v1(66.65,41.26) 67.06,40.85 JDIMM1.63 ; JDIMM2.190 64.7,78.35 65.32,78.97 v1(65.32,79.78) 64.96,80.15 JDIMM2.196 ; v1(70.45,73.83) 70.45,73.62 69.49,72.65 JDIMM1.161 ; JDIMM1.20 75.26,27.95 74.99,28.23 v1(74.99,28.54) 74.99,30.12 75.21,30.35 JDIMM1.28 ; JDIMM2.14 64.99,23.15 v1(65.05,23.09) ; v1(71.9,24.23) 71.9,23.87 70.88,22.85 69.77,22.85 JDIMM1.3 ; v1(51.46,37.25) 51.46,37.14 52.92,35.68 53.94,35.68 54.17,35.45 JDIMM2.55 ; JDIMM1.11 69.17,25.25 69.23,25.32 70.22,25.32 70.37,25.47 v1(70.37,25.88) ; JDIMM1.155 69.2,70.85 69.32,70.73 70.25,70.73 70.48,70.96 v1(70.48,71.29) ; JDIMM1.162 77.52,72.95 77.71,73.14 78.34,73.14 78.71,72.78 v1(78.71,72.58) ; v1(78.49,82.02) 78.03,82.02 77.36,81.35 JDIMM1.190 ; v1(64.78,59.88) 64.65,59.75 JDIMM2.128 ; v1(78.33,39.68) 78.33,39.72 78.1,39.95 JDIMM1.60 ; v1(60.36,25.08) 60.36,24.78 60.64,24.5 61.94,24.5 62.39,24.95 JDIMM2.20 ; JDIMM2.32 64.93,28.55 v1(65.11,28.73) ; v1(70.45,79.83) 70.45,80.07 70.07,80.45 JDIMM1.187 ; v1(70.45,77.27) 70.45,77.6 70,78.05 JDIMM1.179 ; JDIMM1.133 67.12,64.25 66.72,64.65 v1(66.72,66) ; JDIMM1.2 75.05,22.55 v1(74.87,22.36) ; JDIMM1.13 67.11,25.85 66.83,26.13 66.83,27.41 67.07,27.65 JDIMM1.19 70.08,27.65 70.37,27.94 v1(70.37,28.42) ; JDIMM2.162 64.73,69.95 v1(65,70.22) ; JDIMM1.173 69.37,76.25 v1(70.07,75.55) ; v1(52.98,64.15) 52.98,64.51 53.32,64.85 JDIMM2.145 ; JDIMM2.26 62.24,26.75 v1(61.88,27.11) 62.13,27.35 JDIMM2.28 ; JDIMM2.161 56.66,69.65 56.89,69.42 v1(56.89,68.62) ; JDIMM2.54 64.45,35.15 64.87,35.57 v1(64.87,36.05) 64.87,36.74 64.66,36.95 JDIMM2.60 ; v1(52.98,38.77) 52.98,38.44 53.29,38.13 53.94,38.13 54.26,38.45 JDIMM2.65 ; v1(74.77,69.83) 75.24,69.35 JDIMM1.150 ; v1(52.98,79.26) 52.98,79.67 53.17,79.85 JDIMM2.195 ; JDIMM2.179 54.19,75.05 53.97,75.28 53.22,75.28 52.98,75.04 v1(52.98,74.56) ; JDIMM1.139 69.94,66.05 v1(70.1,65.88) ; JDIMM2.156 64.69,68.15 64.92,67.92 v1(64.92,67.3) 64.92,66.6 64.66,66.35 JDIMM2.150 ; JDIMM1.48 75.07,36.35 74.79,36.08 v1(74.79,35.82) 74.86,35.75 JDIMM1.46 ; JDIMM1.14 74.48,26.15 v1(74.46,26.12) ; JDIMM1.32 75.17,31.55 74.74,31.98 v1(74.74,32.86) 75.23,33.35 JDIMM1.38 ; v1(80.23,41.28) 80.23,41.96 79.05,43.14 77.79,43.14 77.38,43.55 JDIMM1.72 ; JDIMM2.11 56.32,22.25 v1(56.6,22.53) 56.28,22.85 JDIMM2.13 ; JDIMM2.139 56.3,63.05 56.69,62.66 56.69,61.17 v1(56.68,61.17) 56.6,61.25 JDIMM2.133 ; JDIMM1.184 75.86,79.55 75.3,79.55 75.03,79.82 v1(74.81,79.82) 74.81,78.14 75.2,77.75 JDIMM1.178 ; JDIMM2.178 64.99,74.75 v1(65.25,75.01) 65.25,76.1 64.8,76.55 JDIMM2.184 ; JDIMM2.19 53.64,24.65 52.98,25.3 v1(52.98,25.44) ; JDIMM2.46 64.54,32.75 v1(64.81,32.48) 64.81,30.74 64.42,30.35 JDIMM2.38 ; v1(74.75,37.88) 75.02,38.15 JDIMM1.54 ; JDIMM1.44 77.33,35.15 77.52,34.96 78.44,34.96 78.71,35.23 v1(78.71,35.54) ; JDIMM1.61 69.12,40.25 69.45,40.59 70.01,40.59 70.45,41.03 v1(70.45,41.34) ; JDIMM1.49 69.28,36.65 69.41,36.52 70.13,36.52 70.45,36.84 v1(70.45,37.11) ; v1(65.45,32.48) 65.45,32.79 64.88,33.35 JDIMM2.48 ; v1(69.99,29.75) 69.69,29.45 JDIMM1.25 ; JDIMM1.31 66.99,31.25 66.67,31.57 66.67,32.69 67.03,33.05 JDIMM1.37 69.99,33.05 70.45,33.51 v1(70.45,33.85) ; JDIMM1.156 78.16,71.15 v1(78.33,70.98) ; JDIMM1.71 70.3,43.25 71.98,41.58 v1(71.98,41.34) ; v1(56.61,67.68) 56.61,66.84 56.42,66.65 JDIMM2.151 ; JDIMM2.63 v1(56.61,37.85) 56.61,37.37 56.5,37.25 JDIMM2.61 ; v1(52.98,31.02) 52.98,30.6 53.54,30.05 JDIMM2.37 ; JDIMM2.155 53.33,67.85 52.98,68.19 v1(52.98,68.46) ; JDIMM2.153 53.33,67.25 52.98,66.9 v1(52.98,66.69) ; JDIMM1.138 78.15,65.75 78.77,66.37 v1(78.77,67.17) ; v1(53.37,72.78) 53.83,73.25 JDIMM2.173 ; v1(70.37,24.23) 70.37,24.5 70.08,24.79 69.33,24.79 69.19,24.65 69.14,24.65 JDIMM1.9 ; JDIMM1.134 74.85,64.55 v1(74.76,64.46) 74.76,63.14 75.15,62.75 JDIMM1.128 ; JDIMM1.167 66.95,74.45 66.66,74.16 v1(66.66,73.65) 66.66,70.59 67,70.25 JDIMM1.153 ; JDIMM2.136 64.59,62.15 v1(64.8,62.36) 64.41,62.75 JDIMM2.138 ; JDIMM2.43 54.06,31.85 v1(53.37,32.55) ; v1(60.74,21.01) 61.08,21.35 JDIMM2.8 64.41,21.35 64.75,21.01 64.75,19.95 64.35,19.55 JDIMM2.2 ; JDIMM1.196 75.01,83.15 v1(74.72,82.86) ; v1(70.45,39.65) 70.45,39.26 69.64,38.45 JDIMM1.55 ; JDIMM2.170 64.89,72.35 v1(65.28,71.96) 65.07,71.75 JDIMM2.168 ; v1(51.46,38.77) 51.46,38.88 52.83,40.25 JDIMM2.71 ; v1(53.37,26.83) 53.75,26.45 JDIMM2.25 ; JDIMM1.170 77.39,75.35 77.75,75.71 78.36,75.71 78.71,75.37 v1(78.71,75.12) ; JDIMM2.44 62.02,32.15 61.65,31.78 60.6,31.78 60.36,32.01 v1(60.36,32.37) ; v1(52.98,77.1) 52.98,77.37 53.31,77.69 53.96,77.69 54.19,77.45 JDIMM2.187 ; JDIMM2.72 61.31,40.55 58.84,38.08 v1(58.84,37.96) ; v1(78.71,30.27) 78.71,29.95 78.45,29.7 77.47,29.7 77.42,29.75 JDIMM1.26 ; v1(52.98,34.71) 52.98,34.56 53.89,33.65 JDIMM2.49 ; v1(70.47,67.18) 70.47,67.49 70.11,67.85 JDIMM1.145 67.17,67.85 66.89,68.13 66.89,69.31 67.23,69.65 JDIMM1.151 ; JDIMM2.127 52.27,59.45 51.46,60.26 v1(51.46,60.55) ; JDIMM1.168 75.48,74.75 v1(74.78,75.45) 75.29,75.95 JDIMM1.172 ; v1(78.57,23.41) 78.42,23.41 77.48,24.35 JDIMM1.8 ; JDIMM2.9 54.13,21.65 52.98,22.8 v1(52.98,22.9)
  BOTTOM w0.381: v1(138.02,72.7) 137.93,72.62 UC1.3 ; v1(262.15,53.48) U39.11 U37.11 ; U37.18 U39.18 265.49,53.48 v1(265.26,53.25) ; U37.4 U39.4 v1(262.1,48.93) ; U37.25 U39.25 v1(265.26,48.93) ; v1(258.83,47.1) 259.36,47.63 U37.2 U39.2 ; v1(262.13,51.53) U39.8 U37.8 ; U7.3 187.81,26.71 v1(188.02,26.51) ; UC2.3 107.02,85.76 v1(106.91,85.86) ; U37.1 U39.1 261.73,46.98 v1(262.11,47.36)
  BOTTOM w0.406: U50.3 137.11,21.21 v1(137.06,21.16) ; v1(181.7,10.14) 181.51,9.95 UH5.3 ; UH3.3 182.63,17.3 v1(182.52,17.18)
  BOTTOM w0.432: Q57.4 163.4,79.26 163.79,78.86 v1(164.02,78.86) ; Q51.1 v1(208.5,3.25) ; Q19.4 133.61,96.91 134,96.52 v1(134,95.06) ; Q19.1 136.56,98.21 v1(136.92,98.57) ; Q51.4 207.2,4.75 206.96,4.99 v1(206.96,5.35) ; v4(178.82,6.98) 178.95,6.85 Q52.1 178.68,3.78 177.38,2.48 Q52.4 ; v1(305.8,46.99) 305.48,46.67 Q35.1 ; R950.2 164.89,69.36 Q78.4 164.89,70.84 v1(164.63,71.1) ; v1(305.97,43.58) 306.46,43.58 306.78,43.9 Q35.4 ; v1(234.1,55.37) Q39.1 ; v1(235.4,54.95) Q39.4 ; Q57.1 v1(164.03,80.56)
  BOTTOM w0.457: v1(237.67,49.97) 237.38,49.68 Q43.4 ; v1(238.13,50.49) 238.61,50.98 Q43.1 ; RH145.1 173.86,31.59 v1(172.99,31.59) ; v1(189.47,27.71) 190.05,28.3 U4.2
  BOTTOM w0.508: PC304.2 PR304.2 96.45,2.37 v1(96.26,2.56) ; C1216.2 v1(74.26,96.99) ; v1(64.32,89.19) 63.94,88.81 Q26.3 ; v1(105.8,58.53) 105.29,59.04 RC42.2 ; RH48.2 176.8,16.82 v1(176.7,16.92) ; v1(179.65,44.65) 180.07,44.23 CH43.2 ; JMINI2.43 245.8,60.23 v1(245.52,60.51) ; CH105.2 141.31,35.79 v1(140.57,36.52) ; v1(11.59,66.88) 10.95,66.88 R1641.2 C1202.2 ; v1(283.43,35.94) 283,35.51 JMINI1.35 ; v1(120.83,26.26) 121.79,25.31 PC1154.2 121.79,24.58 v1(121.23,24.03) ; v1(150.99,13.63) 150.94,13.59 RH270.1 ; v1(77.4,93.37) 77.92,92.85 R1128.2 ; v1(234.67,44.93) 234.99,45.26 R730.2 ; Q69.3 225.22,50.79 v1(225.62,51.19) 226.05,51.62 C764.2 ; PC15.2 12.45,58.96 v1(12.59,58.82) ; JMINI2.4 264.6,65.04 v1(264.47,64.91) ; v1(13.3,4.4) PU1304.4 ; JMINI1.18 289.8,43.95 v1(290.02,44.17) ; v1(170.12,95.3) 169.77,95.65 C278.2 ; CH36.2 175.77,42.73 CH34.2 CH35.2 174.33,42.72 v1(173.7,43.34) ; v1(121.18,70.77) 121.99,69.96 PC1115.2 ; PC506.2 125.3,10.58 v1(124.74,11.14) ; CH65.2 183.4,26.73 182.61,27.52 v1(182.4,27.52) 181.61,26.73 CH64.2 ; C1308.2 35.21,12.85 v1(35.65,12.41) ; RH79.2 152.6,16.1 v1(153.18,16.68) ; v1(167.01,51.6) 166.93,51.67 D23.1 ; Q62.3 187.6,19.02 187.83,19.25 v1(188.21,19.25) ; v1(298.42,44.24) 298.6,44.06 JMINI1.4 ; v1(310.08,66.41) 309.67,66.82 C1104.1 ; Q48.3 305.57,65.92 305.24,66.25 v1(305.24,66.8) ; JMINI2.34 249.4,66.01 v1(249.83,65.58) ; v1(50.04,18.1) JDIMM2.205 ; JDIMM1.66 75,41.75 v1(74.73,41.48) ; PC1116.2 125.29,70.05 v1(124.5,70.84) ; v1(163.98,77.14) 164.01,77.16 R1617.2 C770.2 ; v1(12.69,5.88) PR1348.2 ; v1(238.87,76.4) 238.87,75.65 238.22,75.01 R752.1 ; CH98.2 RH278.2 194.76,21.52 v1(195.13,21.89) ; RC54.2 RC51.2 v1(136.64,66.51) ; v1(139.26,22.32) 139.78,21.8 CH97.2 ; C1332.2 107.49,89.87 v1(107.82,90.19) ; C246.2 140.24,101.66 139.81,102.09 v1(139.81,103.11) ; v1(145.57,40.12) 145.32,40.37 CH93.2 ; JLVDS1.43 110.6,105.26 v1(109.61,106.26) ; R1677.2 v1(309.84,54.87) ; v1(261.71,24.84) 261.25,25.3 JMINI3.34 ; PC4.2 PC5.2 56.29,9.87 v1(55.76,10.4) ; v1(246.26,94.52) 246.26,93.98 246.64,93.59 D87.1 ; U76.2 v1(79.5,94.05) ; v1(261.89,27.77) 261.89,28.15 261.55,28.5 JMINI3.26 ; PC1338.2 PR1346.2 v1(19.73,12.62) ; RH112.1 141.02,27.55 140.36,28.22 v1(140.36,28.56) ; v1(285.97,31.85) 285.79,31.67 C628.2 ; v1(283.58,44.17) 283.4,43.99 JMINI1.34 ; v1(67.49,11.68) 67.49,11.68 CD7.2 CD8.2 ; v1(138.71,86.32) PR705.2 ; JLVDS2.3 v1(127.91,108.7) ; JMINI1.50 277,41.81 v1(276.22,41.03) ; C613.2 278.94,29.92 278.66,30.2 v1(278.66,30.69) ; v1(97.61,97.7) 97.61,101.59 JLVDS1.45 ; JMINI2.26 252.6,65.59 v1(252.68,65.5) ; v1(139.07,98.56) 139.55,99.04 R1632.2 ; JMINI1.29 285.4,35.49 v1(285.83,35.93) 286.2,35.56 JMINI1.27 ; v1(103.98,2.54) 103.36,2.54 PC305.2 ; v1(271.28,24.01) 271.28,24.48 270.86,24.9 JMINI3.35 ; v1(186.75,38.21) 187.11,37.85 CH4.1 ; PC112.2 255.22,13.9 v1(255.43,14.11) ; JMINI3.18 258.63,31.7 258.3,31.36 v1(258.3,30.68) ; C1245.2 18.57,57.44 18.24,57.77 v1(16.81,57.77) ; v1(158.31,13.88) 157.98,13.88 157.62,14.23 RH46.2 156.66,14.83 CH72.2 ; PC86.1 148.19,2.75 v1(148.58,3.14) 148.98,2.73 PC87.2 ; v1(185.03,15.3) 185.34,15 R1621.2 ; v1(271.44,55.2) 271.3,55.06 C552.2 271.29,54.25 C551.2 ; v1(169.19,99.86) 168.93,99.59 C219.2 ; R921.2 192.52,9.94 C769.2 R910.2 190.38,10.28 v1(190.89,10.79) ; v1(104.03,34.68) CC175.2 CC174.2 ; R938.2 165.29,64.68 v1(164.53,64.68) ; CH63.2 184.03,35.49 CH71.2 181.88,35.49 v1(181.41,35.96) ; 272.34,65.5 v1(272.35,65.5) ; 272.34,65.5 271.73,64.89 C600.2 ; 272.34,65.5 271.66,66.19 C605.2 ; C288.2 185.35,30.9 v1(185.74,31.29) ; JSD1.10 296.82,19.08 v1(297.15,18.76) ; PC1160.2 v1(121.72,28.65) ; JSIM1.5 v1(286.51,27.79) ; QH8.3 188.92,22.14 v1(189.14,21.91) 189.31,22.07 CH107.2 ; v1(150.34,84.92) 149.95,84.92 149.59,84.55 PC741.2 ; PC101.2 PR106.2 247.67,8.26 247.26,7.86 v1(247.26,6.82) ; C1220.2 69.87,100.33 v1(70.44,100.9) ; JMINI2.27 252.2,59.83 v1(251.81,60.22) 251.4,59.82 JMINI2.29 ; v1(17.61,42.16) 17.61,42.94 C675.2 ; C1218.2 75.13,97.14 v1(75.28,96.99) ; v1(99.64,19.27) 99.48,19.11 RC73.2 ; JMINI1.53 v1(302.65,33.11) ; v1(153.45,55.33) 154.03,55.33 154.89,54.47 156.93,54.47 158.7,56.25 PC408.2 ; C1231.2 v1(303.52,52.99) ; v1(287.06,41.38) 286.6,41.85 JMINI1.26 ; C772.2 140.56,41.42 v1(140.77,41.64) ; v1(233.38,56.3) 233.11,56.3 232.71,55.89 Q56.3 ; JSIM1.11 272.53,21.54 v1(272.98,21.99) ; v1(156.51,70.93) 156.97,70.93 PC407.2 ; JFAN1.5 153.27,93.53 v1(152.74,93) ; RC16.2 119.12,31.42 119.12,31.41 119.12,31.37 119.03,31.28 v1(118.98,31.28) ; v1(253.43,6.99) 253.43,8.1 252.98,8.56 251.58,8.56 PC107.2 PR105.1 ; CC140.2 137.97,70.09 v1(137.97,69.66) ; CH54.2 160.56,12.79 v1(160.24,12.47) ; CH110.2 v1(170.82,48.97) RH342.2 ; C1330.2 106.09,88.07 C298.2 105.91,88.97 v1(105.44,88.5) ; v1(140.73,2.22) 140.63,2.32 PR86.1 ; C608.2 247.35,54.53 v1(246.31,54.53) C604.2 ; R749.1 237.71,77.48 238.59,77.48 v1(238.87,77.75) 238.37,78.26 R751.1 ; PC306.2 100.69,8.33 v1(101.16,8.8) ; PC1340.2 12.05,4.04 v1(12.5,3.59) ; v1(270.6,21.97) 270.34,21.7 JMINI3.43 ; v1(8.46,8.56) PC1339.2 PR1347.2 ; v1(267.81,57.17) 268.65,58.01 JMINI2.53 ; v1(21.62,41.7) 22.08,42.16 C676.2 ; v1(293.19,4.85) 292.43,5.6 JSIM1.12 ; v1(273.89,5.45) 272.9,5.45 272.53,5.82 JSIM1.13 ; v1(126.23,70.8) 125.32,71.71 PC1118.2 ; v1(305.8,48.76) 305.66,48.9 C1230.2 ; U52.4 207.97,28.01 207.66,27.7 v1(198.23,27.7) ; U40.2 286.75,30.22 C629.2 v1(285.97,30.17) ; C631.2 293.18,31.78 v1(293.24,31.84) ; JMINI1.15 294.2,35.45 v1(294.59,35.85) ; v1(127.86,7.58) 127.92,7.52 PC82.1 ; v1(140.52,32.28) 141.23,32.99 RH91.2 ; v1(81.37,87.21) 81.88,86.7 JDIMM1.206 ; C762.2 207.37,5.75 v1(206.96,5.35) ; v1(131.41,2.85) 132.53,2.85 PR85.2 132.68,3.3 132.48,3.5 v1(131.39,3.5) ; CC176.2 110.55,18.93 110.21,19.27 v1(109.9,19.27) ; v1(193.68,36.23) 193.45,36.46 ME1.1 ; v1(260.72,57.15) 260.2,57.67 JMINI2.15 ; C766.2 v1(231.12,53.57) ; CH73.2 176.64,41.56 v1(176.84,41.77) ; C477.2 R1638.2 307.6,47.24 v1(307.6,47.67) ; v1(235.39,58.75) 235.68,58.45 R1620.2 ; v1(240.92,50.62) R733.2 ; v1(239.35,61.34) 239.35,61.05 239.35,61.05 JMINI2.54 ; Q22.3 149.5,97.73 150.02,98.26 151.92,98.26 152.29,97.89 v1(152.29,97.46) ; RH47.2 170.66,13.97 v1(170.37,13.68) ; JFAN1.1 159.12,95.69 159.61,95.2 v1(161.02,95.2) ; D73.1 202.85,12.02 v1(202.63,11.8) ; JMINI1.21 288.6,35.71 v1(288.31,36) ; PC80.2 v1(136.48,10.1) ; PR103.1 v1(250.17,3.73) ; RH132.1 165.03,47.48 v1(165.09,47.42) 165.03,47.35 RH133.1 ; JSD1.6 v1(293.63,11.57) ; v1(158.27,83.25) 158.87,83.25 v4(159.8,84.17) 159.93,84.3 Q60.3 ; R1610.2 C771.2 188.61,2.87 v1(188.58,2.83) ; v1(143.99,2.22) PC92.1 ; v1(138.21,89.75) 138.58,89.38 PC711.2 ; v1(97.99,15.42) 98.29,15.72 CC135.2 ; C1209.2 v1(9.47,78.47) ; YH2.4 160.61,48.84 v1(160.33,48.56) 160.33,47.66 160.66,47.33 CH19.1 ; v1(118.32,23.96) 118.42,24.06 PC1125.2 118.42,25.36 v1(117.56,26.22) ; JMINI3.50 258.06,18.9 v1(257.22,19.75) ; RH78.2 155.29,16.42 v1(155.26,16.44) ; v1(137.74,26.77) 137.32,26.77 137.11,26.98 137.11,27.23 137.31,27.43 Q70.3 ; R404.2 v1(166.53,104.52) ; D72.1 v1(314.98,62.1) ; C651.2 v1(315.02,49.49) ; JLVDS2.12 v1(118.91,108.73) ; JMINI3.29 269.78,27.3 v1(270.19,27.71) 269.79,28.1 JMINI3.27 ; 136.92,40.6 v1(136.29,40.6) ; CH5.1 187.6,41.92 187.92,42.25 v1(188.19,42.25) ; C1322.2 217.45,2.3 v1(216.87,2.3) ; v1(256.23,52.39) 257.03,52.39 R660.2 C553.2 ; v1(163.39,52.44) 163.68,52.14 YH2.2 ; JMINI3.21 266.92,30.5 v1(266.44,30.02) ; R1613.1 C715.2 304.87,60.08 v1(305.36,59.59) ; v1(122.85,70.76) 121.99,71.63 PC1112.2 ; JLVDS1.41 v1(115.23,105.61) ; JLVDS1.46 92.1,104.84 v1(92.64,105.38) ; JMINI3.4 261.86,40.5 v1(261.96,40.6) ; PC1114.2 128.53,71.02 v1(128.53,70.69) 129.28,69.94 PC1117.2 ; v1(263.7,56.65) 263.11,56.65 262.6,57.16 JMINI2.9 ; JMINI2.21 254.6,57.38 v1(254.68,57.3) ; PR402.1 v1(156.58,69.5) ; v1(233.79,58.03) R716.2 ; v1(176.74,32.48) 176.51,32.25 RH151.2 ; v1(71.71,96.96) 71.21,97.46 C1217.2 ; C296.2 140.9,98.57 v1(140.67,98.35) ; R1618.2 228.01,53.57 v1(227.59,53.15) ; v4(178.82,6.98) 178.44,7.35 v1(177.4,7.35) ; v1(277.62,28.88) JSIM1.9 ; PR104.2 v1(249.15,3.74) ; Q53.3 303.91,58.28 v1(303.52,58.67) ; PC508.2 122.32,2.51 v1(122.24,2.44) ; C476.2 313.48,47 v1(313.38,46.9) ; PC1337.2 v1(31.36,3.4) ; RH49.2 176.08,14.16 v1(175.59,13.66) ; CD2.2 CD1.2 68.45,11.71 v1(68.41,11.68) ; C787.2 v1(69.58,98.03) ; JMINI2.50 243,65.93 v1(242.53,65.46) ; C1221.2 v1(70.53,98.89) ; CD23.2 CD29.2 CD30.2 ; v1(145.26,16.09) PC74.2 ; CH3.2 177.03,28.14 v1(177.11,28.22) ; JMINI1.9 296.6,35.51 v1(296.25,35.86) ; C616.2 v1(293.82,30.22) ; v1(177.48,31.21) 177.48,31.71 RH31.1 CH101.2 ; U53.4 v1(211.81,21.38) ; v1(92.81,2.6) 93.04,2.37 PR305.2 ; v1(254.11,71.43) 255.05,70.49 255.05,68.49 255.8,67.74 JMINI2.18 ; v1(131.21,105.38) JLVDS2.13 ; C292.2 134.36,103.42 C243.2 ; C768.2 168.56,84.81 R919.2 168.38,85.58 v1(168.51,85.71) ; RH131.1 165.94,46.66 v1(165.94,47.4) 165.94,48.01 RH134.1 ; v1(104.16,36.56) 104.59,36.13 RC97.1 ; PC743.2 152.75,86.07 v1(153.27,85.54) PC737.2 ; v1(117.61,105.31) JLVDS2.14 ; v1(184.55,8.47) 184.33,8.68 C761.2 ; JFAN1.6 166.77,93.53 167.08,93.22 v1(167.48,93.22) ; v1(210.57,39.14) 210.97,39.14 C746.2 ; CH18.1 163.67,47.14 163.86,46.95 163.86,45.62 163.43,45.18 163.43,43.09 v1(163.23,42.89) ; C44.2 C45.2 v1(258.84,48.97) ; D9.1 83.1,96.8 82.61,97.29 v1(81.77,97.29) ; D2.2 169.26,101 v1(169.26,100.49) ; C1206.2 C1207.2 v1(9.45,74.87) ; CE4.2 255.03,54.33 v1(255.03,53.78) ; C243.2 134.23,103.43 v1(132.28,105.38) ; C243.2 C293.2 ; PC78.2 141.38,15.88 v1(141.51,16.01) ; JMINI3.9 270.09,38.5 270.45,38.14 v1(270.45,37.15) 270.45,36.72 269.83,36.1 JMINI3.15 ; R1628.2 243.36,45.84 v1(243.77,46.25) ; v1(242.18,56.89) 241.55,56.26 C632.2 ; PR410.2 v1(74.08,4.72) ; C337.2 v1(81.91,99.76) ; v1(242.6,53.57) 242.32,53.84 R715.2 ; C338.2 v1(81.1,97.28) ; v1(242.77,48.31) C650.2 ; v1(134.49,45.3) 134.99,45.81 C773.2 ; JDIMM2.206 v1(50.52,83.7) ; CH2.2 175.66,29.14 v1(175.47,28.95) ; PC105.2 PC104.2 v1(243.06,7.17) ; v1(257.18,56.84) 257.26,56.77 257.26,55.51 C554.2 ; PC1336.2 v1(32.33,3.41) ; C1311.2 C299.2 148.47,109.38 v1(148.19,109.1) ; C982.2 v1(17.63,27.18) ; v1(9.45,72.06) C1205.2 ; v1(280.22,35.86) 279.8,35.44 JMINI1.43 ; JMINI2.35 v1(249,60.55) ; C1233.2 v1(265.85,95.08) ; JLVDS2.6 v1(124.91,108.67) ; JMINI1.54 273.35,36.57 273.03,36.89 v1(273.03,37.17) ; C1210.2 v1(9.47,77.61) ; C1279.2 v1(85.22,13.18) ; C475.2 v1(314.32,41.59) ; v1(188.02,26.51) 188.02,26.36 187.61,25.96 186.9,25.96 186.61,25.67 Q67.3 ; JDIMM2.31 56.22,28.25 v1(56.73,28.77) ; v1(118.51,26.29) 118.42,26.38 PC1159.2 118.42,28.2 v1(118.01,28.61) ; v1(105.4,97.67) 105.1,97.98 JLVDS1.44 ; v1(31.02,87.98) 30.83,87.79 Q72.3 ; R406.2 C282.2 152.9,102.68 v1(152.12,103.45) ; C767.2 190.56,17.64 191.12,17.08 v1(191.52,17.08) ; v1(270.39,15.25) JMINI3.54 ; v1(187.76,33.97) 188.36,33.37 C289.2 ; C1219.2 v1(78.15,97.01) ; C720.2 141.93,24.09 v1(142.13,23.89) ; D90.1 v1(21.87,46.48) ; v1(134.24,109.53) 133.76,109.05 C301.2 133.76,107.56 C1331.2 ; v1(80.48,22.13) 81.5,21.1 JDIMM1.205 ; C630.2 v1(293.82,29.21) ; C1278.2 v1(88.07,13.18) ; v1(167.91,13.84) 167.91,14.42 167.52,14.82 RH271.2 ; JLVDS1.42 v1(87.48,105.53) ; Q68.3 201.66,11.16 201.95,11.45 v1(201.95,11.74) ; C1248.2 v1(270.44,11.43) ; C602.2 271.82,68.03 v1(272.37,68.03) ; CMOS1.1 192.04,33.53 v1(191.88,33.69) ; R913.2 230.8,45.58 v1(231.36,45.02) ; C1222.2 v1(64.6,101.39) ; PC81.1 v1(129.89,7.58) ; C274.2 166.03,100.24 v1(166.79,100.24) ; v1(209.52,12.94) 209.52,13.61 C745.2 ; C1223.2 v1(66.68,100.7) ; RC53.2 v1(135.93,68.06) ; C300.2 148.87,107.79 v1(148.89,107.81) ; CH52.2 140.28,34.36 v1(139.85,34.8) ; v1(272.35,67.38) 272.21,67.24 C607.1 ; CH92.2 v1(138.91,36.65) ; JSIM1.10 v1(291.18,19.4) ; CD30.2 CD24.2 ; CD30.2 v1(57.64,11.5) ; R403.2 v1(166.44,101.79) ; C1167.2 v1(316.3,47.04) ; JLVDS2.9 v1(121.91,108.69) ; PC1329.2 v1(61.63,10.51) ; v1(145.92,16.08) 146.46,15.53 PC75.1 ; v1(136.62,64.73) RC52.2 ; C654.2 v1(312.93,55.66) ; v1(138.18,95.17) Q20.3 ; JMINI3.53 269.21,44.55 v1(270.72,43.04) ; v1(256.44,47.08) R659.2 ; v1(272.06,49.11) C550.2 ; v1(272.08,51.83) 271.63,52.28 CE3.2 ; v1(11.26,60.45) 11.03,60.22 U77.2 ; PR1316.2 v1(27.51,5.94) ; R1619.2 v1(205.25,4.04) ; v1(104.06,88.61) 104.41,88.96 104.41,89.8 C1333.2 ; PC307.2 v1(92.46,9.69) ; v1(280.18,30.71) 280.71,30.71 C614.2 ; PR407.1 v1(157.76,69.49)
  vias: v1(2.82,60.78) v1(3.12,62.72) v1(4.79,59.38) v1(5.02,63.32) v1(6.42,60.42) v1(6.53,62.23) v1(7.08,68.03) v1(7.08,67.21) v1(7.84,57.6) v1(8.35,87.02) v1(8.63,88.5) v1(9.3,85.3) v1(9.81,57.6) v1(10.27,89.39) v1(11.78,85.24) v1(12.53,88.05) v1(13.94,57.74) v1(14.46,44.05) v1(15.46,57.74) v1(15.65,44.03) v1(16.01,45.37) v1(17.84,23.44) v1(17.82,22.64) v1(17.84,21.94) v1(17.86,21.12) v1(18.34,25.63) v1(18.36,24.88) v1(18.38,23.91) v1(18.4,23.11) v1(18.41,22.26) v1(18.4,21.57) v1(20.02,4.51) v1(20.12,2.73) v1(20.92,53.05) v1(21.17,75.55) v1(21.24,52.49) v1(21.42,74.95) v1(21.56,53.05) v1(21.81,75.55) v1(21.77,14.4) v1(21.77,13.76) v1(21.95,5.75) v1(21.96,1.78) v1(22.41,14.4) v1(22.41,13.76) v1(22.46,74.13) v1(22.46,73.49) v1(22.46,72.86) v1(23.12,73.89) v1(23.12,73.25) v1(23.61,18.65) v1(23.63,17.96) v1(23.7,2.78) v1(23.98,3.97) v1(25.05,46.66) v1(26.05,48.79) v1(26.31,77.73) v1(27.03,27.51) v1(26.98,22.93) v1(27.34,23.81) v1(28.26,81.42) v1(28.47,49.68) v1(28.67,63.84) v1(28.67,63.21) v1(28.99,39.82) v1(28.96,34.99) v1(29.3,63.84) v1(29.3,63.21) v1(29.52,19.54) v1(29.94,60.09) v1(29.94,59.26) v1(30,65.75) v1(30,65.11) v1(30,64.48) v1(30,63.84) v1(30,63.21) v1(29.95,58.51) v1(30.16,19.54) v1(30.46,81.34) v1(30.64,65.75) v1(30.64,65.11) v1(30.64,64.48) v1(30.64,63.84) v1(30.64,63.21) v1(31.27,65.11) v1(31.27,64.48) v1(31.27,63.84) v1(31.27,63.21) v1(31.34,39.81) v1(31.39,37.41) v1(32.82,45.45) v1(32.82,44.82) v1(33.8,39.83) v1(33.78,37.38) v1(33.81,35) v1(34.13,25.61) v1(37.95,68.27) v1(37.95,67.64) v1(38.04,65.12) v1(38.04,64.39) v1(38.68,4.29) v1(38.68,3.59) v1(38.68,2.93) v1(38.66,2.25) v1(38.78,65.11) v1(38.78,64.39) v1(42.25,3.44) v1(42.27,4.1) v1(42.91,4.1) v1(42.88,3.44) v1(43.54,4.1) v1(43.52,3.44) v1(47.02,4.21) v1(47.02,3.58) v1(47.66,4.21) v1(47.66,3.58) v1(48.29,4.21) v1(48.29,3.58) v1(51.08,72.78) v1(51.08,62.46) v1(51.08,32.55) v1(51.08,26.83) v1(51.46,77.1) v1(51.46,74.56) v1(51.46,71) v1(51.46,68.46) v1(51.46,66.69) v1(51.46,64.15) v1(51.46,52.52) v1(51.46,34.71) v1(51.46,31.02) v1(51.46,28.48) v1(51.46,25.44) v1(51.46,22.9) v1(52.22,58.05) v1(52.22,55.76) v1(52.22,49.27) v1(52.22,47.28) v1(52.22,45.37) v1(52.22,43.34) v1(53.04,37.27) v1(52.98,28.48) v1(52.98,21.24) v1(53.37,62.46) v1(58.46,21.01) v1(58.66,80.11) v1(58.66,69.54) v1(58.84,34.91) v1(58.84,32.37) v1(58.84,29.65) v1(58.84,27.11) v1(58.84,25.08) v1(58.84,22.54) v1(58.84,19.42) v1(59.04,78.3) v1(59.04,75.76) v1(59.04,73.95) v1(59.04,71.44) v1(59.04,67.76) v1(59.04,65.21) v1(59.04,62.78) v1(59.22,36.43) v1(59.6,41.87) v1(59.68,60.31) v1(59.68,56.97) v1(59.68,55.1) v1(59.68,51.2) v1(59.68,48.45) v1(59.68,46.48) v1(59.68,43.93) v1(60.44,52.69) v1(60.36,37.96) v1(60.36,34.91) v1(60.36,29.65) v1(60.36,27.11) v1(60.36,22.54) v1(60.36,19.42) v1(60.56,78.3) v1(60.56,75.76) v1(60.56,73.98) v1(60.56,71.44) v1(60.56,67.76) v1(60.57,65.21) v1(60.57,62.78) v1(60.72,110.87) v1(60.94,80.11) v1(60.94,69.54) v1(60.99,108.57) v1(61.5,36.43) v1(62.48,107.76) v1(62.71,111.96) v1(63.33,11.27) v1(63.28,4.12) v1(63.29,3.48) v1(63.29,2.79) v1(63.3,2.16) v1(64.34,108.7) v1(64.6,110.7) v1(65.09,93.14) v1(66.53,93.14) v1(66.71,108.32) v1(67.77,91.36) v1(69.67,91.36) v1(70.37,31.31) v1(70.48,69.75) v1(71.22,62.03) v1(71.22,59.54) v1(71.22,57.26) v1(71.22,52.98) v1(71.22,50.54) v1(71.22,48.61) v1(71.22,46.9) v1(71.9,31.31) v1(71.9,28.42) v1(71.9,25.88) v1(71.98,82.93) v1(71.98,77.27) v1(71.98,73.83) v1(72,71.29) v1(72,69.75) v1(71.98,54.04) v1(71.98,39.65) v1(71.98,37.11) v1(71.98,33.85) v1(72.06,67.18) v1(72.28,29.75) v1(72.36,75.55) v1(72.39,65.88) v1(72.36,35.41) v1(74.03,93.37) v1(75.8,93.37) v1(78.72,77.84) v1(78.71,69.71) v1(78.68,44.47) v1(78.71,41.28) v1(78.71,38.08) v1(78.71,32.81) v1(78.75,27.86) v1(78.87,80.38) v1(78.95,25.32) v1(78.95,22.13) v1(79.47,59.75) v1(79.47,57.26) v1(79.47,52.93) v1(79.47,50.57) v1(79.47,48.28) v1(79.47,46.45) v1(80.11,62.04) v1(80.25,77.84) v1(80.23,75.12) v1(80.23,72.58) v1(80.23,69.71) v1(80.23,64.45) v1(80.23,54.53) v1(80.23,38.08) v1(80.23,35.54) v1(80.23,32.81) v1(80.23,30.27) v1(80.29,67.17) v1(80.27,27.86) v1(80.4,83.19) v1(80.4,80.38) v1(80.48,25.32) v1(80.61,70.98) v1(80.61,39.68) v1(80.78,82.02) v1(80.86,23.41) v1(82.28,39.61) v1(82.91,39.61) v1(83.55,39.61) v1(84.23,46.42) v1(84.18,39.61) v1(84.8,104.04) v1(84.8,103.21) v1(84.87,46.42) v1(85.5,46.42) v1(85.93,108) v1(85.86,39.58) v1(86.14,46.42) v1(86.45,91.21) v1(86.49,39.58) v1(87.13,39.58) v1(87.31,94.41) v1(87.76,39.58) v1(88.31,21.19) v1(97.1,7.63) v1(97.05,6.56) v1(97.05,5.78) v1(97.74,6.54) v1(97.74,5.78) v1(99.24,103.06) v1(99.28,101.11) v1(99.36,9.67) v1(99.36,9.04) v1(100.67,104.1) v1(100.68,102) v1(102.44,102.4) v1(104.58,62.04) v1(106.03,40.58) v1(106.33,6.75) v1(106.55,43.7) v1(106.62,4.49) v1(107.7,11.46) v1(107.7,10.82) v1(108.32,3.71) v1(108.37,13.14) v1(108.41,11.22) v1(108.36,8.07) v1(110.31,66.95) v1(110.46,6.73) v1(110.46,4.8) v1(112.02,32.99) v1(112.49,69.97) v1(114.19,83.16) v1(114.56,79.27) v1(114.89,83.16) v1(114.9,2.88) v1(114.92,2.23) v1(115.03,78.84) v1(115.16,83.82) v1(115.49,79.28) v1(115.6,2.88) v1(115.61,2.23) v1(115.87,31) v1(116.24,2.88) v1(116.25,2.23) v1(116.72,69.26) v1(116.87,2.88) v1(116.88,2.23) v1(117.51,2.88) v1(117.52,2.23) v1(118.14,2.88) v1(118.15,2.23) v1(119.18,83.84) v1(119.18,83.18) v1(119.44,105.85) v1(121.42,105.85) v1(122.23,13.29) v1(122.34,19.25) v1(122.42,105.92) v1(122.89,13.29) v1(123.53,13.29) v1(124.59,97.18) v1(124.75,26.36) v1(125.05,96.7) v1(125.08,95.74) v1(125.44,105.88) v1(125.4,26.36) v1(125.51,97.18) v1(125.53,96.26) v1(125.94,3.16) v1(125.99,96.72) v1(126.01,95.76) v1(126.03,26.36) v1(126.45,97.2) v1(126.45,96.26) v1(126.9,96.72) v1(126.9,95.76) v1(127.41,105.83) v1(127.36,97.2) v1(127.39,96.29) v1(127.48,13.99) v1(127.84,96.75) v1(127.84,95.81) v1(127.85,20.7) v1(128.27,97.24) v1(128.3,96.29) v1(128.43,101.25) v1(128.35,95.43) v1(128.78,96.8) v1(128.81,95.88) v1(128.82,84.45) v1(129.05,83.28) v1(129.05,80.67) v1(129.24,97.24) v1(129.27,96.36) v1(129.29,95.43) v1(129.46,84.45) v1(129.72,96.82) v1(129.75,95.88) v1(129.76,93.18) v1(130.18,97.27) v1(130.18,96.36) v1(130.21,95.43) v1(130.38,101.23) v1(130.4,92.8) v1(130.64,96.82) v1(130.66,95.88) v1(131.03,93.18) v1(131.11,97.27) v1(131.12,96.39) v1(131.15,95.45) v1(131.11,9.4) v1(131.54,92.8) v1(131.58,96.84) v1(131.6,95.91) v1(132.12,95.4) v1(132.11,93.18) v1(132.17,96.28) v1(132.75,95.7) v1(132.75,92.8) v1(133.22,95.06) v1(133.25,93.18) v1(134.78,89.49) v1(134.78,88.73) v1(134.78,87.97) v1(134.93,83.65) v1(136.24,58.82) v1(136.24,51.33) v1(136.24,47.39) v1(136.3,55.08) v1(136.91,107.83) v1(137.29,109.13) v1(137.85,106.14) v1(138.14,31.11) v1(138.05,3.06) v1(138.65,51.27) v1(138.79,31.11) v1(138.99,109.99) v1(140.04,20.83) v1(140,19.03) v1(140.18,106.13) v1(140.42,18.51) v1(140.59,109.18) v1(140.96,18.84) v1(141.14,107.73) v1(141.38,77.78) v1(141.36,77.15) v1(142.02,77.76) v1(142.02,77.12) v1(142.02,76.49) v1(142.35,75.88) v1(142.35,75.24) v1(142.33,38.95) v1(142.33,37.53) v1(142.65,77.76) v1(142.65,77.12) v1(142.65,76.49) v1(143.12,85.43) v1(143.12,83.91) v1(143.3,77.76) v1(143.3,77.12) v1(143.3,76.49) v1(143.49,22.84) v1(143.64,7.33) v1(143.67,8.8) v1(143.93,77.76) v1(143.93,77.12) v1(143.93,76.49) v1(144.25,91.65) v1(144.39,84.44) v1(144.43,8.06) v1(144.57,77.76) v1(144.57,77.12) v1(144.57,76.49) v1(145.06,85.75) v1(145.08,22.34) v1(145.1,8.79) v1(145.08,7.29) v1(145.19,91.65) v1(145.22,77.76) v1(145.22,77.12) v1(145.22,76.49) v1(145.7,85.15) v1(145.68,84.11) v1(145.71,83.12) v1(145.85,77.76) v1(145.85,77.12) v1(145.85,76.49) v1(147.2,9.15) v1(147.21,8.52) v1(147.65,49.88) v1(147.65,48.61) v1(147.69,54.82) v1(147.69,54.18) v1(147.69,53.52) v1(147.86,61.3) v1(148.1,29.49) v1(148.16,39.33) v1(148.15,31.54) v1(148.49,61.3) v1(148.75,30.51) v1(148.67,23.5) v1(148.81,38.44) v1(148.82,37.45) v1(148.76,29.49) v1(148.79,28.48) v1(148.79,22.48) v1(149.13,61.3) v1(149.45,35.48) v1(149.43,25.59) v1(149.5,38.42) v1(149.82,19.8) v1(149.89,41.03) v1(150.01,37.45) v1(150.06,29.49) v1(150.06,24.42) v1(150.7,78.5) v1(150.69,40.38) v1(150.71,34.51) v1(150.69,29.49) v1(150.7,28.48) v1(150.76,32.42) v1(150.78,20.56) v1(151.33,35.42) v1(151.33,31.38) v1(151.44,32.42) v1(151.49,65.62) v1(151.48,64.92) v1(151.69,23.73) v1(151.79,21.83) v1(151.83,20.49) v1(151.77,18.36) v1(151.97,37.45) v1(151.97,29.49) v1(152.15,56.63) v1(152.15,55.99) v1(152.18,55.31) v1(152.57,79.14) v1(152.58,78.5) v1(152.65,32.42) v1(152.71,39.74) v1(152.7,23.05) v1(152.74,21.83) v1(152.79,56.63) v1(152.79,55.99) v1(152.81,55.33) v1(153.42,56.63) v1(153.45,55.99) v1(153.38,32.42) v1(153.73,22.45) v1(153.79,41.12) v1(153.78,39.03) v1(153.76,24.35) v1(153.76,23.72) v1(153.76,20.56) v1(153.76,19.8) v1(153.76,18.33) v1(153.98,26.51) v1(154.72,25.09) v1(154.74,23.73) v1(154.84,39.76) v1(155.41,32.8) v1(155.47,44.47) v1(155.74,39.11) v1(155.66,36.5) v1(155.67,24.38) v1(155.72,23.14) v1(155.77,37.16) v1(155.77,21.8) v1(156.22,33.81) v1(156.21,28) v1(156.21,27.19) v1(156.22,26.37) v1(156.27,65.62) v1(156.27,64.74) v1(156.7,80.6) v1(156.7,79.97) v1(156.7,79.33) v1(156.66,21.83) v1(156.72,20.6) v1(156.94,65.17) v1(157.66,64.74) v1(157.71,40.48) v1(157.72,35.83) v1(157.85,27.99) v1(157.78,22.5) v1(157.79,19.87) v1(158.44,104.12) v1(158.63,106.59) v1(158.67,21.15) v1(159.26,106.59) v1(159.53,108.25) v1(159.54,102.96) v1(159.68,40.38) v1(159.68,39.75) v1(159.68,39.11) v1(159.68,38.48) v1(159.68,37.84) v1(159.72,22.46) v1(159.7,21.16) v1(160.51,104.16) v1(160.46,18.2) v1(160.58,101.76) v1(160.69,39.75) v1(160.72,23.73) v1(161.11,28) v1(161.58,37.2) v1(161.71,35.85) v1(161.75,39.72) v1(162.32,108.25) v1(162.53,52.47) v1(162.64,22.45) v1(162.73,33.71) v1(162.96,108.25) v1(163.63,39.09) v1(163.67,19.66) v1(164.64,23.88) v1(164.73,30.37) v1(164.68,21.8) v1(164.79,33.45) v1(165.44,36.35) v1(165.43,34.35) v1(165.42,25.51) v1(165.65,40.38) v1(165.56,37.18) v1(165.64,19.78) v1(166.64,21.18) v1(166.72,29.52) v1(166.68,24.52) v1(167.04,50.27) v1(167.32,27.49) v1(167.32,25.47) v1(167.37,35.39) v1(167.37,34.45) v1(168,31.42) v1(168.43,39.39) v1(168.52,19.17) v1(168.61,48.71) v1(168.68,33.42) v1(169.23,23.53) v1(169.32,25.56) v1(170.85,35.44) v1(173.02,57.08) v1(178.22,52.11) v1(194.05,4.76) v1(194.44,2.37) v1(195.95,5.98) v1(195.97,1.78) v1(197.9,4.9) v1(197.99,2.83) v1(198.29,40.95) v1(199.61,43.08) v1(201.34,38.52) v1(202.21,43.01) v1(203.07,39.79) v1(203.28,41.6) v1(203.37,25.85) v1(204.96,25.85) v1(206.52,25.85) v1(208.4,43.36) v1(211.31,43.42) v1(213.8,42.55) v1(214.09,40.89) v1(215.08,39.84) v1(215.49,44.33) v1(215.94,25.84) v1(217.61,10.73) v1(218.09,43.76) v1(218.76,42.1) v1(223.08,25.84) v1(228,5.42) v1(228.66,5.42) v1(229.32,5.42) v1(233.77,12.98) v1(234.41,14.25) v1(234.41,13.61) v1(234.41,12.98) v1(235.04,14.25) v1(235.04,13.61) v1(235.04,12.98) v1(235.69,14.26) v1(235.68,13.61) v1(235.68,12.98) v1(236.82,30.48) v1(237.74,31.18) v1(237.76,71.8) v1(238.44,110.14) v1(238.47,107.66) v1(238.47,104.35) v1(238.54,100.92) v1(239.34,33.37) v1(239.41,86.7) v1(240,88.41) v1(240.12,84.99) v1(240.24,76.47) v1(240.47,110.14) v1(240.51,107.66) v1(240.51,104.35) v1(240.57,100.92) v1(241.22,79.66) v1(241.55,72.31) v1(241.83,94.65) v1(241.83,94.01) v1(241.83,93.34) v1(241.83,92.71) v1(241.9,89.3) v1(241.97,84.29) v1(242.26,110.14) v1(242.3,107.66) v1(242.3,104.35) v1(242.36,100.92) v1(243.12,12.77) v1(243.66,110.14) v1(243.69,107.66) v1(243.78,88.47) v1(244.14,104.35) v1(244.2,100.92) v1(244.47,33.3) v1(246.27,12.72) v1(250.12,30.26) v1(251.26,29.07) v1(251.92,55.5) v1(251.88,51.71) v1(252.52,89.67) v1(252.52,51.71) v1(252.93,30.91) v1(253.46,37.74) v1(253.89,92.91) v1(254.18,26.07) v1(254.73,15.39) v1(254.73,14.75) v1(255.39,15.38) v1(255.43,14.74) v1(256.06,15.39) v1(256.09,14.74) v1(256.09,14.11) v1(256.67,15.12) v1(258.35,15.78) v1(258.35,15.15) v1(258.35,14.51) v1(260.5,89.67) v1(261.8,93.29) v1(262.06,73.4) v1(262.25,77.08) v1(263.63,86.88) v1(263.56,36.62) v1(264.09,75.31) v1(264.7,15.52) v1(264.7,14.88) v1(265.46,7.83) v1(265.46,5.93) v1(266.03,84.71) v1(265.99,77.08) v1(266.12,73.34) v1(267.49,9.1) v1(267.56,4.53) v1(269.52,7.83) v1(269.52,5.93) v1(269.91,110.83) v1(269.91,108.93) v1(271.94,112.1) v1(271.87,27.26) v1(272,107.53) v1(272.32,81.66) v1(272.58,28.08) v1(273.39,86.48) v1(273.97,110.83) v1(273.97,108.93) v1(273.97,88.41) v1(274.97,37.13) v1(275.85,34.25) v1(275.94,89.2) v1(275.89,32.85) v1(276,84.35) v1(277.78,88.41) v1(278.21,7.25) v1(278.39,86.56) v1(278.75,39.1) v1(278.85,7.25) v1(279.48,7.25) v1(279.74,20.57) v1(279.81,14.95) v1(279.81,13.85) v1(279.81,12.69) v1(280.86,14.95) v1(280.86,13.85) v1(280.86,12.69) v1(281.49,21.43) v1(281.93,12.69) v1(281.97,14.95) v1(281.97,13.85) v1(284.19,29.31) v1(284.99,19.49) v1(285.35,83.25) v1(285.35,81.53) v1(285.35,79.79) v1(286.55,60.24) v1(286.55,56.35) v1(286.91,83.25) v1(286.91,81.53) v1(286.91,79.79) v1(288.5,83.25) v1(288.5,81.53) v1(288.5,79.79) v1(288.91,28.56) v1(288.87,13.98) v1(290,56.36) v1(290.09,60.24) v1(292.14,22.22) v1(292.32,25.22) v1(293.17,10.77) v1(293.17,9.6) v1(293.31,13.51) v1(293.31,12.27) v1(293.82,8.09) v1(293.81,5.52) v1(297.15,82.52) v1(302.15,84.91) v1(302.47,79.45) v1(302.56,71.87) v1(303.39,62.96) v1(303.4,61.05) v1(305.18,54.56) v1(305.45,62.04) v1(306.25,39.85) v1(306.89,39.85) v1(307.87,59.65) v1(307.87,57.75) v1(307.99,52.71) v1(308.01,51.88) v1(308.01,51.01) v1(312.91,62.99) v1(312.91,61.25) v1(317.39,66.29) v1(318.27,67.1) v1(318.34,3.6) v1(319.25,68.08) v1(319.27,3.65) v1(319.99,66.53) v1(320.27,31.14) v1(321.14,68.07) v1(321.19,31.14) v1(321.47,37.68) v1(321.47,35.77) v1(322.04,93.38) v1(322.1,66.55) v1(322.61,94.43) v1(323.04,30.34) v1(323.04,28.31) v1(323.04,26.27) v1(323.04,24.24) v1(323.04,22.21) v1(323.04,20.18) v1(323.04,18.15) v1(323.04,16.11) v1(323.04,14.08) v1(323.04,12.05) v1(323.04,10.02) v1(323.04,7.99) v1(323.04,5.95) v1(323.22,68.04) v1(323.5,38.95) v1(323.5,34.38) v1(323.79,48.64) v1(323.79,47.03) v1(324.01,66.51) v1(325.09,68.02) v1(325.27,91.08) v1(325.29,48.03) v1(325.29,46.4) v1(325.53,37.68) v1(325.53,35.77) v1(326.4,94.49) v1(326.71,92.71) v4(31.32,62.3) v4(63.04,11.96) v4(65.93,104.24) v4(114.83,3.81) v4(125.55,94.33) v4(128.01,94.47) v4(131.49,94.33) v4(148,84.1) v4(151.5,63.14) v4(159.73,65.62) v4(160.72,108.38) v4(229.94,2.84) v4(236.47,13.73) v4(240.52,99.31) v4(255.39,16.28) v4(264.66,13.19) v4(322.59,47.08) v4(323.18,47.63) v5(130.79,54.8) v5(130.85,52.27) v5(132.38,55.17) v5(132.37,49.33)
