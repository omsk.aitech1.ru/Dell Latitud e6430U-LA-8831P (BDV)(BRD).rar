# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LVD_IBG: length 2.9
  TOP w0.102: v2(158.96,35.19) 158.4,35.75 RH344.2 158.04,36.63 v1(157.69,36.63)
  BOTTOM w0.102: UH4.AF37 158.22,36.18 157.78,36.63 v1(157.69,36.63)
LX_3V:
  vias: v1(255.68,11.05) v1(255.66,10.4) v1(256.35,11.05) v1(256.32,10.4) v1(257.01,11.04) v1(257.02,10.39) v1(258.04,9.74) v1(258.07,11.01) v1(258.07,10.37) v2(252.89,11.34)
LX_5V: length 11.8
  TOP w0.102: v4(242.54,10.55) 243.15,9.94 PC109.2
  IN1 w1.016: 234.96,10.34 236.25,10.34 237.31,11.39 239.46,11.39 240.98,9.88 243.86,9.88
  BOTTOM w0.102: PQ103.5 234.94,9.38 v1(235.1,9.38)
  vias: v1(234.46,9.39) v1(244.9,9.47) v1(245.53,9.46)
M_CLK_DDR0: length 58.4
  IN4 w0.091: v3(71.6,54.86) 71.99,54.47 72.18,54.47 72.19,54.46 72.2,54.46 72.43,54.23 74.26,54.23 74.48,54.45 74.48,55.26 74.26,55.48 72.64,55.48 72.55,55.57 72.55,55.96 72.64,56.05 75.32,56.05 75.42,55.95 75.42,54.7 75.63,54.5 76.1,54.5 76.3,54.7 76.3,55.44 76.4,55.54 76.79,55.54 76.89,55.44 76.89,54.72 77.09,54.52 77.55,54.52 77.75,54.72 77.75,54.88 77.86,54.98 78.12,54.98 78.22,54.88 78.22,54.65 78.43,54.44 79.18,54.44 79.48,54.44 79.58,54.33 79.58,54.08 79.74,53.92 80.62,53.92 80.8,54.11 80.8,54.31 80.91,54.41 81.49,54.41 81.59,54.31 81.59,54.21 81.78,54.02 90.04,54.02 90.65,53.4 102.52,53.4 103.1,52.82 109.42,52.82 109.68,52.56 110.32,52.56 110.74,52.99 113.27,52.99 113.53,53.25 113.53,53.38 v1(113.75,53.6)
  BOTTOM w0.102: U1.AU36 114.06,53.28 v1(113.75,53.6) ; v3(71.6,54.86) 71.78,55.05 71.78,55.23 71.66,55.35 70.32,55.35 69.8,54.83 69.53,54.83 69.35,54.65 JDIMM1.101
M_CLK_DDR1: length 54.3
  IN4 w0.091: v1(115.07,54.6) 114.85,54.82 114.85,55.02 114.62,55.25 113.9,55.25 113.7,55.05 113.7,54.35 113.55,54.19 109.83,54.19 109.52,53.88 109.52,53.52 109.39,53.39 103.64,53.39 102.78,54.25 92.48,54.25 92.48,54.81 92.28,55.01 91.85,55.01 91.65,54.81 91.65,54.35 91.55,54.25 91.29,54.25 91.19,54.35 91.19,55.51 90.98,55.71 90.47,55.71 90.26,55.51 90.26,54.96 90.16,54.86 89.88,54.86 89.78,54.96 89.78,55.51 89.57,55.71 89.13,55.71 88.92,55.51 88.92,54.99 88.8,54.86 88.56,54.86 88.44,54.99 88.44,55.51 88.23,55.71 87.77,55.71 87.57,55.51 87.57,54.99 87.44,54.86 87.2,54.86 87.08,54.99 87.08,55.5 86.87,55.71 86.46,55.71 86.26,55.5 86.26,54.99 86.13,54.86 85.93,54.86 85.8,54.99 85.8,55.49 85.61,55.68 85.19,55.68 85,55.49 85,54.99 84.87,54.86 84.67,54.86 84.54,54.99 84.54,55.49 84.35,55.68 83.93,55.68 83.74,55.49 83.74,54.99 83.61,54.86 83.41,54.86 83.28,54.99 83.28,55.48 83.05,55.71 82.7,55.71 82.48,55.48 82.48,55.07 82.35,54.94 82.15,54.94 82.02,55.07 82.02,55.51 81.83,55.7 80.38,55.7 80.07,55.39 80.07,55.25 v3(79.85,55.04)
  BOTTOM w0.102: v3(79.85,55.04) 80.1,55.29 80.1,55.43 79.91,55.62 78.71,55.62 78.21,55.12 77.72,55.12 77.55,54.95 JDIMM1.102 ; v1(115.07,54.6) 114.77,54.9 U1.AT40
M_CLK_DDR2: length 76.1
  IN1 w0.091: v1(111.79,52.59) 111.91,52.59 112.07,52.42 112.07,52.29 111.94,52.16 111.61,52.16 111.6,52.17 109.58,52.17 108.95,52.8 102.94,52.8 102.7,52.56 93.35,52.56 91.96,51.17 66.34,51.17 65.15,52.36 60.74,52.36 60.64,52.26 55.8,52.26 55.57,52.03 55.57,51.19 55.44,51.06 55.24,51.06 55.11,51.19 55.11,52.18 54.88,52.4 54.53,52.4 54.3,52.18 54.3,50.87 54.17,50.74 53.97,50.74 53.84,50.87 53.84,52.38 53.61,52.61 53.26,52.61 53.03,52.38 53.03,50.8 52.9,50.68 51.41,50.68 51.25,50.83 51.25,51.01 51.5,51.27 51.5,51.38 51.57,51.45 v3(51.84,51.45)
  BOTTOM w0.102: v1(111.79,52.59) 112.11,52.26 U1.BA34 ; JDIMM2.101 54.12,51.65 54.03,51.74 54.03,51.95 53.98,52 53.53,52 53.42,51.9 51.77,51.9 51.74,51.87 51.64,51.87 51.52,51.74 51.52,51.51 51.64,51.39 51.78,51.39 v3(51.84,51.45)
M_CLK_DDR3: length 72.7
  IN1 w0.091: v3(60.06,53.7) 60.07,53.7 60.3,53.47 60.3,53.37 60.56,53.1 60.93,53.1 61.17,52.86 61.96,52.86 62.23,53.13 62.23,53.4 62.36,53.53 62.56,53.53 62.69,53.4 62.69,53.02 62.85,52.86 63.35,52.86 63.52,53.03 63.52,53.33 63.64,53.46 63.82,53.46 63.95,53.33 63.95,53.02 64.1,52.87 65.36,52.87 66.43,51.8 67.13,51.8 67.32,51.99 67.32,52.44 67.45,52.57 67.65,52.57 67.78,52.44 67.78,51.99 67.97,51.8 90.74,51.8 90.94,52 90.94,52.45 91.05,52.55 91.3,52.55 91.4,52.45 91.4,52.12 91.6,51.92 92,51.92 92.2,52.12 92.2,53.7 92.31,53.8 92.56,53.8 92.66,53.7 92.66,53.25 92.86,53.05 93.27,53.05 93.47,53.25 93.47,53.71 93.56,53.8 93.83,53.8 93.93,53.71 93.93,53.26 94.13,53.06 94.53,53.06 94.73,53.26 94.73,53.71 94.82,53.8 95.09,53.8 95.19,53.71 95.19,53.26 95.39,53.06 95.79,53.06 95.99,53.26 95.99,53.71 96.08,53.8 96.35,53.8 96.45,53.71 96.45,53.26 96.65,53.06 97.05,53.06 97.25,53.26 97.25,53.71 97.34,53.8 97.61,53.8 97.71,53.71 97.71,53.26 97.91,53.06 98.31,53.06 98.51,53.26 98.51,53.71 98.6,53.8 98.87,53.8 98.97,53.71 98.97,53.26 99.17,53.06 99.57,53.06 99.77,53.26 99.77,53.71 99.86,53.8 100.13,53.8 100.23,53.71 100.23,53.26 100.43,53.06 100.83,53.06 101.03,53.26 101.03,53.71 101.12,53.8 101.39,53.8 101.48,53.71 101.48,53.26 101.69,53.06 102.46,53.06 102.62,53.22 108.97,53.22 109.43,53.68 110.11,53.68 110.8,52.99 111.36,52.99 111.56,53.2 111.56,53.37 v1(111.79,53.6)
  BOTTOM w0.102: U1.BA36 112.11,53.29 v1(111.79,53.6) ; JDIMM2.102 61.56,51.95 61.34,52.17 61.34,52.83 61.18,52.99 60.8,52.99 60.39,53.4 60.36,53.4 v3(60.06,53.7)
M_CLK_DDR#0: length 58.4
  IN4 w0.091: v1(72.36,54.86) 72.36,54.54 72.5,54.4 74.19,54.4 74.31,54.52 74.31,55.19 74.19,55.31 72.57,55.31 72.37,55.5 72.37,56.03 72.57,56.22 75.39,56.22 75.6,56.02 75.6,54.77 75.7,54.67 76.03,54.67 76.13,54.77 76.13,55.51 76.33,55.71 76.86,55.71 77.06,55.51 77.06,54.8 77.17,54.69 77.48,54.69 77.58,54.8 77.58,54.95 77.78,55.16 78.19,55.16 78.39,54.95 78.39,54.72 78.5,54.61 79.11,54.61 79.11,54.61 79.55,54.61 79.76,54.41 79.76,54.16 79.81,54.1 80.55,54.1 80.63,54.18 80.63,54.38 80.83,54.58 81.56,54.58 81.76,54.38 81.76,54.28 81.85,54.19 90.11,54.19 90.73,53.57 102.59,53.57 103.18,52.99 109.49,52.99 109.75,52.73 110.24,52.73 110.67,53.16 113.2,53.16 113.34,53.3 113.34,53.39 113.13,53.6 v3(113.09,53.6)
  BOTTOM w0.102: v3(113.09,53.6) 113,53.51 113,53.37 113.24,53.13 113.36,53.13 U1.AV36 ; v1(72.36,54.86) 72.28,54.78 72.17,54.78 72.03,54.92 72.03,55.33 71.76,55.59 70.22,55.59 69.7,55.07 69.53,55.07 69.35,55.25 JDIMM1.103
M_CLK_DDR#1: length 54.3
  IN4 w0.091: v1(114.42,54.6) 114.46,54.6 114.68,54.81 114.68,54.95 114.55,55.08 113.97,55.08 113.87,54.98 113.87,54.28 113.62,54.02 109.9,54.02 109.69,53.81 109.69,53.44 109.46,53.22 103.57,53.22 102.71,54.07 92.41,54.07 92.31,54.17 92.31,54.73 92.21,54.84 91.92,54.84 91.82,54.73 91.82,54.28 91.62,54.07 91.22,54.07 91.01,54.28 91.01,55.44 90.91,55.54 90.54,55.54 90.44,55.44 90.44,54.89 90.23,54.69 89.81,54.69 89.6,54.89 89.6,55.44 89.5,55.54 89.2,55.54 89.1,55.44 89.1,54.92 88.87,54.69 88.49,54.69 88.26,54.92 88.26,55.44 88.16,55.54 87.85,55.54 87.74,55.44 87.74,54.92 87.52,54.69 87.13,54.69 86.9,54.92 86.9,55.43 86.8,55.53 86.53,55.53 86.43,55.43 86.43,54.92 86.2,54.69 85.85,54.69 85.63,54.92 85.63,55.42 85.53,55.51 85.26,55.51 85.17,55.42 85.17,54.92 84.94,54.69 84.59,54.69 84.37,54.92 84.37,55.42 84.27,55.51 84.01,55.51 84,55.5 arc(83.99,55.49) 83.97,55.48 83.91,55.42 83.91,54.92 83.68,54.69 83.33,54.69 83.11,54.92 83.11,55.41 82.98,55.54 82.78,55.54 82.65,55.41 82.65,55 82.42,54.77 82.07,54.77 81.85,55 81.85,55.44 81.76,55.53 80.45,55.53 80.24,55.32 80.24,55.22 80.42,55.04 v3(80.61,55.04)
  BOTTOM w0.102: v1(114.42,54.6) 114.12,54.9 U1.AU40 ; JDIMM1.104 77.51,55.55 77.7,55.37 78.11,55.37 78.58,55.84 80.04,55.84 80.34,55.53 80.34,55.3 v3(80.61,55.04)
M_CLK_DDR#2: length 76
  IN1 w0.091: v1(112.44,52.59) 112.25,52.39 112.25,52.22 112.01,51.98 111.54,51.98 111.52,52 109.51,52 108.87,52.63 103.01,52.63 102.77,52.39 93.42,52.39 92.03,51 66.26,51 65.08,52.18 60.81,52.18 60.71,52.08 55.87,52.08 55.74,51.96 55.74,51.12 55.52,50.89 55.16,50.89 54.94,51.12 54.94,52.1 54.81,52.23 54.6,52.23 54.47,52.1 54.47,50.8 54.25,50.57 53.89,50.57 53.67,50.8 53.67,52.31 53.54,52.44 53.33,52.44 53.2,52.31 53.2,50.73 52.98,50.5 51.34,50.5 51.08,50.76 v3(51.08,51.45)
  BOTTOM w0.102: U1.AY34 112.76,52.27 v1(112.44,52.59) ; JDIMM2.103 54.37,52.25 54.34,52.22 53.4,52.22 53.32,52.14 51.67,52.14 51.64,52.11 51.54,52.11 51.28,51.84 51.28,51.64 v3(51.08,51.45)
M_CLK_DDR#3: length 72.6
  IN1 w0.091: v1(60.82,53.7) 60.62,53.7 60.47,53.55 60.47,53.44 60.63,53.27 61.01,53.27 61.25,53.03 61.89,53.03 62.06,53.2 62.06,53.47 62.29,53.7 62.63,53.7 62.86,53.47 62.86,53.09 62.92,53.03 63.27,53.03 63.35,53.1 63.35,53.41 63.57,53.63 63.89,53.63 64.12,53.41 64.12,53.09 64.17,53.04 65.43,53.04 66.51,51.97 67.06,51.97 67.15,52.06 67.15,52.51 67.38,52.74 67.72,52.74 67.95,52.51 67.95,52.06 68.04,51.97 90.67,51.97 90.77,52.07 90.77,52.52 90.97,52.72 91.37,52.72 91.57,52.52 91.57,52.19 91.68,52.09 91.93,52.09 92.03,52.19 92.03,53.77 92.23,53.97 92.63,53.97 92.83,53.77 92.83,53.33 92.94,53.22 93.19,53.22 93.3,53.33 93.3,53.78 93.49,53.97 93.91,53.97 94.1,53.78 94.1,53.33 94.2,53.23 94.45,53.23 94.56,53.33 94.56,53.78 94.75,53.97 95.17,53.97 95.36,53.78 95.36,53.33 95.46,53.23 95.71,53.23 95.82,53.33 95.82,53.78 96.01,53.97 96.43,53.97 96.62,53.78 96.62,53.33 96.72,53.23 96.97,53.23 97.08,53.33 97.08,53.78 97.27,53.97 97.69,53.97 97.88,53.78 97.88,53.33 97.98,53.23 98.23,53.23 98.34,53.33 98.34,53.78 98.53,53.97 98.95,53.97 99.14,53.78 99.14,53.33 99.24,53.23 99.49,53.23 99.6,53.33 99.6,53.78 99.79,53.97 100.21,53.97 100.4,53.78 100.4,53.33 100.5,53.23 100.75,53.23 100.86,53.33 100.86,53.78 101.05,53.97 101.47,53.97 101.66,53.78 101.66,53.34 101.76,53.24 102.39,53.24 102.55,53.39 108.89,53.39 109.36,53.85 110.18,53.85 110.87,53.17 111.29,53.17 111.39,53.27 111.39,53.44 111.23,53.6 v3(111.14,53.6)
  BOTTOM w0.102: v3(111.14,53.6) 110.96,53.42 110.96,53.24 111.15,53.05 111.33,53.05 U1.BB36 ; v1(60.82,53.7) 60.7,53.59 60.7,53.39 60.89,53.21 61.27,53.21 61.56,52.92 61.56,52.26 61.65,52.17 62.07,52.17 62.17,52.26 62.17,52.47 62.25,52.55 JDIMM2.104
M_ID2#: length 5.2
  TOP w0.102: C1208.1 9.02,79.82 v2(8.9,79.82) 8.51,79.82 6.39,77.69 JCRT1.4
M_ODT0: length 54.2
  IN4 w0.084: v1(112.5,54.62) 112.1,55.01 110.88,55.01 110.55,54.68 109.16,54.68 109.06,54.78 109.06,55.96 108.71,56.31 105.95,56.31 105.76,56.5 102.71,56.5 101.94,57.27 101.89,57.27 101.87,57.3
  IN4 w0.132: v3(78.71,59.75) 78.71,59.34 78.64,59.28 77.06,59.28 76.69,59.65 74.67,59.65 74.57,59.75 74.57,60.46 74.67,60.56 75.06,60.56 75.19,60.43 75.19,60.28 75.3,60.18 75.62,60.18 75.72,60.28 75.72,60.46 75.82,60.56 76.15,60.56 76.25,60.46 76.25,60.28 76.35,60.18 76.68,60.18 76.78,60.28 76.78,60.46 76.88,60.56 77.21,60.56 77.31,60.46 77.31,60.26 77.41,60.16 77.73,60.16 77.84,60.26 77.84,60.43 77.97,60.56 78.35,60.56 78.48,60.43 78.48,60.33 78.58,60.23 78.91,60.23 79.01,60.33 79.01,60.46 79.11,60.56 79.44,60.56 79.54,60.46 79.54,60.31 79.64,60.21 79.96,60.21 80.07,60.31 80.07,60.46 80.17,60.56 80.49,60.56 80.59,60.46 80.59,60.3 80.7,60.2 81.02,60.2 81.12,60.3 81.12,60.43 81.25,60.56 91.18,60.56 94.44,57.3 101.87,57.3
  BOTTOM w0.102: U1.AY40 112.82,54.94 v1(112.5,54.62)
  BOTTOM w0.165: v3(78.71,59.75) 78.9,59.75 79.02,59.63 79.02,58.97 78.9,58.85 78.06,58.85 77.93,58.97 77.93,59.02 77.8,59.15 76.88,59.15 76.88,59.15 JDIMM1.116
M_ODT1: length 54
  IN4 w0.084: 101.87,58.77 101.9,58.73 102.94,58.73 103.87,57.81 104.35,57.81 105.1,57.05 105.99,57.05 106.18,56.87 108.94,56.87 109.65,56.16 110.1,56.16 110.68,55.57 111.8,55.57 112.26,56.03 v1(112.26,56.03)
  IN4 w0.132: 101.87,58.77 95.07,58.77 91.8,62.04 90.64,62.04 90.53,62.14 90.53,62.89 90.43,63 90.11,63 90.01,62.89 90.01,62.14 89.9,62.04 89.58,62.04 89.48,62.14 89.48,62.89 89.38,63 89.05,63 88.95,62.89 88.95,62.14 88.85,62.04 88.52,62.04 88.42,62.14 88.42,62.89 88.32,63 87.99,63 87.89,62.89 87.89,62.14 87.79,62.04 87.47,62.04 87.36,62.14 87.36,62.89 87.26,63 86.94,63 86.84,62.89 86.84,62.14 86.73,62.04 86.41,62.04 86.31,62.14 86.31,62.89 86.21,63 85.88,63 85.78,62.89 85.78,62.14 85.68,62.04 85.35,62.04 85.25,62.14 85.25,62.89 85.15,63 84.82,63 84.72,62.89 84.72,62.14 84.62,62.04 84.3,62.04 84.19,62.14 84.19,62.89 84.09,63 83.77,63 83.67,62.89 83.67,62.14 83.56,62.04 83.24,62.04 83.14,62.14 83.14,62.89 83.04,63 82.71,63 82.61,62.89 82.61,62.14 82.51,62.04 82.17,62.04 82.06,62.14 82.06,62.38 81.96,62.49 81.44,62.49 81,62.04 v3(80.87,62.04)
  BOTTOM w0.102: U1.BA41 111.84,55.62 v1(112.26,56.03)
  BOTTOM w0.17: v3(80.87,62.04) 79.18,60.35 JDIMM1.120
M_ODT2: length 75.8
  IN1 w0.084: 101.87,56.67 102,56.67 102.21,56.45 109.53,56.45 109.68,56.6 114.48,56.6 v1(114.88,56.99)
  IN1 w0.132: 101.87,56.67 94.37,56.67 93.31,57.72 84.69,57.72 84.55,57.59 84.55,56.82 84.42,56.69 84.16,56.69 84.03,56.82 84.03,57.59 83.89,57.72 83.63,57.72 83.5,57.59 83.5,56.82 83.36,56.69 83.1,56.69 82.97,56.82 82.97,57.59 82.84,57.72 82.57,57.72 82.44,57.59 82.44,56.82 82.31,56.69 82.04,56.69 81.91,56.82 81.91,57.59 81.78,57.72 77.51,57.72 77.38,57.59 77.38,56.81 77.25,56.68 76.98,56.68 76.85,56.81 76.85,57.59 76.72,57.72 76.45,57.72 76.32,57.59 76.32,56.81 76.19,56.68 75.93,56.68 75.79,56.81 75.79,57.59 75.66,57.72 74.38,57.72 74.25,57.59 74.25,56.81 74.12,56.68 73.86,56.68 73.72,56.81 73.72,57.59 73.59,57.72 69.23,57.72 69.11,57.6 69.11,56.8 68.98,56.68 68.67,56.68 68.55,56.8 68.55,57.98 68.28,58.25 63.71,58.25 63.44,57.98 63.44,57.23 63.31,57.1 63.04,57.1 62.91,57.23 62.91,57.93 62.79,58.05 62.51,58.05 62.39,57.93 62.39,57.07 62.25,56.94 61.99,56.94 61.86,57.07 61.86,57.54 61.72,57.68 60.71,57.68 60.58,57.55 60.58,57.1 60.46,56.97 v3(60.44,56.97)
  BOTTOM w0.102: v1(114.88,56.99) 114.52,56.63 U1.AT43
  BOTTOM w0.17: JDIMM2.116 62.37,56.15 62.07,56.45 60.86,56.45 60.44,56.87 v3(60.44,56.97)
M_ODT3: length 73.4
  IN1 w0.084: v1(105.31,59.8) 104.57,59.05 101.91,59.05 101.87,59.1
  IN1 w0.132: v3(60.44,60.31) 60.44,60.63 60.31,60.76 57.73,60.76 57.6,60.88 57.6,61.1 57.73,61.23 64.17,61.23 64.27,61.33 65.95,61.33 66.3,60.98 73.46,60.98 73.82,60.61 74.88,60.61 75.01,60.74 75.01,61.2 75.14,61.33 75.4,61.33 75.54,61.2 75.54,60.74 75.67,60.61 75.93,60.61 76.06,60.74 76.06,61.2 76.2,61.33 76.46,61.33 76.59,61.2 76.59,60.74 76.72,60.61 76.99,60.61 77.12,60.74 77.12,61.2 77.25,61.33 77.52,61.33 77.65,61.2 77.65,60.74 77.78,60.61 78.05,60.61 78.18,60.74 78.18,61.2 78.31,61.33 78.57,61.33 78.71,61.2 78.71,60.74 78.84,60.61 79.1,60.61 79.23,60.74 79.23,61.2 79.37,61.33 79.63,61.33 79.76,61.2 79.76,60.74 79.89,60.61 80.16,60.61 80.29,60.74 80.29,61.2 80.42,61.33 80.69,61.33 80.82,61.2 80.82,60.74 80.95,60.61 81.22,60.61 81.35,60.74 81.35,61.2 81.48,61.33 81.92,61.33 82.05,61.2 82.05,60.33 82.19,60.19 82.45,60.19 82.58,60.33 82.58,61.2 82.71,61.33 82.98,61.33 83.11,61.2 83.11,60.33 83.24,60.19 83.51,60.19 83.64,60.33 83.64,61.2 83.77,61.33 87.8,61.33 89.01,60.12 94.13,60.12 95.15,59.1 101.87,59.1
  BOTTOM w0.102: U1.BG47 109.05,58.62 106.49,58.62 v1(105.31,59.8)
  BOTTOM w0.17: v3(60.44,60.31) 60.44,59.15 62.23,57.35 JDIMM2.120
MASK_BASE_LEDS#: length 197.5
  TOP w0.102: U58.4 257.38,86.96 v1(257.08,87.26)
  IN1 w0.084: v1(170.46,74.76) 171.87,73.35 171.87,69.71 171.16,69 171.16,63.74 170.67,63.25 170.67,61.58 170.83,61.41 170.83,60.31 172.04,59.1 172.04,52.01 173.65,50.4 181.87,50.4 183.59,48.68 187.71,48.68 190.94,45.45 194.54,45.45 196.29,43.71 196.29,42.7 196.91,42.08 196.91,40.32 199.55,37.68 217.35,37.68 232.57,52.9 232.57,58.43 235.94,61.8 235.94,67.65 236.19,67.9 236.19,70.84 236.54,71.19 236.54,71.85 237.76,73.06 240.35,73.06 244.64,77.35 246.61,77.35 251.85,82.59 256.1,82.59 257.08,83.57 v1(257.08,87.26)
  BOTTOM w0.102: Q78.2 163.44,73.02 163.44,75.63 163.86,76.04 169.17,76.04 v1(170.46,74.76) 172.03,73.19 172.03,68.44 170.02,66.43 ; Q84.2 162.91,64.79 161.74,63.62 v2(161.74,62.19) 161.49,61.94 161.49,58.86 161.85,58.49 163.05,58.49 163.12,58.57 Q83.5 Q83.2 165.72,58.57 165.88,58.4 165.88,58 166.07,57.81 169.84,57.81 170.9,58.86 170.9,65.59 170.06,66.43 170.02,66.43 ; 170.02,66.43 169.44,66.43 169.26,66.61 Q74.2
MASK_SATA_LED#: length 142
  TOP w0.102: v1(264.09,71.4) U46.B9
  IN1 w0.084: v1(264.09,71.4) 263.67,70.97 258.24,70.97 257.37,70.1 254.99,70.1 254.32,70.76 253.03,70.76 252.79,71.01 241.66,71.01 241.45,70.79 238.64,70.79 238.03,70.17 238.03,68.17 239.94,66.26 239.94,60.1 239.12,59.28 239.12,57.66 217.87,36.42 199.02,36.42 195.63,39.81 195.63,41.57 192.84,44.36 190.52,44.36 187.45,47.43 186.61,47.43 186.14,46.96 183.81,46.96 181.43,49.35 173.22,49.35 170.99,51.58 170.99,58.62 169.3,60.31 169.3,61.12 169.5,61.32 169.5,64 169.94,64.45 v1(169.95,64.45)
  BOTTOM w0.102: Q74.5 169.26,64.74 169.55,64.45 v1(169.95,64.45) 170.38,64.45 v2(170.54,64.28)
MAX8731_IINP: length 270.9
  TOP w0.254: PR1329.1 PC1323.1 ; PC1323.1 v1(38.44,24.24) ; PC1323.1 37.86,23.58 37.3,23.02 35.32,23.02 35.19,22.88 PU1300.8
  IN1 w0.084: v1(39.83,87.06) 41.05,85.84 41.05,80.22 42.63,78.64 42.63,69.89 43.31,69.21 43.31,68.18 43.17,68.04 43.17,65.32 42.79,64.95 42.79,62.66 43.52,61.94 43.52,54.38 40.12,50.99 40.12,42.46 38.18,40.52 38.18,36.66 35.18,33.66 35.18,28.18 38.44,24.93 v1(38.44,24.24) 39.57,23.11 41.05,23.11 42.84,21.32 42.84,10.95 35.67,3.78 35.67,3.05 35.21,2.59 28.44,2.59 25.15,5.88 25.15,10.69 23.35,12.49 20.31,12.49 19.6,11.78 18.75,11.78 18.22,11.25 18.22,9.17 16.26,7.21 11.37,7.21 9.63,5.47 9.63,4.1 v1(10.06,3.67)
  IN4 w0.084: v1(151.5,103.45) 149.78,105.17 137.9,105.17 133.23,109.84 105.91,109.84 103,106.92 99.46,106.92 95.13,102.59 93.91,102.59 86.97,95.65 65.62,95.65 64.08,94.1 64.08,90.5 62.4,88.82 41.6,88.82 v1(39.83,87.06)
  BOTTOM w0.102: R387.2 153.23,103.63 152.99,103.87 v2(152.66,103.87) 151.92,103.87 v1(151.5,103.45)
  BOTTOM w0.254: v1(10.06,3.67) 10.06,3.65 9.37,4.35 PR1343.1
MAX8731_REF: length 57.8
  TOP w0.254: PU1300.3 36.7,19.52 36.73,19.49 37.11,19.49 v2(37.38,19.22) 37.45,19.16 38.43,19.16 PC1327.1 38.46,19.73 38.51,19.78 38.51,20.03 ; 38.51,20.03 PR1327.1 ; 38.51,20.03 v1(39.54,20.03)
  IN1 w0.254: v1(11.85,8.25) 16.73,8.25 17.84,9.36 17.84,11.62 19.39,13.17 23.14,13.17 25.58,10.73 25.58,9.87 v1(29.51,5.94) 29.83,5.62 30.66,5.62 31.2,6.17 35.27,6.17 40.23,11.12 40.23,17.44 39.54,18.14 v1(39.54,20.03)
  IN4 w0.254: v1(11.85,8.25) 10.14,6.53 v1(10.14,5.25)
  BOTTOM w0.254: v1(10.14,5.25) 10.12,5.26 PR1338.1 ; v1(11.85,8.25) 11.46,8.25 PR1336.1 ; v1(29.51,5.94) 29.49,5.93 PR1311.1
MAX8731A_LDO: length 31.3
  TOP w0.102: PD1301.2 v2(39.62,11.64)
  TOP w0.254: v1(31.5,17.97) 31.06,17.52 30.16,17.52 PC1311.1 30.07,18.25 30.54,18.25 30.81,18.52 PU1300.21 ; PR1319.1 38.1,13.1 v1(37.75,12.76) 37.75,12.09 38.19,11.64 PD1301.2
  IN3 w0.254: v1(37.75,12.76) 37.75,11.26 33.7,7.21 29.7,7.21 v1(28.44,5.95)
  IN4 w0.254: v1(31.5,17.97) 35.18,17.97 35.55,17.61 35.55,16.04 37.75,13.83 v1(37.75,12.76)
  BOTTOM w0.254: PR1310.1 v1(28.44,5.95)
MCARD_MISC_PWREN: length 62.5
  TOP w0.102: v1(240.92,49.7) v2(240.92,48.92) ; R806.1 v1(270.06,85.06)
  IN1 w0.084: v1(240.92,49.7) 239.53,51.1 239.53,54.4 241.51,56.39 v1(241.51,58.28)
  IN2 w0.122: v1(241.51,58.28) 243.05,59.82 250.32,59.82 253.54,63.04 254.55,63.04 256.14,64.63 256.14,68.75 256.71,69.33 257.56,69.33 259.23,71 259.23,76.98 259.62,77.37 261.46,77.37 261.84,77.75 266.22,77.75 266.54,78.06 266.54,79.65 267.49,80.6 268.7,80.6 269.11,81.01 269.11,84.11 v1(270.06,85.06)
  BOTTOM w0.102: v1(240.92,49.7) R733.1 239.53,50.33 Q43.2
MCARD_PCIE_SATA#: length 5.7
  TOP w0.102: v1(259.11,69.35) 258.9,69.35 v2(258.41,68.85) 258.13,68.58 R457.2 ; U46.B3 261.09,71.29 v1(261.19,71.4)
  BOTTOM w0.102: v1(261.19,71.4) 259.14,69.35 v1(259.11,69.35)
MCARD_WWAN_PWREN: length 91.5
  TOP w0.102: Q41.2 316.15,36.21 316.29,36.07 316.29,35.09 316.21,35.01 R726.1 317.86,34.44 318.54,35.12 318.54,44 312.55,49.98 312.55,54.43 309.91,57.07 v2(309.91,64.54) 309.91,65.92 309.03,66.8 v1(306.16,66.8) ; U46.B42 264.59,79.42 v1(264.36,79.19)
  IN4 w0.084: v1(264.36,79.19) 264.82,79.65 269.93,79.65 273.44,76.15 278.85,76.15 282.29,72.71 298.17,72.71 301.41,69.47 303.5,69.47 v1(306.16,66.8)
MCARD_WWAN_PWREN#: length 0.4
  TOP w0.102: 314.7,34.07 v2(315.07,34.07)
ME_FWP: length 144.2
  TOP w0.102: U46.A8 263.84,69.52 264.05,69.3 264.05,67.99 R793.1 264.69,67.36 264.69,65.34 264.98,65.05 v1(264.98,64.45)
  IN3 w0.122: v1(264.98,64.45) 265.34,64.09 265.34,54.42 265.95,53.81 265.95,45.49 267.77,43.67 267.77,27.11 v1(266.34,25.68)
  IN4 w0.084: v1(266.34,25.68) 263.82,25.68 262.72,26.78 256.68,26.78 256.14,27.31 247.43,27.31 246.77,26.65 232.9,26.65 229.93,23.68 196.45,23.68 191.62,28.51 187.31,28.51 186.73,27.93 183.75,27.93 177.87,33.8 177.87,34.06 v3(177.33,34.6)
  BOTTOM w0.102: v3(177.33,34.6) 176.9,34.16 RH50.1
ME_SUS_PWR_ACK: length 163.7
  TOP w0.102: v1(295.82,44.21) v2(295.82,44.83) ; U51.A8 v1(294.21,58.1)
  IN2 w0.102: 174.55,24.11 173.55,24.11 173.19,24.47 172.55,24.47 171.32,25.7 170.72,25.7 170.14,26.29 168.32,26.29 168.15,26.11 167.09,26.11 v1(166.69,26.51)
  IN2 w0.122: v1(295.82,44.21) 294.64,43.04 291.69,43.04 286.37,37.71 278.81,37.71 277.21,36.12 271.03,36.12 268.65,33.74 265.41,33.74 264.51,34.64 262.83,34.64 260.82,36.65 254.68,36.65 254.19,36.17 238.9,36.17 229.54,26.81 200.53,26.81 199.72,26 194.25,26 192.88,27.37 190.95,27.37 190.16,28.15 188.36,28.15 187.14,26.93 185.66,26.93 183.12,24.39 180.07,24.39 179.26,23.58 v1(179,23.58) 177.87,23.58 177.34,24.11 174.55,24.11
  IN3 w0.122: v1(294.21,58.1) 294.29,58.18 295.08,58.18 296.27,56.98 296.27,55.63 296.54,55.37 296.54,49.11 295.84,48.41 295.84,44.24 v1(295.82,44.21)
  BOTTOM w0.102: RH144.2 179.18,21.5 178.31,22.36 RH323.1 179,23.12 v1(179,23.58) ; UH4.K16 166.41,26.24 v1(166.69,26.51)
MEC_XTAL1: length 6.3
  TOP w0.102: U51.A61 290.26,52.15 290.81,51.6 v2(290.81,51.22) 291.09,50.94 291.09,50.1 290.76,49.77 290.38,49.77 C743.1 290,48.88 290.21,48.67 Y6.1
MEC_XTAL2: length 3
  TOP w0.102: R1068.2 291.94,49.86 291.96,49.86 C741.1 292.49,48.94 292.71,48.72 Y6.2
MEC_XTAL2_R: length 3.4
  TOP w0.102: U51.A62 290.76,52.12 291.52,51.36 291.52,51.19 R1068.1
MEM_SMBCLK: length 22.2
  IN4 w0.084: v1(166.69,25.45) 167.21,24.93 169.39,24.93 170.22,24.09 171.73,24.09 171.83,24.19 174.14,24.19 174.25,24.31 177.5,24.31 177.79,24.01 183.5,24.01 v3(184.64,25.16)
  BOTTOM w0.102: v1(166.69,25.45) 167.04,25.09 UH4.H14 ; QH5.6 183.09,24.31 183.16,24.39 RH302.2 183.87,24.39 v3(184.64,25.16)
MEM_SMBDATA: length 15.1
  IN4 w0.084: v1(179.02,22.3) 177.23,24.1 174.34,24.1 174.22,23.98 171.92,23.98 171.49,23.56 v3(171.49,22.37)
  BOTTOM w0.102: QH5.3 181.27,22.19 181.06,21.98 180.57,21.98 RH303.2 180.05,22.45 179.18,22.45 v1(179.02,22.3) ; UH4.C9 169.58,22.54 169.95,22.91 170.14,22.91 170.42,22.63 171.24,22.63 v3(171.49,22.37)
MIC_IN_L: length 3.7
  TOP w0.254: C1163.1 25.81,40.15 25.81,39.49 v2(26.04,39.27) 26.65,38.66 U72.28
MIC_IN_R: length 14.1
  TOP w0.254: U72.29 26.41,38.16 26.02,38.55 v1(24.3,38.55) 23.97,38.88 23.97,41.07 25.48,42.58 R1143.2
  BOTTOM w0.254: v1(24.3,38.55) v2(23.09,38.55) 22.18,38.55 21.57,37.95 L104.2
MINI1CLK_REQ#: length 151.8
  IN2 w0.122: v1(167.04,16.37) 167.31,16.1 169.11,16.1 174.57,10.64 v1(175.2,10.64) 175.62,10.22 178.73,10.22 179.27,9.68 187.49,9.68 190.57,12.76 197.45,12.76 198.1,13.41 203.35,13.41 204.67,12.08 211.29,12.08 213.67,14.46 217.98,14.46 222.22,18.7 240.73,18.7 243.6,21.57 267.37,21.57 270.34,24.53 276.63,24.53 278.74,26.64 291.84,26.64 v1(293.48,28.28)
  BOTTOM w0.102: UH4.J2 166.59,19.05 166.59,17.56 167.04,17.12 v1(167.04,16.37) ; RH81.1 176.99,11.37 176.94,11.42 v2(175.98,11.42) v1(175.2,10.64) ; v1(293.48,28.28) 294.21,28.28 297.4,31.47 JMINI1.7
MINI2CLK_REQ#: length 148.5
  IN2 w0.122: v1(173.18,18.77) 173.18,18.77 173.26,18.77 174.09,17.94 174.93,17.94 176.37,16.51 178.4,16.51 178.68,16.23 186.29,16.23 188.01,17.95 189.59,17.95 190.95,19.31 195.68,19.31 196.83,18.16 197.79,18.16 198.11,18.48 201.81,18.48 202.43,19.11 218.37,19.11 220.67,21.4 230.21,21.4 231.22,22.42 240.13,22.42 240.37,22.65 240.39,22.65 248.66,30.92 252.11,30.92 253.09,29.94 256.85,29.94 258.03,31.12 264.66,31.12 v1(265.77,30.02)
  IN3 w0.122: v1(265.77,30.02) 265.77,30.69 267.23,32.15 267.23,43.5 264.14,46.59 264.14,56.84 v1(263.7,57.28)
  IN4 w0.084: v1(173.18,18.77) 172.71,19.24 169.47,19.24 169,18.76 168.13,18.76 167.2,19.7 167.2,21.18 166.67,21.71 166.67,23.58 166.24,24.01 165.9,24.01 v1(165.41,24.51)
  BOTTOM w0.102: v1(173.18,18.77) 173.18,18.63 v2(173.93,17.88) 174.09,17.71 RH97.1 ; UH4.L14 165.77,24.88 v1(165.41,24.51) ; v1(263.7,57.28) 263.4,57.58 263.4,57.76 JMINI2.7
MINI3CLK_REQ#: length 12.6
  IN4 w0.084: v1(171.49,20.1) 171.51,20.09 179.57,20.09 v1(179.8,20.32)
  BOTTOM w0.102: v1(179.8,20.32) 179.55,20.06 v2(179.32,20.06) 178.82,20.06 RH152.1 ; UH4.A8 171.49,21.07 v1(171.49,20.1)
MMICLK_REQ#: length 140.6
  TOP w0.102: v1(278.36,21.37) 278.94,20.8 278.94,17.73 v2(279.09,17.57) 279.61,17.05 U38.31
  IN1 w0.084: v1(162.25,16.43) 162.25,18.55 161.19,19.61 161.19,21.97 v1(161.68,22.46)
  IN2 w0.122: v1(162.25,16.43) 163.49,15.19 168.27,15.19 169.05,14.41 169.05,13.6 173.18,9.47 178.42,9.47 178.96,8.93 184.9,8.93 185.54,8.3 189.81,8.3 193.05,11.54 197.72,11.54 198.59,12.41 202.93,12.41 204.34,11.01 208.06,11.01 208.41,10.66 210.92,10.66 213.96,13.7 218.27,13.7 222.53,17.96 241.04,17.96 243.91,20.82 276.74,20.82 277.28,21.37 v1(278.36,21.37)
  BOTTOM w0.102: UH4.V10 161.99,22.77 v1(161.68,22.46) ; v1(162.25,16.43) 162.25,16.27 RH87.2
MOD_SATA_PCIE#_DET: length 4.8
  TOP w0.102: v2(263.8,85.27) 263.8,83.57 R773.1 263.33,82.56 263.25,82.48 263.25,81.28 263.34,81.19 U46.A42
MODULE_BATT_PRES#: length 5.3
  TOP w0.102: v1(267.38,71.38) 267.09,71.09 U46.B15 ; R764.1 268.03,68.6 v1(267.58,69.04)
  IN1 w0.084: v1(267.38,71.38) 267.58,71.18 v1(267.58,69.04)
  BOTTOM w0.102: v1(267.58,69.04) 267.58,69.11 v2(268,69.53)
MSATA_DET#: length 117.6
  TOP w0.102: v1(264.88,26.71) v2(264.01,25.84) 263.53,25.36 R711.2 R708.2
  IN4 w0.084: v1(172.05,40.11) 172.86,39.3 174.46,39.3 174.72,39.05 174.72,36.63 175.74,35.6 179.96,35.6 180.68,34.88 180.68,32.72 183.88,29.52 192.48,29.52 196.22,25.77 199.85,25.77 201,24.62 229.44,24.62 233.14,28.32 263.27,28.32 v1(264.88,26.71)
  BOTTOM w0.102: UH4.C41 169.62,38.39 169.93,38.7 170.21,38.7 170.37,38.53 170.61,38.53 172.05,39.97 v1(172.05,40.11) ; v1(264.88,26.71) 264.88,25.24 266.02,24.1 JMINI3.37
MSATA_EN: length 20.4
  TOP w0.102: v3(271.01,88.4) R808.1 R806.2 ; U46.B53 260.08,78.81 260.3,78.58 v1(260.3,78.6)
  IN3 w0.122: v1(260.3,78.6) 260.89,79.18 260.89,82.51 262.16,83.78 267.28,83.78 271.01,87.51 v3(271.01,88.4)
MSATA_PRX_DTX_N0: length 2.8
  BOTTOM w0.102: JMINI3.25 269.53,28.9 269.8,29.17 270.73,29.17 C1309.2
MSATA_PRX_DTX_N0_C: length 130.8
  IN4 w0.091: v1(155.96,17) 156.19,17.24 156.29,17.24 161.03,12.5 167.04,12.5 167.55,13 180.29,13 180.94,13.65 196.78,13.65 202.24,19.11 219.97,19.11 220.56,19.71 233.56,19.71 236.16,22.31 261.64,22.31 263.19,23.86 267.29,23.86 270.85,27.42 270.85,28.48 271.58,29.21 272.36,29.21 v3(272.61,28.97)
  BOTTOM w0.102: v3(272.61,28.97) 272.42,29.15 272.26,29.15 C1309.1 ; v1(155.96,17) 155.85,17.1 155.23,17.1 154.74,17.59 154.74,18.36 154.94,18.56 154.94,18.86 155.07,18.99 155.07,19.37 UH4.AM3
MSATA_PRX_DTX_P0: length 2.8
  BOTTOM w0.102: C1310.2 270.74,29.43 269.81,29.43 269.54,29.7 JMINI3.23
MSATA_PRX_DTX_P0_C: length 130.8
  IN4 w0.084: v3(155.96,17.64) 155.97,17.62 156.02,17.59
  IN4 w0.091: 156.02,17.59 156.02,17.57 156.14,17.45 156.37,17.45 161.11,12.71 166.95,12.71 167.46,13.22 180.21,13.22 180.85,13.87 196.69,13.87 202.15,19.33 219.88,19.33 220.47,19.92 233.47,19.92 236.07,22.53 261.55,22.53 263.1,24.07 267.2,24.07 270.64,27.51 270.64,28.57 271.49,29.42 272.43,29.42 v1(272.61,29.6)
  BOTTOM w0.102: v3(155.96,17.64) 155.69,17.37 155.34,17.37 155,17.7 155,18.24 155.05,18.29 155.64,18.29 155.72,18.37 155.72,18.69 155.48,18.93 155.39,18.93 155.25,18.78 UH4.AM1 ; v1(272.61,29.6) 272.42,29.42 272.28,29.42 C1310.1
MSATA_PTX_DRX_N0: length 2
  BOTTOM w0.102: JMINI3.31 269.48,26.5 269.77,26.21 270.03,26.21 C617.2
MSATA_PTX_DRX_N0_C: length 131.7
  IN4 w0.091: v3(271.88,26.36) 271.71,26.18 270.94,26.18 266.56,21.8 236.38,21.8 233.81,19.24 220.76,19.24 220.16,18.64 203.61,18.64 201.25,16.28 200.55,16.28 197.38,13.11 181.59,13.11 180.5,12.02 159.56,12.02 155.69,15.9 155.15,15.9 154.82,16.23 154.82,16.82 155.36,17.37 155.36,20.69 155.09,20.97 154.86,20.97 v1(154.66,21.17)
  BOTTOM w0.102: C617.1 271.54,26.17 271.7,26.17 v3(271.88,26.36) ; v1(154.66,21.17) 154.33,21.5 UH4.AP7
MSATA_PTX_DRX_P0: length 2.1
  BOTTOM w0.102: JMINI3.33 269.51,25.7 269.75,25.94 269.97,25.94 C618.2
MSATA_PTX_DRX_P0_C: length 131.8
  IN4 w0.091: v1(271.88,25.72) 271.63,25.97 271.03,25.97 266.65,21.59 236.47,21.59 233.9,19.02 220.84,19.02 220.25,18.43 203.7,18.43 201.34,16.07 200.64,16.07 197.47,12.9 181.67,12.9 180.59,11.81 159.47,11.81 155.6,15.68 155.06,15.68 154.61,16.14 154.61,16.91 155.15,17.46 155.15,20.6 155,20.75 154.78,20.75 154.66,20.64 v3(154.66,20.53)
  BOTTOM w0.102: v1(271.88,25.72) 271.7,25.9 271.53,25.9 C618.1 ; v3(154.66,20.53) 154.33,20.86 UH4.AP5
MSCLK: length 42.9
  TOP w0.102: v1(284.16,57.93) 283.74,58.35 U51.B43 ; JDEG2.6 262.95,59.81 v2(263.34,60.2) 263.34,60.21 v1(263.74,60.61) 264.09,60.96 R847.2
  IN1 w0.084: v1(284.16,57.93) 282.04,57.93 281.27,58.7 272.65,58.7 272.18,59.17 264.95,59.17 263.98,60.15 263.98,60.38 v1(263.74,60.61) 263.96,60.83 263.96,60.96 263.61,61.31 258.58,61.31 256.74,59.47 256.74,57.02 256.37,56.64 255.05,56.64 254.69,56.28 v1(254.69,55.62)
  BOTTOM w0.102: JMINI2.19 255.4,56.99 254.69,56.28 v1(254.69,55.62)
MSDATA: length 53.7
  TOP w0.102: JDEG2.7 263.45,59.69 v1(264.38,60.61) 264.98,61.21 R850.2 ; U51.A40 281.99,58.6 v1(281.81,58.77) 280.84,58.77 R869.1
  IN1 w0.084: v3(249.69,54.37) 250.35,55.03 252.82,55.03 254.65,56.86 256.28,56.86 256.53,57.11 256.53,59.56 258.5,61.52 263.69,61.52 264.17,61.05 264.17,60.83 v1(264.38,60.61) 264.19,60.43 264.19,60.23 265.04,59.38 272.27,59.38 272.74,58.91 281.67,58.91 v1(281.81,58.77)
  IN3 w0.122: v1(261.45,65.51) 260.95,65.02 260.95,63.19 262.9,61.25 263.74,61.25 v1(264.38,60.61)
  BOTTOM w0.102: v1(261.45,65.51) 260.89,65.51 260.6,65.81 JMINI2.14 ; v3(249.69,54.37) 249.79,54.47 R706.2
NB_LAN_TX0+: length 6.5
  BOTTOM w0.089: JLOM1.1 317.05,82.47 315.64,83.89 315.64,85.21 315.16,85.69 314.9,85.69 314.81,85.78 314.81,86.08 314.73,86.17 TR1.13
NB_LAN_TX0-: length 6.5
  BOTTOM w0.089: TR1.14 314.73,84.9 314.81,84.98 314.81,85.28 314.9,85.37 315.03,85.37 315.32,85.08 315.32,83.75 316.95,82.13 316.95,81.74 JLOM1.2
NB_LAN_TX1+: length 4.8
  IN4 w0.084: JLOM1.3 315.41,80.43 v1(315.3,80.54)
  BOTTOM w0.089: TR1.17 314.76,81.09 314.84,81.01 314.84,80.45 314.94,80.35 315.11,80.35 v1(315.3,80.54)
NB_LAN_TX1-: length 4.8
  IN4 w0.084: v1(315.3,79.9) 315.54,79.66 315.54,78.49 JLOM1.6
  BOTTOM w0.089: v1(315.3,79.9) 315.17,80.03 314.9,80.03 314.68,79.82 TR1.18
NB_LAN_TX2+: length 4.7
  BOTTOM w0.089: JLOM1.4 316.96,79.11 316.96,78.78 316.72,78.53 315.85,78.53 315.38,78.07 314.98,78.07 314.89,78.16 314.89,78.46 314.8,78.55 TR1.19
NB_LAN_TX2-: length 4.7
  BOTTOM w0.089: JLOM1.5 317.02,78.39 316.85,78.22 315.98,78.22 315.52,77.75 314.98,77.75 314.89,77.66 314.89,77.36 314.8,77.28 TR1.20
NB_LAN_TX3+: length 7.6
  BOTTOM w0.089: JLOM1.7 317,76.35 316.86,76.49 315.82,76.49 315.27,75.94 315.27,73.09 315.17,72.99 314.95,72.99 314.87,73.08 314.87,73.38 314.78,73.47 TR1.23
NB_LAN_TX3-: length 7.6
  BOTTOM w0.089: TR1.24 314.78,72.2 314.87,72.28 314.87,72.58 314.95,72.67 315.3,72.67 315.59,72.96 315.59,75.8 315.96,76.17 316.73,76.17 316.97,75.93 316.97,75.64 JLOM1.8
NB_PSID: length 24.5
  TOP w0.102: v1(30.38,71.27) v2(31.06,71.27)
  TOP w0.254: PL4.2 32.71,82.1 v1(32.73,82.13) 33.61,83 PD7.2
  IN1 w0.254: v1(32.73,82.13) 32.73,73.62 v1(30.38,71.27)
  BOTTOM w0.254: PJPDC1.1 23.2,71.49 23.63,71.92 29.74,71.92 v1(30.38,71.27)
NC: length 3.4
  TOP w0.102: T144.1 8.35,69.97 JCRT1.11
NC_P: length 4
  BOTTOM w0.102: U39.14 U37.14 259.08,55.43 259.01,55.5 C554.1 258.18,56.07 v2(258.65,56.54)
NTC: length 20
  TOP w0.203: PR727.1 146.65,87.28 v1(146.65,87.46)
  IN4 w0.254: v1(154.36,79.49) 153.85,79.99 153.85,83.56 151.1,86.31 147.8,86.31 v1(146.65,87.46)
  BOTTOM w0.203: PU700.10 146.19,87.31 146.33,87.46 v1(146.65,87.46)
  BOTTOM w0.254: v1(154.36,79.49) 154.53,79.65 155.05,79.65 155.42,79.28 v2(155.42,78.1) 155.42,76.07 155.29,75.94 155.09,75.94 PH702.1
NTCG: length 25.5
  TOP w0.254: PR715.1 143.57,87.89 v1(143.57,87.93) ; v3(122.66,85.16) 122.84,85.34 123.36,85.34 PH701.1
  IN2 w0.254: v1(143.57,87.93) 143.57,87.91 142.61,86.95 138,86.95 136.39,85.34 122.85,85.34 122.67,85.16 v3(122.66,85.16)
  BOTTOM w0.203: v1(143.57,87.93) 143.57,87.7 143.79,87.48 PU700.4
P1_SW: length 40.4
  IN4 w0.254: v1(154.46,86.13) 155.21,86.13 157.64,83.7 157.64,78.39 155.05,75.81 155.05,67.88 153.85,66.68 153.85,65.59 151.66,63.4 145.27,63.4 144.61,64.06 144.61,65.16 145.06,65.62 v1(145.14,65.62)
  BOTTOM w0.102: v2(155.1,86) 154.59,86 v1(154.46,86.13)
  BOTTOM w0.254: v1(145.14,65.62) 145.37,65.62 145.75,65.24 PL702.3 ; PR755.2 154.46,86.84 v1(154.46,86.13)
P1_VO: length 38.8
  IN4 w0.254: v1(145.14,64.93) 145.23,64.84 145.23,64.13 145.58,63.78 151.5,63.78 153.47,65.75 153.47,66.84 154.67,68.04 154.67,75.97 157.26,78.56 157.26,83.54 155.35,85.46 154.45,85.46 v1(154.44,85.44)
  BOTTOM w0.102: v1(154.44,85.44) v2(154.44,84.6)
  BOTTOM w0.254: v1(154.44,85.44) 154.31,85.44 153.64,86.12 PR757.1 ; v1(145.14,64.93) 144.96,64.93 144.66,65.24 PL702.2
PANEL_BKEN_EC: length 273.1
  TOP w0.102: v2(95.61,101.47) v1(94.86,101.47) ; v1(267.33,81.69) 266.84,81.21 U46.A35 ; v1(96.76,84.27) 96.36,84.67 D69.2
  IN1 w0.084: v1(94.86,101.47) 95.27,101.06 95.27,85.76 v1(96.76,84.27)
  IN2 w0.122: v1(267.33,81.69) 266.22,80.59 259.98,80.59 258.23,78.85 258.23,75.7 257.29,74.76 257.29,72.05 257.08,71.84 256.47,71.84 256.05,71.42 256.05,70.1 254.25,68.3 254.25,65.16 250.56,61.47 242.96,61.47 235.96,54.47 234.49,54.47 232.62,52.6 230.15,52.6 221,43.45 221,41.83 217.66,38.49 212.98,38.49 211.31,36.82 199.21,36.82 193.01,43.01 187.06,43.01 180.59,49.49 173.66,49.49 168.08,55.06 168.08,66.88 167.65,67.32 167.65,68.16 166.73,69.08 166.73,78.14 167.23,78.65 167.23,81.15 165.93,82.45 165.93,94.78 164.44,96.27 158.99,96.27 156.47,98.79 156.47,99.63 156.52,99.68 156.52,100.39 155.44,101.47 147.9,101.47 147.57,101.14 137.94,101.14 137.48,101.6 136.63,101.6 135.11,103.12 106.01,103.12 103.62,105.51 98.9,105.51 v1(94.86,101.47)
PANEL_BKEN_PCH: length 135
  TOP w0.102: v1(105.97,87.16) 105.97,86.47 104.21,84.71 100.79,84.71 100.07,85.42 v2(99.52,85.42) D67.2
  IN1 w0.084: v1(105.97,87.16) 106.58,87.76 v1(106.58,98.94)
  IN2 w0.102: 167.94,43.37 167.94,42.21 166.64,40.91 v1(166.64,40.41)
  IN2 w0.122: v1(106.58,98.94) 107.26,99.62 133.18,99.62 134.9,97.9 140.9,97.9 141.54,98.54 147.97,98.54 150.01,96.5 154.81,96.5 158.42,92.89 158.42,89.07 162.06,85.43 162.06,73.32 162.41,72.97 162.41,62.24 163.23,61.43 163.23,57.17 164.06,56.33 164.06,54.29 166.29,52.07 166.29,49.27 168.29,47.27 168.29,44.35 167.94,44 167.94,43.37
  BOTTOM w0.102: v1(166.64,40.41) 166.64,41.04 UH4.J47
PANEL_HDD_LED: length 98.9
  IN2 w0.122: v3(112.54,101.4) 126.29,101.4 127.04,100.64 135.82,100.64 136.11,100.35 136.97,100.35 137.67,99.65 153.45,99.65 159.15,93.96 160.12,93.96 161.92,92.16 161.92,90.04 163.82,88.14 163.82,81.75 164.54,81.03 164.54,75.11 163.94,74.51 163.94,64.66 v1(164.53,64.07)
  BOTTOM w0.102: v1(164.53,64.07) 165.93,64.07 166.3,64.44 167.18,64.44 167.71,64.97 167.71,67.73 Q81.3 ; JLVDS1.5 109.1,108.38 112.18,105.29 112.18,101.75 v3(112.54,101.4)
PBAT_PRES#: length 294
  TOP w0.102: U46.B40 265.59,79.14 v1(265.02,78.58) ; v1(176.62,6.08) 177.36,6.82 177.95,6.82 178.57,7.44 178.57,8.57 183.13,13.13 184.9,13.13 186.28,14.5 188.89,14.5 190.72,16.33 190.72,23.02 191.81,24.11 191.81,25.55 194.62,28.35 v2(194.62,33.41) 194.62,43.75 v1(194.61,43.76)
  TOP w0.254: v1(52.35,12.81) 53.55,11.61 53.55,9.92 53.19,9.56 53.19,6.02 PR6.2 PR8.2
  IN1 w0.084: v1(194.61,43.76) 194.61,43.18 196.06,41.73 196.06,39.97 199.2,36.84 217.7,36.84 234.9,54.05 234.9,56.18 238.66,59.94 238.66,66.64 237.4,67.91 237.4,70.49 238.33,71.42 241.19,71.42 241.4,71.64 251.73,71.64 251.95,71.86 254.89,71.86 254.98,71.76 255.73,71.76 255.9,71.93 257.57,71.93 258.83,73.19 260.98,73.19 265.02,77.23 v1(265.02,78.58)
  IN2 w0.122: v1(52.35,12.81) 52.59,12.57 61.66,12.57 61.96,12.28 83.5,12.28 85.56,14.34 93.83,14.34 96.73,17.24 129.91,17.24 133.83,13.33 140.13,13.33 141.26,12.2 148.05,12.2 150.51,9.74 153.75,9.74 154.87,8.62 156.83,8.62 158.83,6.61 170.94,6.61 172.54,5.02 175.56,5.02 v1(176.62,6.08)
PBAT_SMBCLK: length 289.1
  TOP w0.102: PR7.2 55.4,5.05 55.4,4.82 v1(55.59,4.63) ; v1(287.44,49.5) 287.27,49.32 v1(287.27,48.89) 287.27,48.68 287.41,48.54 287.41,48.29 R820.2 ; U51.A56 v1(287.76,52.14)
  IN1 w0.084: v1(89.45,9.91) 89.66,10.12 92.11,10.12 92.45,10.46 94.99,10.46 100,15.48 137.42,15.48 138.85,14.05 139.08,14.05 140.55,12.58 145.97,12.58 146.67,11.88 149.03,11.88 149.47,12.32 155.57,12.32 160.51,7.38 167.05,7.38 169.83,10.16 169.83,12.25 171.81,14.23 178.01,14.23 181.38,17.6 195.97,17.6 197.46,16.11 213.03,16.11 213.11,16.19 242.26,16.19 243.45,17.38 246.77,17.38 247.8,18.42 259.93,18.42 260.29,18.77 285.51,18.77 v1(285.61,18.68)
  IN3 w0.122: v1(287.76,52.14) 287.76,52.83 287.48,53.11 287.07,53.11 286.93,52.98 286.93,50.92 287.25,50.6 287.25,49.69 v1(287.44,49.5) 287.25,49.3 287.25,46.21 286.97,45.94 286.97,43.03 286.62,42.68 286.62,40.52 286.91,40.22 286.91,38.09 286.71,37.89 286.71,29.31 285.68,28.27 285.68,20.52 286.39,19.81 286.39,19.19 286.13,18.92 285.85,18.92 v1(285.61,18.68)
  IN4 w0.084: v1(55.59,4.63) 55.38,4.84 55.38,7.56 55.94,8.11 86.64,8.11 88.66,10.13 89.23,10.13 v1(89.45,9.91)
PBAT_SMBDAT: length 289.6
  TOP w0.102: PR9.2 54.84,5.34 55.17,5.01 55.17,4.85 v1(54.96,4.63) ; R818.2 287.18,48.29 287.18,48.44 287.01,48.61 287.01,49.29 v1(286.81,49.5) ; U51.B59 287.51,54.4 v1(287.57,54.46)
  IN1 w0.084: v3(285.61,19.31) 285.39,19.1 285.39,19.06 285.31,18.98 260.2,18.98 259.85,18.63 247.71,18.63 246.68,17.59 243.36,17.59 242.17,16.4 213.02,16.4 212.95,16.32 197.55,16.32 196.06,17.81 181.3,17.81 177.93,14.44 171.73,14.44 169.62,12.34 169.62,10.25 166.96,7.6 160.6,7.6 155.66,12.53 149.38,12.53 148.94,12.09 146.75,12.09 146.06,12.79 140.64,12.79 139.17,14.26 138.94,14.26 137.51,15.69 99.92,15.69 94.9,10.67 92.36,10.67 92.02,10.33 89.66,10.33 v1(89.45,10.54)
  IN3 w0.122: v1(287.57,54.46) 287.57,53.44 287.48,53.36 286.96,53.36 286.69,53.08 286.69,50.82 287,50.5 287,49.69 v1(286.81,49.5) 287,49.31 287,46.31 286.73,46.04 286.73,43.14 286.37,42.78 286.37,40.41 286.66,40.12 286.66,38.19 286.47,37.99 286.47,29.41 285.43,28.37 285.43,20.42 286.14,19.71 286.14,19.29 286.02,19.17 285.75,19.17 v3(285.61,19.31)
  IN4 w0.084: v1(54.96,4.63) 55.17,4.84 55.17,7.64 55.85,8.32 86.55,8.32 88.57,10.34 89.25,10.34 v1(89.45,10.54)
PBATT+_C: length 1.2
  BOTTOM w0.102: v4(58.65,8.86) 58.65,7.68
PCH_ALW_ON: length 491.7
  TOP w0.102: PR25.1 33.85,74.64 34.51,75.3 v4(34.51,75.51) 34.51,76.22 v1(34.32,76.41) ; v1(288.45,67.78) 288.19,67.78 288.02,67.6 288.02,66.67 R880.2 288.76,65.93 U51.A23
  IN4 w0.084: v1(220.22,13.74) 219.78,13.29 219.12,13.29 218.88,13.05 210.36,13.05 209.82,13.59 207.96,13.59 207.18,12.8 207.18,8.93 210.15,5.95 210.15,4.48 v1(209.72,4.05) ; v1(299.9,36.84) 298.05,34.99 277.65,34.99 276.64,36 v1(266.01,36) ; v1(288.45,67.78) 287.19,66.52 284.7,66.52 282.48,64.3 277.46,64.3 275.8,62.63 273.31,62.63 270.12,59.45 253.26,59.45 252.59,58.78 245.53,58.78 244.59,57.85 244.59,56.83 242.74,54.98 237.6,54.98 236.17,53.54 232.89,53.54 216.63,37.28 199.07,37.28 191.14,45.21 187.75,45.21 185.18,47.77 185.18,48.42 182.58,51.03 173.75,51.03 171.23,53.54 171.23,58.66 169.43,60.46 169.43,70.73 168.64,71.53 168.64,75.27 169.97,76.6 169.97,80.01 160.93,89.05 160.05,89.05 153.17,95.93 140.19,95.93 136.53,99.59 133.44,99.59 130.53,102.5 116.5,102.5 114.05,100.05 105.47,100.05 97.74,92.33 89.76,92.33 88.08,90.65 85.79,90.65 85.48,90.33 68.26,90.33 64.8,86.88 49.99,86.88 42.93,79.82 37.72,79.82 v1(34.32,76.41)
  BOTTOM w0.102: v1(220.22,13.74) 220.22,15.28 226.04,21.09 230.27,21.09 231.55,22.37 239.04,22.37 240.51,23.84 240.51,29.05 243.92,32.47 257.55,32.47 258.88,33.8 263.81,33.8 v1(266.01,36) ; R737.1 209.64,3.97 v1(209.72,4.05) ; v1(299.9,36.84) 300.32,36.84 301.87,38.39 301.87,43.61 299.15,46.33 299.15,63.28 297.78,64.65 297.78,67.26 295.93,69.11 288.94,69.11 288.45,68.62 v1(288.45,67.78)
PCH_AZ_BITCLK: length 16
  TOP w0.102: v1(164.72,35.51) 165.33,34.91 v2(165.45,34.91) 166.3,34.91 167.29,33.92 169.17,33.92 170.43,32.66 175.02,32.66 175.25,32.89 176.88,32.89 v1(177.3,33.31)
  BOTTOM w0.102: UH4.N34 164.43,35.22 v1(164.72,35.51) ; v1(177.3,33.31) 177.3,33.7 177.69,34.1 RH25.2
PCH_AZ_CODEC_BITCLK: length 196.6
  TOP w0.102: U72.6 35.77,37.16 v1(35.82,37.11) 36.42,37.11 v2(36.71,36.81) 36.84,36.68 R1076.1
  IN3 w0.122: v1(35.82,37.11) 35.82,35.81 36.46,35.16 37.52,35.16 38.07,35.71 42.82,35.71 44.73,33.8 44.73,17.67 50.96,11.45 56.96,11.45 57.45,11.95 60.82,11.95 62.44,10.32 69.82,10.32 74.32,5.81 91.04,5.81 99.26,14.03 104.4,14.03 105.23,14.86 129.66,14.86 132.32,12.2 140.38,12.2 141.05,11.53 146.93,11.53 147.59,10.87 150.24,10.87 150.91,11.54 160.44,11.54 161.92,13.02 170.76,13.02 173.03,15.29 174.17,15.29 175.54,16.66 175.54,19.94 175.72,20.12 175.72,25.94 177.53,27.76 177.53,29.86 180.08,32.4 180.08,34.04 v1(179.65,34.46)
  BOTTOM w0.102: CH101.1 RH25.1 179.28,34.1 v1(179.65,34.46)
PCH_AZ_CODEC_RST#: length 187.8
  TOP w0.102: U72.11 36.29,39.66 v3(36.51,39.44)
  IN3 w0.102: 174.55,17.97 174.17,17.59
  IN3 w0.122: v1(176.85,31.21) 176.28,30.65 176.28,28.45 175.22,27.38 175.22,20.32 175.04,20.15 175.04,18.45 174.55,17.97 ; v3(36.51,39.44) 36.57,39.38 36.57,35.76 36.67,35.66 37.23,35.66 37.78,36.21 43.2,36.21 45.23,34.18 45.23,18.95 52.24,11.95 56.75,11.95 57.25,12.44 69.69,12.44 75.62,6.51 91.04,6.51 99.89,15.36 129.87,15.36 132.53,12.7 140.58,12.7 141.21,12.07 159.17,12.07 161.42,14.33 170.91,14.33 174.17,17.59
  BOTTOM w0.102: v1(176.85,31.21) 176.73,31.33 RH27.1
PCH_AZ_CODEC_SDIN0: length 188.1
  TOP w0.102: R1096.1 v3(39.53,37.63)
  IN3 w0.122: v3(39.53,37.63) 39.68,37.78 42.33,37.78 45.73,34.38 45.73,19.58 52.05,13.25 69.58,13.25 75.83,7.01 90.83,7.01 99.68,15.86 130.07,15.86 132.09,13.85 133.92,13.85 134.57,13.2 140.79,13.2 141.41,12.58 158.97,12.58 161.22,14.83 170.7,14.83 173.96,18.08 173.96,19.83 174.72,20.6 174.72,27.63 175.04,27.95 175.04,33.08 173.26,34.86 168.26,34.86 168.03,35.09 v1(168.03,35.4)
  BOTTOM w0.102: v1(168.03,35.4) 168.03,35.4 168.31,35.11 UH4.E34
PCH_AZ_CODEC_SDOUT: length 187.5
  TOP w0.102: v1(176.66,33.32) v4(175.97,33.32) ; U72.5 36.24,36.66 36.76,36.14 v1(37.01,36.14) 37.35,35.8 R1077.1
  IN3 w0.122: v1(176.66,33.32) 176.03,32.69 176.03,28.55 174.97,27.48 174.97,20.43 174.79,20.25 174.79,18.56 170.81,14.58 161.32,14.58 159.07,12.33 141.31,12.33 140.69,12.95 134.46,12.95 133.82,13.6 131.99,13.6 129.97,15.61 99.78,15.61 90.93,6.76 75.72,6.76 69.79,12.69 57.15,12.69 56.65,12.19 52.34,12.19 45.48,19.06 45.48,34.28 43.3,36.46 37.33,36.46 v1(37.01,36.14)
  BOTTOM w0.102: RH29.1 176.55,33.21 v1(176.66,33.32)
PCH_AZ_CODEC_SYNC: length 192.5
  TOP w0.102: v3(35.82,39.23) 35.75,39.16 U72.10
  IN3 w0.122: v3(35.82,39.23) 36.32,38.73 36.32,35.66 36.57,35.41 37.36,35.41 37.91,35.96 43.09,35.96 44.98,34.07 44.98,17.77 51.06,11.7 56.85,11.7 57.35,12.19 60.92,12.19 62.55,10.57 69.92,10.57 74.43,6.06 90.94,6.06 99.19,14.31 104.33,14.31 105.13,15.11 129.77,15.11 132.43,12.45 140.48,12.45 141.14,11.79 160.34,11.79 161.82,13.27 170.66,13.27 172.97,15.58 174.07,15.58 175.29,16.8 175.29,20.04 175.47,20.22 175.47,27.28 177.15,28.95 177.15,29.82 178.15,30.83 v1(178.15,31.21)
  BOTTOM w0.102: RH26.1 180.73,30.81 180.5,30.58 178.78,30.58 v1(178.15,31.21)
PCH_AZ_RST#: length 12.9
  TOP w0.102: v1(174.16,33.37) 174.16,33.59 174.05,33.7 173.59,33.7 173.51,33.63 173.51,33.01 173.39,32.88 170.79,32.88 168.79,34.88 166.83,34.88 166.73,34.98 v1(166.73,35.45)
  BOTTOM w0.102: UH4.K34 166.41,35.14 v1(166.73,35.45) ; RH27.2 174.48,32.04 174.48,32.37 174.16,32.69 v2(174.16,32.75) v1(174.16,33.37)
PCH_AZ_SDIN0_R: length 3.3
  TOP w0.254: R1096.2 37.56,37.63 37.03,38.16 v2(36.84,38.16) U72.8
PCH_AZ_SDOUT: length 12.8
  BOTTOM w0.102: UH4.A36 170.53,35.91 170.59,35.85 171.51,35.85 171.59,35.77 171.59,35.52 171.67,35.44 171.94,35.44 172.02,35.52 172.02,36.39 172.09,36.47 172.35,36.47 172.42,36.39 172.42,35.51 172.5,35.43 172.75,35.43 172.83,35.51 172.83,36.67 172.91,36.75 173.16,36.75 173.24,36.67 173.24,35.5 173.31,35.43 173.57,35.43 173.64,35.5 v2(173.64,35.98) 173.64,36.1 173.74,36.2 173.95,36.2 174.05,36.1 174.05,35.66 174.15,35.56 RH287.2 RH50.2 RH29.2
PCH_AZ_SYNC: length 20.4
  TOP w0.102: v1(166.07,34.34) 167.44,32.98 169.53,32.98 v2(170.46,32.04) 171.33,31.18 175.27,31.18 175.96,31.87 178.91,31.87 179.2,32.17 179.2,33.59 179.57,33.96 180.18,33.96 RH66.2 181.36,34.36 v1(181.44,34.29)
  BOTTOM w0.102: v1(166.07,34.34) 165.77,34.64 UH4.L34 ; QH7.1 181.38,34.35 v1(181.44,34.29)
PCH_AZ_SYNC_Q:
  vias: v2(178.8,31.05)
PCH_BATLOW#: length 10.3
  TOP w0.102: v1(167.96,23.53) 168.38,23.95 170.02,23.95 170.8,23.17 171.7,23.17 173.94,20.93 v2(173.94,20.22) 173.94,20.05 v1(174.38,19.62)
  BOTTOM w0.102: v1(167.96,23.53) 168.31,23.17 UH4.E10 ; RH139.2 v1(174.38,19.62)
PCH_CL_CLK1: length 119.1
  IN2 w0.102: v3(165.6,21.88) 165.6,22.64 165.85,22.9 166.49,22.9 166.76,22.63 166.76,22.22 167.04,21.93 170.53,21.93 171.04,21.42 174.52,21.42 174.53,21.41 174.55,21.41
  IN2 w0.122: v1(243.64,33.33) 243.44,33.52 241.4,33.52 237.12,29.24 235.43,29.24 230.22,24.03 218.41,24.03 216.97,22.59 194.93,22.59 194.14,21.8 190.31,21.8 189.46,22.64 186.54,22.64 185.07,21.17 182.94,21.17 181.2,19.43 178.87,19.43 177.89,20.41 175.89,20.41 174.89,21.41 174.55,21.41
  IN3 w0.122: v1(243.64,33.33) 243.86,33.55 244.13,33.55 244.52,33.94 244.52,43.03 243.12,44.43 243.12,46.9 244.4,48.18 244.4,56.67 245.01,57.29 245.01,58.99 244.7,59.3 244.7,60.33 v1(244.89,60.51)
  BOTTOM w0.102: JMINI2.45 245,59.74 244.69,60.05 244.69,60.31 v1(244.89,60.51) ; UH4.M7 165.22,21.5 v3(165.6,21.88)
PCH_CL_DATA1: length 120.3
  IN2 w0.102: 174.55,21.66 174.53,21.66 174.52,21.65 171.13,21.65 170.62,22.16 167.21,22.16 166.96,22.41 166.96,22.77 166.62,23.11 165.59,23.11 165.32,22.84 164.65,22.84 163.71,23.78 v1(163.71,23.85)
  IN2 w0.122: 174.55,21.66 175,21.66 176,20.66 178,20.66 178.97,19.68 181.1,19.68 182.84,21.42 184.96,21.42 186.43,22.89 189.57,22.89 190.41,22.05 194.04,22.05 194.83,22.84 216.87,22.84 218.31,24.28 230.12,24.28 235.33,29.49 237.01,29.49 241.3,33.78 243.45,33.78 v3(243.64,33.96)
  IN3 w0.122: v1(244.26,60.51) 244.46,60.32 244.46,59.2 244.77,58.89 244.77,57.39 244.15,56.78 244.15,48.28 242.87,47 242.87,44.33 244.27,42.93 244.27,34.05 244.02,33.8 243.8,33.8 v3(243.64,33.96)
  BOTTOM w0.102: v1(244.26,60.51) 244.46,60.31 244.46,60.01 244.2,59.75 244.2,58.94 JMINI2.47 ; UH4.T11 163.25,23.4 163.68,23.83 163.7,23.83 v1(163.71,23.85)
PCH_CL_RST1#: length 140.1
  TOP w0.102: R707.1 241,59.12 v1(241,57.74) 241,57.71 v2(241.37,57.34) ; v1(163.71,23.03) 163.58,22.9 162.43,22.9 162.15,22.62 162.15,22.29 161.91,22.05 161.36,22.05 161.03,21.72 161.03,20.03 160.87,19.87 160.87,18.01 160.51,17.65 160.51,16.23 161.55,15.19 164.55,15.19 165.14,14.59 168.45,14.59 168.93,14.11 168.93,11.21 v1(173.79,6.35)
  IN3 w0.122: v1(241,57.74) 241,56.6 241.74,55.86 241.74,49.78 239.9,47.94 239.9,39.6 238.36,38.06 238.36,28.65 235.75,26.04 235.75,22.76 232.71,19.72 222.31,19.72 214.86,12.28 214.03,12.28 209.85,8.1 204.03,8.1 202.03,10.1 190.77,10.1 187.16,6.49 178.69,6.49 177.5,5.29 174.85,5.29 v1(173.79,6.35)
  BOTTOM w0.102: v1(163.71,23.03) 163.98,22.77 UH4.P10
PCH_CRT_DDC_CLK: length 24.9
  IN3 w0.102: 169.8,38.16 169.77,38.16 169.76,38.15 169.01,38.15 168.85,37.98 166.67,37.98 166.22,38.44 166.22,38.69 166,38.91 164.31,38.91 163.86,38.45 v1(163.7,38.45)
  IN3 w0.122: 169.8,38.16 170.66,38.16 170.76,38.05 171.67,38.05 172.74,39.13 172.74,39.79 173.63,40.68 173.85,40.68 174.4,41.24 178.25,41.24 178.89,40.6 178.89,39.5 178.62,39.24 178.62,38.95 178.62,38.95 v3(179.89,37.68)
  BOTTOM w0.102: QH6.1 179.8,37.02 179.85,36.97 RH317.2 180.27,37.3 179.89,37.68 v3(179.89,37.68) ; UH4.T39 163.51,37.52 163.7,37.71 v1(163.7,38.45)
PCH_CRT_DDC_DAT: length 21.2
  IN3 w0.102: 169.8,37.91 169.77,37.91 169.76,37.92 169.11,37.92 168.94,37.75 166.58,37.75 165.85,38.48 v1(165.65,38.48)
  IN3 w0.122: v3(176.81,40.22) 177.61,39.43 178.46,39.43 178.64,39.61 178.64,40.49 178.14,40.99 174.51,40.99 173.95,40.43 173.74,40.43 172.99,39.68 172.99,39.02 171.77,37.81 170.65,37.81 170.55,37.91 169.8,37.91
  BOTTOM w0.102: v3(176.81,40.22) 176.81,40.17 177.04,39.94 RH316.2 177.72,39.52 177.84,39.39 QH6.4 ; UH4.M40 165.33,38.16 v1(165.65,38.48)
PCH_DPWROK: length 139.6
  TOP w0.102: R802.1 269.21,66.25 269.21,65.77 v1(268.8,65.36) 268.8,65.22 269.16,64.87 v4(269.59,64.87)
  IN2 w0.122: v1(270.05,39.91) 269.41,39.28 254.92,39.28 253.89,40.31 247.06,40.31 245.56,38.81 237.83,38.81 228.45,29.43 194.53,29.43 193.18,30.78 187.27,30.78 186.66,30.17 183.62,30.17 183.42,30.37 177.06,30.37 v1(176.73,30.03) 175,30.03 173.89,28.93 173.08,28.93 172.97,28.81 169.86,28.81 169.63,29.04 168.54,29.04 v1(168.02,28.53)
  IN3 w0.122: v1(268.8,65.36) 268.51,65.08 268.51,47.93 270.05,46.4 v1(270.05,39.91)
  BOTTOM w0.102: v1(176.73,30.03) 176.54,30.22 RH113.1 ; UH4.E22 168.31,28.82 v1(168.02,28.53)
PCH_GPIO3: length 15.2
  TOP w0.102: RH332.2 169.75,42.3 v2(172.37,42.3) 174.1,42.3 174.53,41.87 174.53,41.19 174.18,40.84 172.28,40.84 172.25,40.88 169.36,40.88 168.96,40.48 168.96,40.19 168.66,39.89 168.22,39.89 168,39.67 v1(168,38.39)
  BOTTOM w0.102: UH4.G40 167.68,38.07 v1(168,38.39)
PCH_GPIO6: length 10
  TOP w0.102: RH165.2 172.61,34.33 v2(172.18,34.76) 170.2,34.76 169.86,35.1 169.86,35.42 169.46,35.81 167.34,35.81 v1(166.71,36.44)
  BOTTOM w0.102: UH4.H36 167.04,36.11 v1(166.71,36.44)
PCH_GPIO7: length 6.2
  TOP w0.102: RH178.2 172.74,35.28 172.61,35.4 171.68,35.4 171.24,35.85 171.01,35.85 170.44,35.85 169.93,36.35 v2(168.79,36.35) 168.1,36.35 v1(168.01,36.44)
  BOTTOM w0.102: v1(168.01,36.44) 168.31,36.74 UH4.E38
PCH_GPIO15: length 8.9
  BOTTOM w0.102: UH4.G2 167.5,19.06 167.5,17.86 168.39,16.96 170.31,16.96 RH354.2 172.03,15.25 172.03,13.42 v2(172.1,13.34)
