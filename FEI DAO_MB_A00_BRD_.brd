# Allegro board FEI DAO_MB_A00_BRD_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
POWER_SW#_MB: length 193.2
  TOP w0.102: PWRSW1.1 309.82,45.92 C759.1 308.51,45.73 v1(303.28,45.73) 301.2,47.81 301.2,49.58 R811.2 299.95,50.36 299.9,50.41 C721.1 ; JLED1.8 162.25,61.66 162.02,61.43 160.62,61.43 160.37,61.17 160.37,58.28 v2(161.4,57.25) 161.4,57.25 162.37,56.28 v1(162.37,56.27)
  TOP w0.508: SW1.4 SW1.2 311.18,40.45 309.85,41.78 PWRSW1.1
  IN4 w0.084: v1(162.37,56.27) 163.17,56.27 169.92,49.51 171.31,49.51 172.54,48.29 180.94,48.29 181.56,47.67 181.56,47.05 190.75,37.86 193.6,37.86 197.66,33.79 218.47,33.79 220.45,35.78 230.62,35.78 234.29,39.45 254.32,39.45 254.98,38.79 264.48,38.79 270.96,45.27 280.47,45.27 281.13,44.62 286.13,44.62 286.95,45.44 288.54,45.44 289.24,44.74 302.29,44.74 v1(303.28,45.73)
  BOTTOM w0.102: v1(162.37,56.27) 162.82,56.27 164,55.09 D23.3
POWER_SW_IN#: length 233.1
  TOP w0.102: U51.B67 291.51,54.09 291.46,54.14 291.46,54.77 v1(291.72,55.04) ; v1(300.16,48.78) 300.41,49.03 R811.1 300.4,49.46 R810.2 299.51,49.44 C722.1
  IN1 w0.084: v1(291.72,55.04) 291.47,54.78 291.47,53.7 291.74,53.42 295.13,53.42 296,52.55 298.62,52.55 299.01,52.16 299.01,49.92 v1(300.16,48.78)
  IN2 w0.102: 171.95,43.37 172.29,43.02 172.29,41.32 173.2,40.41 174.55,40.41
  IN2 w0.122: 174.55,40.41 174.97,40.41 175.61,39.77 177.07,39.77 177.53,39.32 179.23,39.32 179.42,39.14 179.55,39 180.76,39 184.59,35.17 188.35,35.17 190.5,33.02 194.11,33.02 195.46,31.67 227.4,31.67 240.69,44.96 248.63,44.96 251.66,47.99 253.61,47.99 254.97,49.35 258.37,49.35 258.51,49.49 268.76,49.49 270.22,48.03 274.36,48.03 279.98,53.64 292.05,53.64 292.34,53.92 292.34,54.61 291.91,55.04 v1(291.72,55.04) ; 171.95,43.37 169.05,46.26 169.05,47.46 167.48,49.03 167.48,51.72 165.34,53.85 165.34,56.1 163.98,57.46 163.98,61.45 162.95,62.48 162.95,73.66 162.57,74.04 162.57,85.63 158.92,89.27 158.92,93.09 155,97.01 151.46,97.01 v1(151.01,97.46)
  BOTTOM w0.102: v1(151.01,97.46) 151.01,97.29 v2(151.31,96.99) 152.1,96.2 158.02,96.2 158.54,96.72 158.54,98.53 159.69,99.67 U9.20
PP: length 2.8
  BOTTOM w0.102: U39.7 U37.7 258.85,50.88 258.8,50.82 R656.1
PROCHOT#_EC: length 52.3
  TOP w0.102: U51.A46 282.26,55.6 282.04,55.38 281.61,55.38 281.48,55.25 281.08,55.25 280.92,55.41 v1(280.92,55.52) ; v1(280.77,48.69) 280.48,48.69 280.41,48.76 R1179.2 R1180.1 R812.2 278.23,49.66 v2(277.64,49.66) 277.64,49.91 277.36,50.19 276.62,50.19 276.14,49.71 Q47.2
  IN3 w0.122: v1(280.77,48.69) 280.77,47.87 280.68,47.78 280.23,47.78 279.7,47.25 279.7,46.97 279.78,46.89 280.67,46.89 280.75,46.82 280.75,46.5 280.67,46.43 279.78,46.43 279.7,46.35 279.7,46.02 279.78,45.94 280.41,45.94 280.53,45.82 280.53,42.9 280.61,42.83 281.39,42.83 281.46,42.9 281.46,43.92 281.54,43.99 281.96,43.99 282.03,43.92 282.03,42.19 281.96,42.11 281.24,42.11 281.16,42.03 281.16,41.65 281.24,41.57 282.5,41.57 282.58,41.65 282.58,44.4 282.5,44.47 281.18,44.47 281.1,44.55 281.1,44.89 281.18,44.96 281.87,44.96 281.95,45.04 281.95,45.37 281.87,45.45 281.23,45.45 281.16,45.53 281.16,46.34 281.23,46.42 282.57,46.42 282.65,46.5 282.65,46.86 282.57,46.94 281.63,46.94 281.55,47.01 281.55,47.35 281.63,47.42 282.14,47.42 282.22,47.5 282.22,47.82 282.14,47.9 281.97,47.9 281.89,47.98 281.89,48.37 281.97,48.45 282.14,48.45 282.22,48.52 282.22,49.3 282.14,49.38 280.57,49.38 280.49,49.45 280.49,49.83 280.57,49.91 281.39,49.91 281.47,49.98 281.47,50.3 281.39,50.38 280.57,50.38 280.49,50.45 280.49,51.52 280.57,51.6 281.26,51.6 281.33,51.67 281.33,52.01 281.26,52.08 280.57,52.08 280.49,52.16 280.49,52.54 280.57,52.61 281.26,52.61 281.33,52.69 281.33,53.42 281.26,53.5 280.57,53.5 280.49,53.57 280.49,53.93 280.61,54.05 280.81,54.05 280.89,54.13 280.89,54.46 280.81,54.54 280.57,54.54 280.49,54.61 280.49,55.43 280.58,55.52 v1(280.92,55.52)
PROCHOT_GATE: length 374.5
  TOP w0.102: U46.A50 258.31,78.56 257.37,79.5 v1(256.9,79.5) 256.74,79.5 R761.2 ; v1(41.56,85.38) v2(40.87,85.38)
  TOP w0.254: v1(38.89,26.24) 39.22,25.91 PU1302.2
  IN1 w0.084: v1(38.89,26.24) 37.22,27.91 37.22,33.77 38.6,35.15 38.6,40.34 41.18,42.92 41.18,51.15 44.4,54.38 44.4,62.04 43.75,62.69 43.75,62.95 44.53,63.73 44.53,70.91 43.26,72.18 43.26,79.02 42.17,80.11 42.17,84.77 v1(41.56,85.38)
  IN2 w0.122: v1(41.56,85.38) 43.73,87.55 64.6,87.55 66.22,89.18 74.53,89.18 78.83,93.48 78.83,94.41 80.21,95.78 92.53,95.78 93.59,96.84 93.59,101.2 98.39,106 103.93,106 106.31,103.62 135.32,103.62 136.84,102.1 137.69,102.1 138.14,101.64 147.36,101.64 147.74,102.02 155.73,102.02 158.24,99.5 158.24,98.13 159.6,96.77 164.64,96.77 166.43,94.98 166.43,82.66 167.73,81.36 167.73,78.42 167.22,77.91 167.22,69.29 168.17,68.35 168.17,67.53 168.58,67.12 168.58,58.55 169.26,57.87 169.26,54.58 173.86,49.98 180.79,49.98 187.27,43.51 193.24,43.51 199.44,37.31 211.1,37.31 212.77,38.99 217.45,38.99 220.5,42.04 220.5,43.9 229.7,53.1 232.42,53.1 235.04,55.72 236.51,55.72 242.75,61.96 250.35,61.96 252.27,63.88 252.27,66.5 252.96,67.19 252.96,72.33 253.56,72.93 255.19,72.93 256.38,74.13 256.38,78.98 v1(256.9,79.5)
PS_ID: length 310.9
  TOP w0.102: v2(45.2,79.82) 45.28,79.82 45.88,79.22 v1(45.88,79.03) ; U51.A55 287.26,51.74 v1(287.4,51.59)
  TOP w0.254: v1(41.5,78.18) PR12.1 PR13.2
  IN2 w0.122: v1(41.5,78.18) 45.03,78.18 v1(45.88,79.03)
  IN4 w0.084: v1(45.88,79.03) 48.62,81.77 53.3,81.77 54.1,82.57 62.08,82.57 64.87,85.36 65.49,85.36 68.91,88.78 86.68,88.78 86.93,89.03 91.65,89.03 92.34,89.72 101.03,89.72 109.63,98.33 114.82,98.33 116.2,99.7 130.93,99.7 133.42,97.22 135.18,97.22 135.97,96.42 135.97,94.87 137.35,93.5 139.47,93.5 139.69,93.72 152.88,93.72 159.27,87.32 160.26,87.32 167.47,80.1 167.47,71.15 168.35,70.27 168.35,58.08 167.43,57.16 167.43,55 170.9,51.53 171.68,51.53 173.24,49.97 181.82,49.97 183.49,48.3 183.49,47.5 187.72,43.27 189.29,43.27 192.85,39.72 194.12,39.72 198.36,35.48 217.34,35.48 219.33,37.46 229.86,37.46 236.13,43.73 252.86,43.73 254.34,45.21 258.27,45.21 259.34,46.28 266.24,46.28 267.53,47.57 269.65,47.57 272.57,50.49 275.5,50.49 275.69,50.68 277.69,50.68 280.61,53.6 285.41,53.6 285.86,53.14 285.87,53.14 287.4,51.6 v1(287.4,51.59)
PSID_DISABLE#: length 318.8
  TOP w0.102: v1(265.69,82.14) 265.84,81.99 U46.A37
  TOP w0.254: PR17.2 41.28,77.24 42,77.97 v2(42,82.65) v1(40.59,84.06)
  IN2 w0.122: v1(40.59,84.06) 40.59,85.89 43.21,88.5 62.62,88.5 69.09,94.98 70.5,94.98 72.05,96.53 92.22,96.53 92.84,97.15 92.84,101.57 98.02,106.75 104.39,106.75 105.58,105.55 114.02,105.55 114.71,104.86 135.83,104.86 136.72,103.97 151.04,103.97 151.22,104.15 155.71,104.15 159.38,100.48 161.19,100.48 161.91,99.76 164.41,99.76 168.95,95.21 168.95,87.16 168.09,86.3 168.09,84.17 169.07,83.19 169.07,82.16 169.27,81.96 169.27,80.62 170.92,78.96 170.92,68.41 171.38,67.95 171.38,63.79 170.8,63.21 170.8,61.86 171.39,61.26 171.39,60.6 173.54,58.46 177.7,58.46 182.56,53.6 182.56,50.19 185.39,47.36 186.98,47.36 188.83,45.51 194.3,45.51 195.32,44.49 213.07,44.49 214.6,46.01 219.84,46.01 236.47,62.64 236.47,64.81 239.77,68.12 239.77,69.49 241.22,70.94 241.84,70.94 253.37,82.47 256.02,82.47 257.2,83.65 264.17,83.65 v1(265.69,82.14)
PWM3: length 2.4
  BOTTOM w0.203: PU700.24 144.99,81.1 144.84,80.95 v2(144.84,80.6) 144.84,79.88 PR714.1
PWR_SRC_ON: length 4.5
  BOTTOM w0.102: Q21.3 146.16,99.88 146.39,99.65 v2(146.39,99.4) 146.04,99.06 145.9,99.06 R423.1 C297.2 R422.2
PWRSHARE_EN: length 5.2
  BOTTOM w0.102: U2.1 307.08,62.79 307.6,63.31 v2(307.6,63.51) 307.6,64.27 307.25,64.62 Q48.2 305.37,64.62 305.24,64.5 R784.2
PWRSHARE_EN#: length 15.8
  TOP w0.102: v1(308.27,63.35) 307.44,62.52 v2(307.44,60.44) 307.44,54.2 v1(306.89,53.65)
  BOTTOM w0.102: U75.5 306.14,52.88 305.97,53.05 305.97,53.43 306.2,53.65 v1(306.89,53.65) ; v1(308.27,63.35) 308.91,63.35 309.24,63.68 R816.1 308.46,65.27 Q48.1
R: length 6.1
  BOTTOM w0.102: JCRT1.1 6.25,70.82 7.14,71.71 8.67,71.71 9.23,71.15 C1205.1 10.15,70.1 L99.2
RBIAS_CPY: length 5
  BOTTOM w0.102: UH4.BH21 147.23,28.6 145.36,28.6 144.31,27.55 v2(143.82,27.55) RH112.2
RBIAS_SATA3: length 3.1
  BOTTOM w0.102: UH4.AH1 157.5,18.38 v2(157.5,16.69) 157.62,16.56 RH46.1
RED_CRT: length 229.9
  TOP w0.102: v1(11.83,67.71) 11,67.71 D83.2 10.99,68.36 v1(11.84,68.36)
  IN3 w0.122: v1(11.84,68.36) 11.84,71.97 13.12,73.24 13.12,77.04 13.99,77.91 21.63,77.91 21.94,77.61 24.58,77.61 24.9,77.29 27.25,77.29 29.55,79.59 29.55,82.28 30.23,82.96 44.71,82.96 49.49,87.74 65.03,87.74 65.62,88.33 88.51,88.33 91.05,85.79 91.05,83.42 95.22,79.26 97.24,79.26 106.86,69.63 108.64,69.63 112.43,65.85 122.6,65.85 123.4,65.05 123.4,64.3 123.65,64.04 123.65,59.93 123.4,59.67 123.4,58.66 123.63,58.43 123.63,57.69 124.06,57.26 124.77,57.26 126.12,55.92 126.85,55.92 127.72,55.05 127.72,46.03 129.61,44.14 129.61,41.97 129.33,41.69 129.33,39.67 v3(129.9,39.1)
  IN4 w0.084: v3(129.9,39.1) 132.63,39.1 133.89,37.84 140.42,37.84 141.27,38.69 141.27,39.51 142.46,40.7 142.46,41.85 150.95,50.34 154.4,50.34 154.89,49.85 158.24,49.85 161.29,52.9 164.48,52.9 v1(165.41,51.96)
  BOTTOM w0.102: UH4.T49 163.44,42.28 163.87,42.71 163.87,44.8 164.48,45.41 164.74,45.41 RH133.2 165.03,45.72 164.53,46.21 164.53,51.28 165.22,51.96 v1(165.41,51.96) ; L99.1 9.58,68.99 9.37,68.78 9.37,68.17 9.58,67.95 C1202.1 R1641.1 11.59,67.95 v1(11.83,67.71)
REGCTL_PNP10: length 12.4
  TOP w0.508: L29.1 v1(295.83,80.43)
  IN4 w0.508: v1(286.99,77.54) 287.94,77.54 291.7,81.3 295.19,81.3 295.83,80.67 v1(295.83,80.43)
  BOTTOM w0.127: v1(286.99,77.54) v2(287.69,77.54)
REM_DIODE1_N_4022: length 75.4
  TOP w0.254: v1(122.62,56.11) 122.45,55.93 C266.1 122.32,55.27 Q12.3
  IN3 w0.254: v1(134.08,81.81) 134.08,81.84 134.42,82.17 134.42,82.17 134.57,82.32 135.3,82.32 137.62,84.65 137.62,88.23 139.05,89.65 139.05,93.58 140.5,95.03 144.85,95.03 149.81,99.98 153.1,99.98 153.68,99.4 156.08,99.4 156.36,99.68 157.21,99.68 157.55,99.33 v3(157.55,98.98)
  IN4 w0.084: v1(122.62,56.11) 122.76,56.25 122.76,56.7 123.12,57.06 125.55,57.06 126.62,58.13 126.62,58.29 127.1,58.77 127.1,59.73 126.8,60.02 126.8,61.28 127.95,62.42 128.02,62.49 128.29,62.49 128.39,62.59
  IN4 w0.254: 128.39,62.59 128.68,62.88 128.68,63.78 130.21,65.31 130.21,71.08 128.91,72.38 128.91,77.23 131.42,79.75 133.61,79.75 134.08,80.21 v1(134.08,81.81)
  BOTTOM w0.254: U9.23 158.19,99.62 v3(157.55,98.98) 157.69,98.85 C270.2
REM_DIODE1_P_4022: length 75.8
  TOP w0.254: Q12.1 122.97,52.97 123.62,53.62 Q12.2 123.62,55.14 C266.2 123.36,56 v1(123.26,56.11)
  IN3 w0.254: v1(156.92,98.98) 156.83,98.89 153.47,98.89 152.89,99.48 150.02,99.48 145.06,94.52 140.71,94.52 139.55,93.37 139.55,89.44 138.13,88.02 138.13,84.44 135.51,81.82 134.78,81.82 v3(134.78,81.81)
  IN4 w0.084: v1(123.26,56.11) 123.1,56.26 123.1,56.56 123.26,56.72 125.69,56.72 126.96,57.99 126.96,58.15 127.44,58.63 127.44,59.87 127.14,60.16 127.14,61.14 128.14,62.14 128.66,62.14
  IN4 w0.254: v3(134.78,81.81) 134.78,80.17 133.84,79.24 131.63,79.24 129.42,77.02 129.42,72.59 130.72,71.29 130.72,65.1 129.19,63.57 129.19,62.67 128.66,62.14
  BOTTOM w0.254: C270.1 156.77,98.84 v1(156.92,98.98) 156.92,99.25 157.69,100.02 U9.24
REM_DIODE2_N_4022: length 201.2
  TOP w0.254: v1(65.46,39.81) 64.23,39.81 63.91,39.49 63.91,38.5 64.15,38.26 C272.2 64.97,38.26 65.73,37.5 Q14.3
  IN3 w0.254: v1(130.19,83.03) 130.32,83.16 130.32,83.56 130.76,84 133.38,84 136.45,87.08 136.45,92.72 140.13,96.4 144.52,96.4 149.79,101.66 155.23,101.66 155.69,101.19 155.69,100.22 v1(155.45,99.98)
  IN4 w0.254: v1(65.46,39.81) 65.45,39.82 51.31,39.82 50.9,39.42 50.12,39.42 v1(49.97,39.27) ; v1(50.04,78.25) 55.07,78.25 55.66,77.66 61.95,77.66 63.3,79 66.22,79 68.1,80.89 68.1,85.21 69.95,87.06 70.98,87.06 71.87,86.17 73.28,86.17 73.82,86.71 75.69,86.71 76.31,86.09 87.81,86.09 88.97,87.26 104.75,87.26 109.37,82.64 130.09,82.64 130.22,82.77 130.22,83 v1(130.19,83.03)
  BOTTOM w0.254: Q13.1 124.77,82.19 125.42,82.84 Q13.2 127.04,82.84 v2(127.23,82.65) C277.2 129.02,82.65 129.14,82.76 129.92,82.76 v1(130.19,83.03) ; U9.26 156.43,101.74 156.37,101.8 156.14,101.8 155.87,101.54 155.87,100.62 155.52,100.27 155.52,100.05 v1(155.45,99.98) 155,99.53 C271.2 ; v1(50.04,78.25) 49.81,78.25 49.24,77.68 49.24,73.45 48.21,72.42 48.21,49.7 47.69,49.18 47.69,41.04 49.47,39.27 v1(49.97,39.27)
REM_DIODE2_P_4022: length 200
  TOP w0.254: Q14.1 67.28,37.89 66.63,38.54 Q14.2 65.46,38.54 65.23,38.77 65,38.77 C272.1 64.72,39.3 66.58,39.3 v1(66.71,39.43)
  IN3 w0.254: v1(155,100.44) 155.32,100.76 155.32,101.04 155.07,101.28 149.94,101.28 144.68,96.02 140.29,96.02 136.83,92.56 136.83,86.92 133.53,83.63 130.92,83.63 130.69,83.4 130.69,83.16 v1(130.82,83.03)
  IN4 w0.254: v1(66.71,39.43) 65.8,40.33 51.1,40.33 50.69,39.93 50.02,39.93 v1(49.93,40.01) ; v1(50.04,77.62) 50.17,77.75 54.86,77.75 55.45,77.15 62.16,77.15 63.51,78.5 66.43,78.5 68.61,80.68 68.61,85 70.16,86.55 70.77,86.55 71.66,85.66 73.49,85.66 74.03,86.2 75.48,86.2 76.1,85.58 88.02,85.58 89.18,86.75 104.54,86.75 109.16,82.13 130.3,82.13 130.73,82.56 130.73,82.94 v1(130.82,83.03)
  BOTTOM w0.254: C271.1 154.57,99.93 155,100.35 v1(155,100.44) 155.19,100.44 155.52,100.77 155.52,101.69 155.99,102.16 156.37,102.16 156.45,102.24 U9.27 ; Q13.3 127.09,81.54 127.28,81.73 C277.1 128.8,81.73 129.38,82.32 v2(129.88,82.32) 130.23,82.32 130.82,82.91 v1(130.82,83.03) ; v1(49.93,40.01) 49.44,40.01 48.2,41.25 48.2,48.97 48.72,49.49 48.72,72.21 49.75,73.24 49.75,77.47 49.9,77.62 v1(50.04,77.62)
RES_BIAS: length 1.8
  TOP w0.102: U31.12 289.11,77.96 289.78,77.29 R562.1
RESET_OUT#: length 159.6
  TOP w0.102: v1(174.29,25.96) 175.41,25.96 RH321.1 ; v1(281.92,65.67) 282.23,65.98 Q50.2 282.23,67.01 282.1,67.14 281.41,67.14 R843.2 280.61,66.82 v4(280.09,67.35) ; U51.B39 283.76,60.35 v1(284.16,59.95)
  IN2 w0.102: 169.05,28.11 166.52,28.11 v1(166.09,28.55)
  IN2 w0.122: v1(282.39,45.92) 281.29,44.82 278.11,44.82 274.05,40.77 271.84,40.77 270.1,39.03 254.74,39.03 253.76,40.01 247.11,40.01 245.66,38.56 237.93,38.56 228.55,29.18 194.43,29.18 193.08,30.53 187.38,30.53 186.77,29.92 183.52,29.92 183.32,30.12 177.47,30.12 176.92,29.56 175.01,29.56 v1(173.91,28.46) 173.81,28.36 169.3,28.36 169.05,28.11
  IN3 w0.102: v1(173.91,28.46) 173.91,26.34 v1(174.29,25.96)
  IN3 w0.122: v1(281.92,65.67) 283.42,64.17 283.42,60.69 v1(284.16,59.95) 282.81,58.6 282.81,55.89 282.17,55.25 281.64,55.25 281.35,54.96 281.35,54.51 281.8,54.06 281.8,51.77 281.93,51.63 281.93,50.61 282.68,49.86 282.68,47.72 283.12,47.29 283.12,46.02 283.02,45.92 v1(282.39,45.92)
  BOTTOM w0.102: v1(166.09,28.55) 165.77,28.86 UH4.L22
REXT: length 4.2
  TOP w0.102: v1(236.63,75.83) 236.88,76.08 U44.20
  BOTTOM w0.102: v2(237.48,73.1) 236.62,73.96 R1595.2 236.63,74.1 R752.2 236.63,75.82 v1(236.63,75.83)
RF_+V1.05S_VCCPP: length 1.8
  TOP w0.254: PU500.5 126.57,12.14 127.22,12.79 PR505.1
RF_+V1.05SP: length 3.6
  BOTTOM w0.102: v2(160.57,67.56) 160.24,67.89 PR405.1
  BOTTOM w0.254: PU400.5 157.94,67.13 158.15,67.33 159.05,67.33 PR405.1
RSMRST#: length 4.4
  BOTTOM w0.102: U4.3 188.75,27.5 ; 188.75,27.5 R1622.1 188.08,27.5 187.94,27.36 U7.2 ; 188.75,27.5 189.09,27.16 v2(189.77,27.16)
RSMRST#_XDP: length 8.3
  TOP w0.102: v2(115.89,21.77) 116.26,22.13 117.66,22.13 117.96,21.83 RH284.1 RH24.2 119.32,21.06 v1(119.32,20.86) ; v1(121.67,19.23) 121.92,19.49 JXDP2.17
  IN1 w0.084: v1(119.32,20.86) 120.05,20.86 v1(121.67,19.23)
RUN_ON: length 326.5
  TOP w0.102: R786.2 265.66,68.28 v1(265.66,68.42) 265.83,68.59 265.83,69.19 265.34,69.68 U46.A11
  TOP w0.254: PR303.1 97.39,2.05 92.67,2.05 v1(92.15,2.58) ; v1(159.91,76.31) 160.19,76.31 162.01,74.5 167.73,74.5 v4(168.8,73.43) 169.7,72.53 v1(169.77,72.53)
  IN1 w0.084: v1(169.77,72.53) 169.77,72.53 169.07,71.83 169.07,61.49 168.78,61.2 168.78,58.12 169.53,57.36 169.53,54.21 170.15,53.59 170.15,51.51 172.95,48.71 181.12,48.71 183.98,45.86 v1(187.78,45.86) 188.13,45.86 190.26,43.73 192.57,43.73 195,41.31 195,39.54 198.76,35.78 218.13,35.78 239.79,57.44 239.79,59.06 242.34,61.61 242.34,63.15 241.68,63.81 241.27,63.81 240.62,64.47 240.62,68.1 242.01,69.48 242.73,69.48 243.34,70.09 254.1,70.09 254.72,69.47 257.63,69.47 258.51,70.34 263.28,70.34 263.79,69.83 263.79,68.93 264.04,68.68 264.04,68.32 264.34,68.02 265.27,68.02 265.66,68.42 v1(265.66,68.42) ; v1(181.25,8.47) 180.76,8.95 176.68,8.95 174.91,7.19 173.13,7.19 170.53,4.59 154.71,4.59 153.79,5.51 150.84,5.51 150.32,6.03 150.32,8.98 148.59,10.72 147.16,10.72 145.78,12.1 140.42,12.1 138.97,13.55 138.75,13.55 137.25,15.05 100.56,15.05 94.89,9.38 94.89,5.31 92.15,2.58 v1(92.15,2.58)
  IN3 w0.122: v1(181.25,8.47) 182.72,8.47 183.44,9.18 187.56,9.18 188.63,10.25 188.63,13.53 189.85,14.76 189.85,20.39 188.63,21.61 188.63,22.31 188.93,22.62 188.93,34.43 188.45,34.91 188.45,41.7 188.93,42.19 188.93,44.7 v1(187.78,45.86)
  BOTTOM w0.102: v1(181.25,8.47) 180.82,8.04 R744.1
  BOTTOM w0.254: v1(159.91,76.31) 160.51,76.31 PR409.1
RUN_ON_CPU1.5VS3: length 83.3
  TOP w0.102: v1(102.1,11.68) 102.1,12.38 v2(101.35,13.13)
  TOP w0.254: RC72.2 104.45,12.61 RC143.1 104.45,11.7 CC136.1 103.99,10.28 102.93,10.28 102.56,9.91 102.56,9.51 102.34,9.3 QC4.3 101.95,11.53 v1(102.1,11.68)
  TOP w0.508: v1(101.85,72.95) 103.08,72.95 103.55,73.42 103.55,77.72 103.74,77.91 QC5.2
  BOTTOM w0.508: QC3.4 101.75,11.33 v1(102.1,11.68) 102.22,11.8 102.22,20.99 101.71,21.5 101.71,42.99 99.7,44.99 99.7,50.77 101.85,52.92 v1(101.85,72.95)
RUN_ON_CPU1.5VS3#: length 198.6
  TOP w0.102: QC1.2 104.95,81.7 104.42,81.18 104.42,77.9 103.99,77.47 103.99,71.76 104.17,71.59 ; 104.17,71.59 105.21,71.59 105.22,71.58 110.63,71.58 112.6,73.56 v1(112.6,74.45) ; 104.17,71.59 102.99,70.41 93.38,70.41 92.7,69.73 v2(92.7,68.18) 92.7,63.46 90.12,60.88 90.12,20.51 93.62,17.02 99.69,17.02 100.87,15.83 Q71.2 100.06,11.81 99.37,11.12 RC74.2 98.89,10 98.89,8.82 99.15,8.56 99.52,8.56 99.61,8.65 QC4.5 100.42,8.65 100.61,8.46 100.61,8.15 100.46,8 QC4.6
  IN2 w0.122: v1(112.6,74.45) 112.6,76.06 109.53,79.13 107.8,79.13 105.87,81.06 69.44,81.06 67.81,82.69 53.71,82.69 53.54,82.86 51.38,82.86 51.12,82.61 33.94,82.61 v1(33.44,82.12)
  BOTTOM w0.102: v1(33.44,82.12) 33.44,83.54 30.49,86.49 Q72.2
RUN_ON_ENABLE#: length 303.6
  TOP w0.102: v1(136.75,24.75) 136.85,24.85 136.85,30.57 138.38,32.1 138.38,39.84 v2(139.36,40.82) 141.13,42.58 Q64.2 ; Q45.2 298.25,65.86 298.49,66.1 v1(298.49,66.94)
  TOP w0.254: v1(185.91,17.18) 185.91,14.87 184.63,13.59 182.81,13.59 v1(176.61,7.39)
  IN1 w0.254: v1(176.61,7.39) 173.52,4.29 154.59,4.29 153.72,5.16 150.63,5.16 149.99,5.8 149.99,8.89 148.46,10.42 146.95,10.42 145.57,11.8 140.27,11.8 138.84,13.23 138.09,13.23 v1(136.85,14.47)
  IN2 w0.122: v1(185.91,17.18) 187.43,18.7 189.28,18.7 190.64,20.06 196.26,20.06 v1(197.22,19.1)
  IN3 w0.254: v1(187.04,46.53) 187.04,42.67 188.07,41.64 188.07,34.85 188.62,34.3 188.62,28.84 v1(186.15,26.37) 186.15,26.22 186.68,25.69 186.68,23.41 186.11,22.83 186.11,17.38 v1(185.91,17.18)
  IN4 w0.084: v1(298.49,66.94) 296.44,69 283.7,69 283.01,68.31 283.01,67.5 281.98,66.47 278.15,66.47 275.39,63.71 269.59,63.71 267.3,61.43 265.78,61.43 265.03,62.18 258.34,62.18 256.65,60.49 253.01,60.49 252.19,59.66 241.31,59.66 238.82,57.17 232.67,57.17 v1(231.82,56.32) 229.61,54.11 229.61,51.32 v1(223.56,45.27) 223.56,44.51 216.55,37.49 199.16,37.49 191.13,45.51 189.68,45.51 188.66,46.53 v1(187.04,46.53)
  BOTTOM w0.102: v1(231.82,56.32) 231.41,55.91 Q56.2 ; v1(223.56,45.27) 223.56,47.98 223.92,48.33 Q69.2 ; Q52.5 176.71,3.13 176.56,3.29 176.56,3.6 176.74,3.78 Q52.6 177.45,3.78 177.88,4.21 R909.2 177.88,6.12 v1(176.61,7.39)
  BOTTOM w0.254: Q70.2 138.08,26.13 138.37,25.84 138.37,25.09 138.03,24.75 v1(136.75,24.75) 136.75,24.36 136.33,23.93 136.33,20.83 136.97,20.18 137.5,20.18 138.47,19.21 138.47,15.15 137.8,14.47 v1(136.85,14.47) ; Q67.2 185.31,25.84 185.85,26.37 v1(186.15,26.37) ; Q68.2 200.48,9.86 197.22,13.12 v1(197.22,19.1) ; v1(185.91,17.18) 186.3,17.57 Q62.2
RUNPWROK: length 306.5
  TOP w0.102: v1(98.28,97.67) 98.58,97.37 99.54,97.37 v2(100.86,96.05) 102.11,94.79 102.11,92.45 103.93,90.64 106.47,90.64 106.86,90.24 106.86,86.42 105.52,85.07 v1(105.52,84.73) ; v1(287.44,61.61) 287.44,61.61 287.77,61.61 287.87,61.71 287.87,62.51 288.01,62.65 U51.B26 ; Q45.1 295.13,66.51 R799.2 294.51,70.38 v1(294.38,70.51) ; U46.A4 261.84,69.56 261.66,69.38 261.66,68.97 v1(262.09,68.54)
  IN1 w0.084: v1(287.44,61.61) 288.94,63.11 288.94,67.98 291.08,70.11 291.08,70.76 291.37,71.05 293.83,71.05 v1(294.38,70.51)
  IN2 w0.122: v1(262.09,68.54) 262.54,68.98 262.54,69.73 262.72,69.9 276.04,69.9 277.57,71.43 293.46,71.43 v1(294.38,70.51)
  IN4 w0.084: v1(262.09,68.54) 261.6,68.04 258.08,68.04 256.85,69.28 256.75,69.37 256.32,69.37 255.63,70.05 247.9,70.05 247.24,70.72 238.87,70.72 236.77,68.61 236.77,64.63 235.42,63.29 235.42,60.53 231.4,56.5 231.4,56.2 229.36,54.16 229.36,51.84 223.12,45.6 223.12,44.36 216.46,37.7 199.25,37.7 191.22,45.72 189.77,45.72 188.75,46.74 188.39,46.74 177.05,58.08 172.16,58.08 169.74,60.5 169.74,63.24 170.38,63.88 170.38,72.55 169.77,73.16 169.77,76.07 170.25,76.56 170.25,80.02 164.6,85.68 164.6,89.32 163.9,90.01 160.37,90.01 153.37,97.01 150.22,97.01 147.49,99.74 137.68,99.74 136.83,100.59 136.11,100.59 133.36,103.34 116.15,103.34 113.73,100.92 104.93,100.92 102.44,98.43 99.04,98.43 v1(98.28,97.67)
  BOTTOM w0.102: UC2.1 105.72,84.3 105.52,84.5 v1(105.52,84.73)
RUNPWROK_AND: length 57.7
  TOP w0.102: RC64.2 RC28.1 107.69,81.98 108.05,81.61 109.1,81.61 v1(109.1,81.62)
  BOTTOM w0.102: v1(109.1,81.62) v4(108.53,81.05) 107.32,79.84 RC12.2 106.29,80.32 106.16,80.45 95.7,80.45 95.57,80.58 95.57,83.02 95.7,83.14 95.99,83.14 96.12,83.02 96.12,81.02 96.22,80.92 96.53,80.92 96.63,81.02 96.63,83 96.76,83.13 97.01,83.13 97.14,83 97.14,81.02 97.24,80.92 97.54,80.92 97.65,81.02 97.65,82.26 97.77,82.38 98.03,82.38 98.15,82.26 98.15,81.02 98.26,80.92 98.56,80.92 98.66,81.02 98.66,82.27 98.76,82.37 99.07,82.37 99.17,82.27 99.17,81.02 99.27,80.92 99.58,80.92 99.68,81.02 99.68,82.27 99.78,82.37 100.08,82.37 100.19,82.27 100.19,81.02 100.29,80.92 100.59,80.92 100.69,81.02 100.69,82.27 100.8,82.37 101.1,82.37 101.2,82.27 101.2,81.02 101.3,80.92 101.61,80.92 101.71,81.02 101.71,82.27 101.81,82.37 102.12,82.37 102.22,82.27 102.22,81.02 102.32,80.92 102.62,80.92 102.73,81.02 102.73,82.27 102.83,82.37 103.13,82.37 103.23,82.27 103.23,81.02 103.34,80.92 103.64,80.92 103.74,81.02 103.74,82.27 103.84,82.37 104.16,82.37 104.29,82.24 104.29,81.07 104.41,80.95 106.89,80.95 107.02,81.07 UC2.4
S5_1.5V: length 7
  TOP w0.102: v2(44.61,66.58) 42.4,66.58 41.99,66.18 PC255.1
  TOP w0.203: PU200.8 41.09,64.75 41.56,64.28 PR206.2 PR232.2 PC255.1
SATA3_COMP: length 10.3
  IN4 w0.084: v1(159.72,23.7) 159.3,23.27 159.3,19.91 158.02,18.63 158.02,17.26 v3(158.58,16.7)
  BOTTOM w0.102: v3(158.58,16.7) 158.58,15.95 RH42.1 ; UH4.AB13 UH4.AB12 160.08,24.06 v1(159.72,23.7)
SATA_ACT#: length 101.5
  TOP w0.102: v1(162.69,17) 162.69,16.06 v2(162.73,16.02)
  IN1 w0.084: v1(163.89,10.26) 163.89,14.55 162.69,15.74 v1(162.69,17)
  IN3 w0.122: v1(169.95,65.9) 170.39,65.46 170.39,61.16 170.64,60.91 170.64,60.02 172.19,58.47 172.19,53.28 174.41,51.06 183.5,51.06 184.86,49.7 184.86,38.7 186.82,36.73 186.82,33.48 187.56,32.75 187.56,30.36 185.85,28.65 185.85,27.76 184.96,26.87 184.96,25.88 185.52,25.32 185.52,23.74 184.52,22.75 184.52,21.51 184.3,21.29 184.3,17.77 184.12,17.58 184.12,13.87 179.46,9.21 174.89,9.21 174.63,8.95 165.2,8.95 v1(163.89,10.26)
  BOTTOM w0.102: UH4.P3 164.16,19.12 163.75,18.71 163.75,17.96 162.8,17 v1(162.69,17) ; Q74.4 169.91,65.86 v1(169.95,65.9)
SATA_COMP: length 12.5
  IN4 w0.084: v1(161.66,23.81) 161.31,24.17 160.55,24.17 160.15,23.77 160.15,19.58 159.45,18.88 158.98,18.88 158.58,18.48 158.58,17.4 v3(159.25,16.72)
  BOTTOM w0.102: UH4.Y10 UH4.Y11 161.26,23.4 v1(161.66,23.81) ; RH40.1 159.67,16.3 v3(159.25,16.72)
SATA_LED: length 4.7
  TOP w0.127: R1731.2 165.38,58.38 165.92,57.85 v2(165.92,57.83)
  TOP w0.254: JLED1.3 164.75,61.25 165.04,60.96 165.04,59.47 165.38,59.13 R1731.2
SATA_PRX_DTX_N4: length 9.4
  BOTTOM w0.102: JESA1.9 257.78,100.36 257.78,99.97 258.16,99.59 258.16,98.67 258.75,98.08 261.11,98.08 261.47,97.72 261.47,96.6 260.58,95.71 260.58,95.37 C1238.2
SATA_PRX_DTX_N4_B: length 17.1
  TOP w0.102: v3(240.25,69.32) 240.43,69.51 240.43,69.99 R1722.1 ; R1723.2 240.44,81.98 240.44,82.41 v1(240.27,82.59)
  IN3 w0.122: v3(240.25,69.32) 240.45,69.53 240.45,69.68 242.14,71.37 242.14,79.47 240.49,81.12 240.49,82.36 v1(240.27,82.59)
SATA_PRX_DTX_P4: length 9.4
  BOTTOM w0.102: JESA1.10 258.04,100.37 258.04,100.08 258.43,99.7 258.43,98.78 258.86,98.34 261.22,98.34 261.74,97.83 261.74,96.49 260.85,95.6 260.85,95.39 C1239.2
SATA_PRX_DTX_P4_B: length 17.1
  TOP w0.102: R1725.2 240.7,81.98 240.7,82.39 v1(240.9,82.59) ; v3(240.88,69.32) 240.7,69.51 240.7,69.99 R1724.1
  IN3 w0.122: v1(240.9,82.59) 240.73,82.42 240.73,81.23 242.39,79.57 242.39,71.27 240.7,69.58 240.7,69.51 v3(240.88,69.32)
SATA_PTX_DRX_N4: length 11
  BOTTOM w0.102: C1237.2 252.61,95.44 252.61,95.62 252.33,95.89 251.17,95.89 250.35,96.72 250.35,97.74 250.82,98.21 251.81,98.21 251.94,98.08 253.32,98.08 253.89,98.65 253.89,99.64 254.26,100.01 254.26,100.4 JESA1.7
SATA_PTX_DRX_N4_B: length 17.9
  TOP w0.102: R1721.2 238.83,82.01 238.83,82.46 v1(239.01,82.65) ; R1720.1 238.89,69.99 238.89,69.53 v3(239.09,69.33)
  IN3 w0.122: v3(239.09,69.33) 238.9,69.52 238.9,70.26 239.76,71.12 239.76,74.09 237.5,76.36 237.5,78.7 237.25,78.94 237.25,80.21 238.82,81.78 238.82,82.45 v1(239.01,82.65)
SATA_PTX_DRX_P4: length 11
  BOTTOM w0.102: C1236.2 252.34,95.38 252.34,95.51 252.22,95.63 251.06,95.63 250.08,96.6 250.08,97.85 250.7,98.47 251.92,98.47 252.05,98.35 253.21,98.35 253.62,98.76 253.62,99.75 253.99,100.12 253.99,100.34 JESA1.6
SATA_PTX_DRX_P4_B: length 17.9
  TOP w0.102: R1719.2 238.56,82.01 238.56,82.46 v1(238.38,82.65) ; v3(238.45,69.33) 238.62,69.5 238.62,69.99 R1718.1
  IN3 w0.122: v1(238.38,82.65) 238.58,82.45 238.58,81.88 237.01,80.31 237.01,78.84 237.25,78.6 237.25,76.25 239.51,73.99 239.51,71.22 238.65,70.36 238.65,69.53 v3(238.45,69.33)
SB#: length 13.4
  BOTTOM w0.102: v2(303.79,55.84) 304.3,56.35 Q53.2 303.39,56.98 302.56,57.81 302.56,63.79 303.27,64.5 R1626.1 303.97,64.02 303.83,63.88 303.83,62.96 304.01,62.79 U2.8
SCLK: length 4.8
  TOP w0.102: PR730.1 142.73,88.66 v2(142.26,89.13)
  TOP w0.254: PR730.1 143.86,88.66 v1(144.06,88.45)
  BOTTOM w0.203: PU700.5 144.19,87.59 144.06,87.71 v1(144.06,88.45)
  BOTTOM w0.254: v1(144.06,88.45) 144.06,89.28 PR716.2
SD/MMCCD#: length 18.1
  TOP w0.102: v3(280.85,9.94) 280.61,10.18 U38.12
  IN4 w0.084: v3(280.85,9.94) 280.85,8.6 281.25,8.2 286.96,8.2 287.62,7.54 291.76,7.54 293.15,6.15 v1(293.81,6.15)
  BOTTOM w0.102: JSD1.2 v1(293.81,6.15)
SD/MMCCLK: length 9.9
  TOP w0.102: 287.99,11.86 287.99,11.86 R676.2 ; 287.99,11.86 v2(287.98,11.86) ; 287.99,11.86 288.29,11.86 RE678.1 v1(289.18,13.43)
  IN4 w0.084: v1(293.63,14.07) 289.82,14.07 v1(289.18,13.43)
  BOTTOM w0.102: JSD1.8 v1(293.63,14.07)
SD/MMCCLK_R: length 2.9
  TOP w0.102: U38.18 285.2,12.6 R676.1
SD/MMCCMD: length 16
  TOP w0.102: v1(287.93,12.75) 286.85,12.75 R674.2
  IN4 w0.084: v1(287.93,12.75) 287.32,13.36 287.32,17.5 290.38,20.56 292.68,20.56 v3(293.82,21.7)
  BOTTOM w0.102: v3(293.82,21.7) 293.94,21.58 JSD1.12
SD/MMCCMD_R: length 2.7
  TOP w0.102: U38.19 v2(284.79,13.1) 285.58,13.1 R674.1
SD/MMCDAT0: length 23.2
  TOP w0.102: v1(280.41,20.59) 280.17,20.35 R665.2
  IN4 w0.084: v3(293.65,9.15) 290.8,9.15 286.18,13.77 286.18,16.85 282.03,20.99 280.81,20.99 v1(280.41,20.59)
  BOTTOM w0.102: JSD1.4 v3(293.65,9.15)
SD/MMCDAT0_R: length 2.3
  TOP w0.102: U38.29 280.61,17.26 v2(280.38,17.49) 280.38,18.24 R665.1
SD/MMCDAT1: length 22.8
  TOP w0.102: v3(281.07,20.56) 281.06,20.55 R663.2
  IN4 w0.084: v1(293.81,7.45) 292.59,8.67 290.73,8.67 285.79,13.61 285.79,16.69 281.91,20.56 v3(281.07,20.56)
  BOTTOM w0.102: JSD1.3 v1(293.81,7.45)
SD/MMCDAT1_R: length 2.6
  TOP w0.102: U38.28 281.11,16.8 281.68,17.37 v2(281.68,17.51) 281.68,17.6 281.06,18.22 R663.1
SD/MMCDAT2: length 18.3
  TOP w0.102: v3(282.14,21.43) R664.2
  IN4 w0.084: v3(282.14,21.43) 283.12,22.41 289.84,22.41 291.09,23.66 292.68,23.66 v1(293.79,24.77)
  BOTTOM w0.102: JSD1.15 294.22,26.58 293.79,26.16 v1(293.79,24.77)
SD/MMCDAT2_R: length 3.6
  TOP w0.102: U38.26 282.11,17.61 282.14,17.64 R664.1 282.79,18.45 v2(283.36,17.89)
SD/MMCDAT3: length 12.3
  TOP w0.102: v3(287.62,19.39) 286.85,18.62 R668.2
  IN4 w0.084: v1(293.79,24.08) 292.71,23 291.23,23 v3(287.62,19.39)
  BOTTOM w0.102: JSD1.14 v1(293.79,24.08)
SD/MMCDAT3_R: length 3.3
  TOP w0.102: U38.24 284.07,15.6 v2(284.77,16.3) 285.67,17.19 R668.1
SD/MMCDAT4: length 12.3
  TOP w0.102: R669.2 287.62,17.08 v2(287.62,18.07) v1(287.62,18.76)
  IN4 w0.084: v1(293.79,22.34) 292.56,21.1 289.97,21.1 v1(287.62,18.76)
  BOTTOM w0.102: v1(293.79,22.34) 294.29,22.83 JSD1.13
SD/MMCDAT4_R: length 3.1
  TOP w0.102: U38.23 284.73,15.1 R669.1
SD/MMCDAT5: length 10.6
  TOP w0.102: R670.2 v1(287.94,15.42)
  IN4 w0.084: v3(293.68,19.83) 293.68,19.82 289.28,15.42 v1(287.94,15.42)
  BOTTOM w0.102: v3(293.68,19.83) 294.18,20.33 JSD1.11
SD/MMCDAT5_R: length 2.9
  TOP w0.102: U38.22 v2(284.69,14.6) 285.12,14.6 R670.1
SD/MMCDAT6: length 9.6
  TOP w0.102: R672.2 v1(287.93,14.53)
  IN4 w0.084: v3(293.63,12.82) 289.09,12.82 288.4,13.51 288.4,14.06 v1(287.93,14.53)
  BOTTOM w0.102: JSD1.7 v3(293.63,12.82)
SD/MMCDAT6_R: length 2.8
  TOP w0.102: R672.1 285.5,14.1 U38.21
SD/MMCDAT7: length 10.1
  TOP w0.102: v3(287.94,13.64) 286.85,13.64 R673.2
  IN4 w0.084: v1(293.63,10.32) 291,10.32 287.94,13.38 v3(287.94,13.64)
  BOTTOM w0.102: JSD1.5 v1(293.63,10.32)
SD/MMCDAT7_R: length 2.6
  TOP w0.102: R673.1 285.89,13.6 U38.20
SDA: length 3.8
  TOP w0.102: v1(145.22,88.05) 145.52,87.74 v2(146.13,87.74)
  TOP w0.254: v1(145.22,88.05) 145.22,88.2 PR737.1
  BOTTOM w0.203: v1(145.22,88.05) 145.22,87.87 144.99,87.64 PU700.7
  BOTTOM w0.254: PR737.1 145.22,88.2 v1(145.22,88.05)
SDWP: length 32.1
  TOP w0.102: U38.30 280.11,16.9 279.94,17.07 279.94,17.68 279.28,18.34 v3(279.28,21.36)
  IN4 w0.084: v1(293.83,4.85) 294.29,5.31 294.29,6.47 293.95,6.82 293.45,6.82 291.99,8.28 290.57,8.28 285.37,13.48 285.37,16.55 282.13,19.8 279.66,19.8 279.28,20.18 v3(279.28,21.36)
  BOTTOM w0.102: JSD1.1 v1(293.83,4.85)
SEL: length 4.9
  BOTTOM w0.102: Q53.1 306.69,57.63 306.9,57.85 v2(306.9,58.38) R1614.1 R1613.2 307.17,60.59 307.17,61.1 306.98,61.29 U2.4
SIO_14M: length 8.4
  TOP w0.102: v4(168.37,42.63) 168.63,42.37 v1(168.63,41.53)
  IN3 w0.102: v1(171.24,42.79) 170.82,43.21 170.24,43.21 168.63,41.59 v1(168.63,41.53)
  BOTTOM w0.102: UH4.F47 168.48,41.39 v1(168.63,41.53) ; RH313.2 171.7,44.7 171.24,44.25 v1(171.24,42.79)
SIO_A20GATE: length 186.8
  TOP w0.102: v1(281.82,55.84) 282.08,56.1 U51.A45 ; v1(163.67,20.34) 164.11,19.89 164.11,19.43 164.92,18.63 166.02,18.63 167.38,17.27 169.6,17.27 170.4,16.47 173.64,16.47 v2(175.4,14.71) 175.56,14.55 178.87,14.55 182.91,18.59 182.91,20.62 RH158.2
  IN2 w0.102: v1(163.67,20.34) 165.04,18.97 166.77,18.97 167.94,17.8 169.52,17.8 169.73,17.59
  IN2 w0.122: v1(281.83,29.58) 281.68,29.44 275.11,29.44 273.86,30.69 268.71,30.69 266.59,28.57 252.83,28.57 251.94,27.68 246.97,27.68 240.7,21.42 235.71,21.42 234.7,20.41 221.12,20.41 218.82,18.11 203.2,18.11 201.81,16.73 198.05,16.73 196.5,15.17 186.66,15.17 185.23,13.75 176.55,13.75 175.85,14.45 175.52,14.45 174.56,15.4 171.91,15.4 169.73,17.59
  IN3 w0.122: v1(281.83,29.58) 282.27,30.03 282.27,30.83 282.08,31.02 282.08,40.69 281.75,41.03 281.12,41.03 280.49,41.66 280.49,42.29 280.07,42.71 280.07,44.77 279.24,45.6 279.24,47.45 280.03,48.23 280.03,55.76 280.27,56.01 281.66,56.01 v1(281.82,55.84)
  BOTTOM w0.102: UH4.P4 164.05,20.34 v1(163.67,20.34)
SIO_EXT_SCI#: length 196.8
  TOP w0.102: RH263.1 184.13,20.94 183.63,20.94 183.15,20.46 183.15,18.45 179.03,14.32 174.87,14.32 173.1,16.09 v2(172.54,16.09) 169.98,16.09 169.28,16.79 167.2,16.79 166.48,17.51 165.24,17.51 163.26,19.49 163.26,21.31 v1(163.72,21.77) ; U51.A33 282.15,62.1 v1(281.86,62.39)
  IN2 w0.102: 170.09,17.59 169.67,18 168.02,18 166.85,19.17 165.12,19.17 164.07,20.22 164.07,21.41 v1(163.72,21.77)
  IN2 w0.122: v1(281.83,30.22) 281.3,29.69 275.23,29.69 273.98,30.94 268.61,30.94 266.78,29.11 263.99,29.11 263.42,29.68 257.83,29.68 257.31,29.15 253.01,29.15 251.79,27.93 246.78,27.93 240.51,21.67 235.61,21.67 234.6,20.66 221.02,20.66 218.72,18.36 202.74,18.36 202.11,17.74 198.42,17.74 198.1,17.41 196.53,17.41 195.37,18.57 191.26,18.57 189.89,17.2 188.32,17.2 185.85,14.73 175.59,14.73 174.67,15.65 172.02,15.65 170.09,17.59
  IN3 w0.122: v1(281.83,30.22) 281.84,30.22 281.84,39.61 279.99,41.46 279.99,42.09 279.57,42.5 279.57,44.57 278.74,45.4 278.74,47.65 279.53,48.44 279.53,55.97 280.28,56.72 280.28,60.8 v1(281.86,62.39)
  BOTTOM w0.102: UH4.T7 163.44,21.5 v1(163.72,21.77)
SIO_EXT_SMI#: length 155.8
  TOP w0.102: U51.A6 v1(294.21,57.1)
  IN2 w0.102: v1(172.8,24.88) 173.07,24.88 173.59,24.35 174.55,24.35
  IN2 w0.122: 174.55,24.35 177.81,24.35 177.83,24.33 179.59,24.33 179.9,24.64 183.02,24.64 185.56,27.18 187.04,27.18 188.26,28.4 190.27,28.4 191.05,27.62 192.99,27.62 194.36,26.25 199.62,26.25 200.43,27.06 229.43,27.06 238.79,36.42 254.08,36.42 254.57,36.9 260.92,36.9 262.94,34.89 269.35,34.89 270.83,36.37 276.99,36.37 278.59,37.97 286.27,37.97 292.53,44.23 v1(295.14,44.23)
  IN3 w0.122: v1(294.21,57.1) 294.5,57.1 295.33,56.27 295.33,55.19 296.29,54.22 296.29,49.22 295.6,48.52 295.6,44.68 v1(295.14,44.23)
  BOTTOM w0.102: UH4.C14 170.03,25.02 170.52,25.51 171.45,25.51 172.08,24.88 v1(172.8,24.88) 173.63,24.05 v2(174,24.05) 174.9,24.05 RH348.1
SIO_EXT_WAKE#: length 140.6
  TOP w0.102: R797.1 253.29,78.29 v1(252.95,78.64) ; RH177.1 174.68,22.04 v2(173.89,22.04) 173.6,22.04 v1(172.8,22.84)
  IN2 w0.102: v1(172.8,22.84) 172.8,22.42 173.17,22.05 174.55,22.05
  IN2 w0.122: 174.55,22.05 175.07,22.05 176.06,21.06 179.54,21.06 180.47,21.99 184.83,21.99 186.23,23.39 202.63,23.39 202.94,23.7 216.52,23.7 217.72,24.9 229.82,24.9 239.84,34.92 250.7,34.92 v1(251.66,33.97)
  IN3 w0.122: v1(252.95,78.64) 252.69,78.38 252.69,72.95 252.32,72.57 252.32,68.44 250.44,66.56 250.44,61.57 250.94,61.06 250.94,53.8 250.17,53.03 250.17,50.56 250.7,50.02 250.7,34.92 v1(251.66,33.97)
  BOTTOM w0.102: UH4.C10 169.82,23.22 170.21,23.22 170.32,23.34 171.1,23.34 171.28,23.16 172.48,23.16 v1(172.8,22.84)
SIO_PWRBTN#: length 415.8
  TOP w0.102: RH41.2 RH21.1 112.43,20.07 113.25,20.07 113.98,20.8 v1(114.32,20.8) ; RC6.1 93.62,88.53 v1(94.13,88.02) v4(94.6,87.55) ; v1(286.93,54.46) 286.93,54.12 287.01,54.04 U51.B58
  IN1 w0.084: v1(44.34,42.3) 44.11,42.53 44.11,49.93 48.02,53.85 48.02,71.94 46.37,73.59 46.37,84.08 47.77,85.48 59.44,85.48 59.9,85.02 67.39,85.02 67.87,84.54 87.39,84.54 90.87,88.02 v1(94.13,88.02) ; v1(55.16,17.15) 56.57,15.75 82.73,15.75 84.46,17.47 89.44,17.47 90.98,19.01 98.24,19.01 99.29,20.06 111.09,20.06 112.45,21.42 113.7,21.42 v1(114.32,20.8) 114.53,20.8 115.25,21.52 125.12,21.52 129.02,17.63 135.28,17.63 135.63,17.28 138.01,17.28 139.55,15.74 139.78,15.74 140.36,15.16 155.42,15.16 161.3,9.29 164.15,9.29 164.94,10.08 164.94,10.88 165.56,11.5 165.56,14.28 165,14.84 165,18.69 164.19,19.5 164.19,24.75 163.65,25.3 163.65,25.84 163.83,26.03 164.24,26.03 165.12,26.91 168.18,26.91 v1(168.73,27.47)
  IN2 w0.122: v1(55.16,17.15) 53.07,17.15 48.14,22.08 48.14,38.5 v1(44.34,42.3) ; v1(168.73,27.47) 169.69,27.47 169.89,27.67 176,27.67 178.17,25.5 181.72,25.5 182.24,26.02 183.34,26.02 185.25,27.93 186.73,27.93 187.95,29.15 192.51,29.15 194.67,26.99 199.31,26.99 200.12,27.8 229.12,27.8 238.48,37.16 253.77,37.16 254.26,37.65 270.68,37.65 270.68,37.65 276.62,37.65 277.47,38.5 285.75,38.5 v1(286.01,38.76)
  IN3 w0.122: v1(286.93,54.46) 286.93,54.22 285.71,53 285.71,50.6 285.15,50.03 285.15,45.01 285.69,44.46 285.69,39.07 v1(286.01,38.76)
  BOTTOM w0.102: v1(168.73,27.47) 168.73,27.5 168.31,27.92 UH4.E20
SIO_RCIN#: length 189.3
  TOP w0.102: v1(164.7,21.16) 165.1,20.75 165.1,20.5 165.41,20.19 165.87,20.19 166.19,19.87 166.19,19.71 167.63,18.26 v2(172.78,18.26) 175.1,18.26 175.96,17.4 177.09,17.4 178.43,18.73 178.43,20.77 179.05,21.4 RH203.2 ; v1(286.59,64.83) 286.76,64.67 U51.A27
  IN2 w0.102: 171.83,17.59 171.18,18.23 168.08,18.23 166.94,19.38 165.2,19.38 164.28,20.31 164.28,20.74 v1(164.7,21.16)
  IN2 w0.122: v1(285.34,32.16) 282.58,32.16 281.6,31.19 268.51,31.19 266.7,29.39 264.06,29.39 263.49,29.96 257.68,29.96 257.12,29.4 252.91,29.4 251.68,28.18 246.67,28.18 240.41,21.92 235.35,21.92 234.34,20.91 220.92,20.91 218.62,18.61 202.63,18.61 202.01,17.98 198.32,17.98 197.99,17.66 196.63,17.66 195.47,18.82 191.16,18.82 189.79,17.45 188.22,17.45 186.49,15.72 178.52,15.72 177.97,15.17 176.52,15.17 175.71,15.99 173.42,15.99 171.83,17.59
  IN3 w0.122: v1(286.59,64.83) 286.59,64.48 285.18,63.07 285.18,61.47 285.76,60.89 285.76,59.53 285.96,59.33 285.96,55.8 286.28,55.48 286.28,53.92 285.46,53.1 285.46,50.7 284.9,50.13 284.9,44.91 285.45,44.36 285.45,41.79 285.33,41.67 285.33,32.17 v1(285.34,32.16)
  BOTTOM w0.102: UH4.P5 164.46,21.16 v1(164.7,21.16)
SIO_SLP_A#: length 231.8
  TOP w0.102: U46.B63 260.06,73.81 v1(260.22,73.96) ; T61.1 167.32,23.68 v1(167.32,23.53)
  TOP w0.254: v1(159.91,75.59) 161.54,73.96 v1(164.71,73.96)
  IN1 w0.084: v1(168.36,12.48) 168.36,17.03 167.24,18.15 167.24,21.73 166.99,21.97 166.99,23.2 v1(167.32,23.53)
  IN3 w0.122: v1(164.01,79.74) 163.56,79.29 163.56,75.12 v1(164.71,73.96) 165.35,73.33 165.35,67.99 165.83,67.5 165.83,66.3 165.55,66.02 165.55,62.25 166.13,61.67 166.13,59.24 166.24,59.14 166.24,55.34 168.96,52.62 168.96,51.98 169.8,51.14 169.8,46.85 v1(173.08,43.57) 173.27,43.76 177.73,43.76 180.97,40.52 180.97,32.94 177.78,29.76 177.78,27.66 175.96,25.84 175.96,20.01 175.79,19.84 175.79,16.55 174.27,15.04 173.13,15.04 170.57,12.48 v1(168.36,12.48)
  IN4 w0.084: v1(260.22,73.96) 259.88,73.62 259.88,71.39 258.48,70 256.69,70 255.93,70.76 248.18,70.76 247.59,71.35 238.61,71.35 236.14,68.87 236.14,64.89 234.79,63.55 234.79,60.79 230.76,56.76 230.76,56.46 228.62,54.31 228.62,52.15 221.73,45.26 214.92,45.26 213.85,44.2 194.24,44.2 v1(194.05,44.39)
  BOTTOM w0.102: v1(173.08,43.57) 173.66,44.14 173.98,44.14 175.14,45.3 193.15,45.3 v1(194.05,44.39) ; v1(164.01,79.74) 164.17,79.91 Q57.2 ; UH4.G10 167.68,23.17 v1(167.32,23.53) ; UH5.1 179.56,11.25 178.97,11.83 175.2,11.83 173.2,9.83 168.85,9.83 168.36,10.32 v1(168.36,12.48)
  BOTTOM w0.254: PR403.1 160.32,75.59 v1(159.91,75.59)
SIO_SLP_LAN#: length 219.2
  TOP w0.102: U46.A5 262.34,69.42 v1(262.09,69.17) ; v1(265.43,32.67) v2(265.43,33.52)
  IN2 w0.102: v1(166.05,25.51) 166.42,25.88 168.2,25.88 168.41,26.08 169.37,26.08 171.53,23.92 173.16,23.92 173.48,23.61 174.55,23.61
  IN2 w0.122: v1(303.04,68.4) 302.43,69.01 301.85,69.01 300.5,70.36 298.75,70.36 297.42,71.68 277.47,71.68 275.94,70.15 262.61,70.15 262.09,69.63 v1(262.09,69.17) ; v1(265.43,32.67) 264.27,33.83 262.93,33.83 260.61,36.16 254.88,36.16 254.39,35.67 239.1,35.67 229.73,26.3 200.73,26.3 199.93,25.5 194.05,25.5 193.48,26.07 189.48,26.07 188.25,24.84 186.23,24.84 184.4,23.01 179.91,23.01 179.75,22.84 175.88,22.84 175.11,23.61 174.55,23.61
  IN3 w0.122: v1(303.04,68.4) 301.97,67.33 301.97,57.69 303.35,56.32 303.35,53.88 304.2,53.03 304.2,49.25 v1(305.8,47.65) ; v1(262.09,69.17) 262.53,68.73 262.53,67.85 260.66,65.97 260.66,63.04 261.45,62.25 261.45,60.63 262.74,59.33 262.74,54.31 262.91,54.14 262.91,46.4 265.78,43.53 265.78,38.63 264.47,37.32 264.47,33.63 v1(265.43,32.67)
  BOTTOM w0.102: UH4.K14 166.41,25.15 v1(166.05,25.51) ; Q35.2 306.13,46.63 306.27,46.77 306.27,47.18 v1(305.8,47.65)
SIO_SLP_S3#: length 371.5
  TOP w0.102: v1(106.63,19.26) 107.53,18.36 v1(107.53,13.17) 106.91,12.56 106.91,10.79 105.78,9.66 105.11,9.66 RC82.1 ; U46.B65 260.32,72.81 v1(260.36,72.77) ; T60.1 167.87,20.29 v1(167.68,20.48)
  TOP w0.254: v1(126.17,7.81) 125.46,7.81 PR307.1 ; PR306.1 98.99,2.49 99.89,3.39 99.89,6.84 97.7,9.04 v1(97.7,10.57) ; v1(159.91,77.05) 160.39,77.05 162.51,74.93 168.22,74.93 170.31,72.83 170.31,71.02 171.43,69.9 v1(171.43,69.87)
  IN2 w0.102: v1(167.68,20.48) 168.38,19.78 168.79,19.78 168.97,19.61 173.68,19.61 174.55,18.73
  IN2 w0.122: 174.55,18.73 174.59,18.69 177.27,18.69 178.95,17.01 181.12,17.01 182.03,17.93 184.14,17.93 184.9,17.17 v1(185.24,17.17) 187.79,19.72 189.95,19.72 190.54,20.31 198.57,20.31 199.65,19.23 201.5,19.23 202.12,19.85 218.06,19.85 220.36,22.15 229.8,22.15 235.79,28.15 239,28.15 241.27,30.41 245.45,30.41 246.71,31.67 256.94,31.67 257.98,32.71 v1(261.32,32.71) ; v1(107.53,13.17) 108.26,13.9 111.07,13.9 111.61,13.36 114.85,13.36 115.66,14.17 124.22,14.17 126.03,12.37 127.15,12.37 128,11.52 128,9.64 v1(126.17,7.81)
  IN3 w0.122: v1(167.68,20.48) 166.28,19.08 162.92,19.08 162.12,18.29 162.12,18.2 161.75,17.83 161.18,17.83 159.03,15.68 157.05,15.68 156.51,15.14 154.67,15.14 154.51,15.29 146.89,15.29 146.45,14.84 138.29,14.84 137.56,15.58 132.79,15.58 130.79,17.58 109.05,17.58 107.36,19.26 v1(106.63,19.26) ; v1(260.36,72.77) 259.9,72.31 259.9,62.76 260.07,62.59 260.07,54.79 260.38,54.48 260.38,44.58 261.32,43.64 v1(261.32,32.71) ; v1(107.53,13.17) 106.99,12.63 100.04,12.63 97.98,10.57 v1(97.7,10.57) ; v1(171.43,69.87) 170.89,69.33 170.89,61.42 171.15,61.15 171.15,60.3 173.22,58.23 177.05,58.23 186.25,49.03 186.25,42.59 187.71,41.13 187.71,34.76 188.3,34.17 188.3,29.15 185.71,26.56 185.71,26.19 186.37,25.53 186.37,23.53 185.27,22.44 185.27,21.15 185.05,20.94 185.05,17.35 v1(185.24,17.17) 185.24,16.51 185.47,16.27 185.47,14.14 182.49,11.16 182.49,9.51 182.03,9.05 181.14,9.05 v1(180.58,8.49)
  BOTTOM w0.102: v1(167.68,20.48) 167.93,20.23 UH4.F4 ; R735.1 179.9,7.82 v1(180.58,8.49)
  BOTTOM w0.254: v1(159.91,77.05) 160.7,77.05 PR408.1
SIO_SLP_S4#: length 338.2
  TOP w0.102: v1(257.73,73.02) 257.77,73.06 U46.A61 ; v1(167.67,19.8) 168.01,19.45 T59.1
  TOP w0.254: v1(53.36,15.35) 53.36,15.97 48.2,21.13 48.2,47.5 43.25,52.45 39.27,52.45 38.51,53.21 38.51,56.89 39.79,58.18 41.03,58.18 45.16,62.3 45.16,64.76 44.68,65.24 PR232.1
  IN2 w0.102: 174.55,18.44 174.44,18.44 173.5,19.38 168.91,19.38 168.71,19.58 167.88,19.58 v1(167.67,19.8)
  IN2 w0.122: 174.55,18.44 177.17,18.44 178.85,16.76 181.22,16.76 182.13,17.68 184.04,17.68 184.99,16.73 186.08,16.73 187.8,18.45 189.38,18.45 190.74,19.81 195.89,19.81 197.04,18.66 197.53,18.66 197.86,18.98 201.6,18.98 202.22,19.6 218.17,19.6 220.47,21.9 229.93,21.9 235.81,27.78 239.26,27.78 241.38,29.91 245.57,29.91 247.07,31.4 256.25,31.4 v1(256.94,30.71)
  IN3 w0.122: v1(257.73,73.02) 257.73,70.27 257.4,69.94 257.4,67.98 256.46,67.03 256.46,63.4 258.1,61.75 258.1,46.82 258.18,46.73 258.18,40.74 257.73,40.29 257.73,38.05 256.79,37.1 256.79,30.86 v1(256.94,30.71) ; v1(167.67,19.8) 166.73,18.86 163.07,18.86 162.44,18.22 162.44,18.13 161.87,17.56 161.33,17.56 159.2,15.43 157.16,15.43 156.6,14.87 154.54,14.87 154.37,15.04 147,15.04 146.55,14.59 138.19,14.59 137.47,15.32 132.7,15.32 130.68,17.33 108.95,17.33 108.21,18.06 98.47,18.06 91.95,11.54 88.09,11.54 85.04,8.48 79.01,8.48 78.45,9.04 77.35,9.04 76.51,9.88 76.51,14.51 74.17,16.84 66.78,16.84 65.25,15.32 53.38,15.32 v1(53.36,15.35)
  BOTTOM w0.102: v1(167.67,19.8) 167.23,20.23 UH4.H4
SIO_SLP_S5#: length 164.9
  TOP w0.102: v1(168.59,23.53) 169.04,23.09 169.63,23.09 T58.1 ; U51.B16 292.23,61.85 v1(291.97,61.58)
  IN2 w0.102: v1(168.59,23.53) 169,23.12 171.18,23.12 171.3,23.25 172.97,23.25 173.32,22.9 173.32,22.5 173.53,22.3 174.55,22.3
  IN2 w0.122: 174.55,22.3 175.18,22.3 176.16,21.31 179.43,21.31 180.36,22.24 184.72,22.24 186.13,23.64 202.49,23.64 202.8,23.95 216.42,23.95 217.62,25.15 229.72,25.15 239.74,35.17 255.02,35.17 255.5,35.66 260.41,35.66 263.85,32.22 269.12,32.22 269.37,32.47 274.69,32.47 279.41,37.18 291.11,37.18 v1(291.62,37.7)
  IN3 w0.122: v1(291.62,37.7) 291.62,43.44 294.42,46.23 294.42,49.26 290.44,53.24 290.44,58.57 291.14,59.27 291.97,59.27 292.36,59.66 292.36,61.19 v1(291.97,61.58)
  BOTTOM w0.102: v1(168.59,23.53) 168.95,23.17 UH4.D10
SIO_SLP_SUS#: length 230.2
  TOP w0.102: v1(262.97,71.4) 262.59,71.02 U46.B6 ; v1(167.32,26.52) 167.62,26.81 T62.1
  IN2 w0.122: v1(167.32,26.52) 167.46,26.65 170.95,26.65 171.28,26.32 172.79,26.32 173.44,26.97 175.89,26.97 178.28,24.58 179.49,24.58 179.8,24.89 182.92,24.89 185.45,27.43 186.93,27.43 188.16,28.65 192.3,28.65 194.46,26.49 199.51,26.49 200.32,27.3 229.33,27.3 238.69,36.66 253.98,36.66 254.47,37.15 263.79,37.15 v1(264.94,36)
  IN3 w0.122: v1(262.97,71.4) 262.97,69.97 264.06,68.87 264.06,66.76 263.67,66.36 263.67,64.22 264.83,63.07 264.83,59.38 262.99,57.55 262.99,54.42 263.16,54.25 263.16,46.5 266.07,43.59 266.07,37.12 v1(264.94,36)
  IN4 w0.084: v1(219.37,12.86) 219.31,12.8 210.3,12.8 209.73,13.37 208.07,13.37 207.39,12.69 207.39,9.1 210.41,6.09 v1(210.41,4.05)
  BOTTOM w0.102: v1(264.94,36) 263.16,34.21 258.88,34.21 257.46,32.79 243.91,32.79 240.28,29.16 240.28,23.93 238.98,22.63 231.34,22.63 230.14,21.42 225.9,21.42 219.79,15.31 219.79,13.28 v1(219.37,12.86) ; v1(210.41,4.05) 210.6,3.86 R750.1 ; UH4.G16 167.68,26.16 v1(167.32,26.52)
SLICE_BAT_ON: length 2.4
  TOP w0.102: U46.A31 v2(270.79,78.56) 271.55,78.56 R791.2
SLICE_BAT_PRES#: length 11
  TOP w0.102: v2(276.13,79.28) 275.66,79.75 v1(275.66,79.88) 275.43,80.11 R760.2 ; v1(268,79.21) 268.41,78.81 U46.B33
  IN1 w0.084: v1(275.66,79.88) 274.1,78.32 271.42,78.32 270.52,79.21 v1(268,79.21)
SLP_ME_CSW_DEV#: length 171.1
  TOP w0.102: v1(164.68,22.44) 165.67,22.44 166.15,21.96 168.26,21.96 v2(168.36,22.06) 168.46,22.16 RH53.1 ; U46.B58 260.39,76.31 v1(260.91,76.83)
  IN2 w0.102: v1(164.68,22.44) 165.11,22.01 165.11,20.54 165.45,20.2 166.4,20.2 168.17,18.43 171.38,18.43 171.51,18.3
  IN2 w0.122: v1(265.11,30.02) 264.91,30.22 257.52,30.22 256.95,29.65 252.8,29.65 251.58,28.43 246.57,28.43 240.31,22.17 235.22,22.17 234.21,21.16 220.78,21.16 218.48,18.86 202.53,18.86 201.91,18.23 198.21,18.23 197.89,17.91 196.73,17.91 195.58,19.06 191.05,19.06 189.69,17.7 188.11,17.7 186.39,15.98 178.57,15.98 178.29,16.26 176.12,16.26 174.71,17.68
  IN2 w0.124: 174.71,17.68 172.14,17.68 171.51,18.3
  IN3 w0.122: v1(265.11,30.02) 265.11,30.39 266.99,32.26 266.99,43.4 263.41,46.97 263.41,54.35 263.24,54.52 263.24,57.44 265.09,59.29 265.09,63.26 263.92,64.43 263.92,66.11 264.95,67.14 264.95,69.52 263.58,70.89 263.58,72.76 262.01,74.33 262.01,76.25 261.43,76.83 v1(260.91,76.83)
  BOTTOM w0.102: v1(164.68,22.44) 164.38,22.13 UH4.P8
SM_RCOMP0: length 5.1
  BOTTOM w0.102: U1.BF44 109.45,56.99 v2(106.94,56.99) 106.56,56.99 106.42,57.13 106.11,57.13
  BOTTOM w0.508: 106.11,57.13 105.12,58.13 RC42.1
SM_RCOMP1: length 3.4
  TOP w0.102: v2(110.72,59.2) 110.55,59.03 110.55,58.47 RC43.1
  TOP w0.508: v5(110.06,57.08) 110.95,57.97 RC43.1
  BOTTOM w0.254: U1.BE43 110.06,56.7 v5(110.06,57.08)
SM_RCOMP2: length 8.4
  TOP w0.508: v1(104.07,57.34) 102.56,55.82 RC45.1
  BOTTOM w0.102: 105.67,56.8 105.86,56.61 109.06,56.61 109.15,56.53 U1.BG43
  BOTTOM w0.381: 105.67,56.8 v2(105.14,56.8) 104.6,56.8 v1(104.07,57.34)
SML1_SMBCLK: length 175.5
  TOP w0.102: RH298.1 169.83,26.23 168.4,26.23 168.01,25.85 v1(168.01,25.42) ; U51.B6 292.39,56.85 292.23,57.01 v1(291.91,57.01)
  IN1 w0.084: v3(291.57,21.91) 291.39,22.09 290.17,22.09 288.8,20.72 282.94,20.72 282.09,19.87 276.82,19.87 275.97,20.72 263.49,20.72 262.6,19.83 259.98,19.83 259.25,19.11 243.59,19.11 242.15,17.67 213.54,17.67 212.4,16.53 197.72,16.53 195.99,18.26 183.28,18.26 182.22,19.32 179.95,19.32 179.6,19.67 179.05,19.67 177.07,21.65 175.96,21.65 174.19,23.42 170.94,23.42 169.83,24.53 169.83,25.61 169.49,25.95 168.25,25.95 168.01,25.71 v1(168.01,25.42)
  IN3 w0.122: v1(291.91,57.01) 292.75,57.01 292.87,56.89 292.87,52.17 294.88,50.16 294.88,46.04 292.09,43.24 292.09,37.14 289.93,34.98 289.93,28.92 290.69,28.16 290.69,22.46 291.05,22.1 291.38,22.1 v3(291.57,21.91)
  BOTTOM w0.102: v1(168.01,25.42) 168.31,25.12 UH4.E14
SML1_SMBDATA: length 180.5
  TOP w0.102: v3(294.84,56.09) 294.34,56.6 U51.A5 ; RH299.1 169.83,26.46 168.3,26.46 167.78,25.94 165.98,25.94 v1(165.42,26.5)
  IN1 w0.084: v1(291.57,22.54) 291.33,22.3 290.08,22.3 288.72,20.93 282.85,20.93 282,20.08 276.91,20.08 276.06,20.93 263.41,20.93 262.52,20.05 259.89,20.05 259.17,19.32 243.51,19.32 242.06,17.88 213.45,17.88 212.31,16.74 197.81,16.74 196.08,18.47 183.37,18.47 182.31,19.53 180.04,19.53 179.69,19.89 179.14,19.89 177.16,21.86 176.05,21.86 174.28,23.63 171.03,23.63 170.04,24.62 170.04,25.7 169.57,26.16 168.17,26.16 168.03,26.03 165.89,26.03 v1(165.42,26.5)
  IN3 w0.122: v3(294.84,56.09) 294.84,55.95 294.51,55.61 293.34,55.61 293.12,55.39 293.12,52.27 295.13,50.26 295.13,45.93 292.34,43.14 292.34,37.03 290.18,34.88 290.18,29.02 290.94,28.27 290.94,22.57 291.16,22.35 291.38,22.35 v1(291.57,22.54)
  BOTTOM w0.102: v1(165.42,26.5) 165.06,26.15 UH4.M16
SNUB_1.5V:
  vias: v2(27.36,69.25)
SNUB_1.8VSP: length 3.6
  BOTTOM w0.102: PC305.1 102.88,2.97 104.3,2.97 v2(104.73,2.54)
  BOTTOM w0.508: PC305.1 PR301.2
SNUB_3V: length 0.7
  BOTTOM w0.102: v2(252.27,13.95) 252.93,13.95
SNUB_5V:
  vias: v2(232.81,12.8)
SP_TPM_LPC_EN: length 71.1
  TOP w0.102: v1(253.98,78.99) 254.44,78.99 255.07,78.35 R772.2 ; v1(260.91,77.85) 260.37,77.31 U46.B56
  IN1 w0.084: v1(260.91,77.85) 260.48,77.42 256.46,77.42 254.88,78.99 v1(253.98,78.99)
  IN2 w0.122: v3(253.9,43.01) 254.73,43.01 257.13,45.41 269.27,45.41 v1(270.86,43.82)
  IN3 w0.122: v3(253.9,43.01) 253.83,43.09 253.83,54.15 253.5,54.48 253.5,56.56 252.48,57.58 252.48,62.84 251.81,63.51 251.81,67.08 252.57,67.84 252.57,72.39 252.94,72.76 252.94,74.98 253.95,75.99 253.95,78.97 v1(253.98,78.99)
  BOTTOM w0.102: v1(270.86,43.82) 270.86,44.79 271.87,45.81 D91.1 271.32,46.37 R1662.1
SP_TPM_LPC_EN_R: length 6.1
  BOTTOM w0.102: U39.28 U37.28 268.46,46.98 v2(269.32,47.84) R1663.2 R1662.2 270.4,45.88 D91.2
SPI_CLK32: length 16.1
  BOTTOM w0.102: R897.1 214.2,15 214.31,15.1 215.25,15.1 215.35,15.2 215.35,15.4 215.25,15.5 214.31,15.5 214.2,15.6 214.2,15.81 214.31,15.91 215.25,15.91 215.35,16.01 215.35,16.21 215.25,16.32 214.31,16.32 214.2,16.42 214.2,16.62 214.31,16.72 215.25,16.72 215.35,16.82 215.35,17.03 215.25,17.13 214.31,17.13 214.2,17.23 214.2,18.02 214.05,18.17 210.8,18.17 210.54,17.91 U53.6
SPI_CLK64: length 13.8
  BOTTOM w0.102: R899.1 209.28,41.44 209.4,41.56 v2(209.86,41.56) 210.37,41.56 210.47,41.46 210.47,41.24 210.37,41.14 209.91,41.14 209.81,41.03 209.81,40.83 209.91,40.73 210.37,40.73 210.47,40.63 210.47,40.43 210.37,40.32 209.91,40.32 209.81,40.22 209.81,40.02 209.91,39.92 210.37,39.92 210.47,39.82 210.47,39.61 210.34,39.48 209.38,39.48 209.28,39.38 209.28,39.18 209.38,39.08 210.01,39.08 210.11,38.97 210.11,38.77 210.01,38.67 209.38,38.67 209.28,38.57 209.28,38.36 209.38,38.26 210.01,38.26 210.11,38.16 210.11,37.96 210.01,37.86 209.38,37.86 209.24,37.71 U52.6
